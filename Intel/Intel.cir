.title spice transient solver
Vg GND 0 318.15
I_0_0_0 GND Node0_0_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.33988439306358326A 0.024s 0.33988439306358326A 0.024000000001s 0.33988439306358326A 0.036000000000000004s 0.33988439306358326A 0.036000000001s 0.33988439306358326A 0.048s 0.33988439306358326A 0.048000000001s 0.33988439306358326A 0.06s 0.33988439306358326A 0.060000000000999996s 0.33988439306358326A 0.07200000000000001s 0.33988439306358326A 0.07200000000100001s 0.33988439306358326A 0.084s 0.33988439306358326A 0.08400000000100001s 0.33988439306358326A 0.096s 0.33988439306358326A 0.09600000000100001s 0.33988439306358326A 0.108s 0.33988439306358326A 0.108000000001s 0.33988439306358326A 0.12s 0.33988439306358326A 0.120000000001s 0.33988439306358326A 0.132s 0.33988439306358326A 0.132000000001s 0.33988439306358326A 0.14400000000000002s 0.33988439306358326A 0.14400000000100002s 0.33988439306358326A 0.156s 0.33988439306358326A 0.156000000001s 0.33988439306358326A 0.168s 0.33988439306358326A 0.16800000000100002s 0.33988439306358326A 0.18s 0.33988439306358326A 0.180000000001s 0.33988439306358326A 0.192s 0.33988439306358326A 0.192000000001s 0.33988439306358326A 0.20400000000000001s 0.33988439306358326A 0.20400000000100002s 0.33988439306358326A 0.216s 0.33988439306358326A 0.216000000001s 0.33988439306358326A 0.228s 0.33988439306358326A 0.228000000001s 0.33988439306358326A 0.24s 0.33988439306358326A 0.240000000001s 0.33988439306358326A 0.252s 0.33988439306358326A 0.252000000001s 0.33988439306358326A 0.264s 0.33988439306358326A 0.264000000001s 0.33988439306358326A 0.276s 0.33988439306358326A 0.276000000001s 0.33988439306358326A 0.28800000000000003s 0.33988439306358326A 0.288000000001s 0.33988439306358326A 0.3s 0.33988439306358326A 0.30000000000099997s 0.33988439306358326A 0.312s 0.33988439306358326A 0.312000000001s 0.33988439306358326A 0.324s 0.33988439306358326A 0.324000000001s 0.33988439306358326A 0.336s 0.33988439306358326A 0.336000000001s 0.33988439306358326A 0.34800000000000003s 0.33988439306358326A 0.348000000001s 0.33988439306358326A 0.36s 0.33988439306358326A 0.36000000000099996s 0.33988439306358326A 0.372s 0.33988439306358326A 0.372000000001s 0.33988439306358326A 0.384s 0.33988439306358326A 0.384000000001s 0.33988439306358326A 0.396s 0.33988439306358326A 0.396000000001s 0.33988439306358326A 0.40800000000000003s 0.33988439306358326A 0.408000000001s 0.33988439306358326A 0.42s 0.33988439306358326A 0.42000000000099996s 0.33988439306358326A 0.432s 0.33988439306358326A 0.432000000001s 0.33988439306358326A 0.444s 0.33988439306358326A 0.444000000001s 0.33988439306358326A 0.456s 0.33988439306358326A 0.456000000001s 0.33988439306358326A 0.468s 0.33988439306358326A 0.468000000001s 0.33988439306358326A 0.48s 0.33988439306358326A 0.48000000000099996s 0.33988439306358326A 0.492s 0.33988439306358326A 0.49200000000099997s 0.33988439306358326A 0.504s 0.33988439306358326A 0.504000000001s 0.33988439306358326A 0.516s 0.33988439306358326A 0.516000000001s 0.33988439306358326A 0.528s 0.33988439306358326A 0.528000000001s 0.33988439306358326A 0.54s 0.33988439306358326A 0.540000000001s 0.33988439306358326A 0.552s 0.33988439306358326A 0.552000000001s 0.33988439306358326A 0.5640000000000001s 0.33988439306358326A 0.564000000001s 0.33988439306358326A 0.5760000000000001s 0.33988439306358326A 0.576000000001s 0.33988439306358326A 0.588s 0.33988439306358326A 0.588000000001s 0.33988439306358326A 0.6s 0.33988439306358326A 0.600000000001s 0.33988439306358326A 0.612s 0.33988439306358326A 0.612000000001s 0.33988439306358326A 0.624s 0.33988439306358326A 0.624000000001s 0.33988439306358326A 0.636s 0.33988439306358326A 0.636000000001s 0.33988439306358326A 0.648s 0.33988439306358326A 0.648000000001s 0.33988439306358326A 0.66s 0.33988439306358326A 0.660000000001s 0.33988439306358326A 0.672s 0.33988439306358326A 0.672000000001s 0.33988439306358326A 0.684s 0.33988439306358326A 0.684000000001s 0.33988439306358326A 0.6960000000000001s 0.33988439306358326A 0.696000000001s 0.33988439306358326A 0.708s 0.33988439306358326A 0.7080000000009999s 0.33988439306358326A 0.72s 0.33988439306358326A 0.720000000001s 0.33988439306358326A 0.732s 0.33988439306358326A 0.732000000001s 0.33988439306358326A 0.744s 0.33988439306358326A 0.744000000001s 0.33988439306358326A 0.756s 0.33988439306358326A 0.756000000001s 0.33988439306358326A 0.768s 0.33988439306358326A 0.768000000001s 0.33988439306358326A 0.78s 0.33988439306358326A 0.780000000001s 0.33988439306358326A 0.792s 0.33988439306358326A 0.792000000001s 0.33988439306358326A 0.804s 0.33988439306358326A 0.804000000001s 0.33988439306358326A 0.8160000000000001s 0.33988439306358326A 0.816000000001s 0.33988439306358326A 0.8280000000000001s 0.33988439306358326A 0.828000000001s 0.33988439306358326A 0.84s 0.33988439306358326A 0.840000000001s 0.33988439306358326A 0.852s 0.33988439306358326A 0.852000000001s 0.33988439306358326A 0.864s 0.33988439306358326A 0.864000000001s 0.33988439306358326A 0.876s 0.33988439306358326A 0.876000000001s 0.33988439306358326A 0.888s 0.33988439306358326A 0.888000000001s 0.33988439306358326A 0.9s 0.33988439306358326A 0.900000000001s 0.33988439306358326A 0.912s 0.33988439306358326A 0.912000000001s 0.33988439306358326A 0.924s 0.33988439306358326A 0.924000000001s 0.33988439306358326A 0.936s 0.33988439306358326A 0.936000000001s 0.33988439306358326A 0.9480000000000001s 0.33988439306358326A 0.948000000001s 0.33988439306358326A 0.96s 0.33988439306358326A 0.9600000000009999s 0.33988439306358326A 0.972s 0.33988439306358326A 0.972000000001s 0.33988439306358326A 0.984s 0.33988439306358326A 0.984000000001s 0.33988439306358326A 0.996s 0.33988439306358326A 0.996000000001s 0.33988439306358326A 1.008s 0.33988439306358326A 1.008000000001s 0.33988439306358326A 1.02s 0.33988439306358326A 1.020000000001s 0.33988439306358326A 1.032s 0.33988439306358326A 1.0320000000010001s 0.33988439306358326A 1.044s 0.33988439306358326A 1.0440000000010001s 0.33988439306358326A 1.056s 0.33988439306358326A 1.0560000000010001s 0.33988439306358326A 1.068s 0.33988439306358326A 1.0680000000010001s 0.33988439306358326A 1.08s 0.33988439306358326A 1.0800000000010002s 0.33988439306358326A 1.092s 0.33988439306358326A 1.0920000000010002s 0.33988439306358326A 1.104s 0.33988439306358326A 1.1040000000010002s 0.33988439306358326A 1.116s 0.33988439306358326A 1.1160000000010002s 0.33988439306358326A 1.1280000000000001s 0.33988439306358326A 1.1280000000010002s 0.33988439306358326A 1.1400000000000001s 0.33988439306358326A 1.1400000000010002s 0.33988439306358326A 1.1520000000000001s 0.33988439306358326A 1.1520000000010002s 0.33988439306358326A 1.164s 0.33988439306358326A 1.164000000001s 0.33988439306358326A 1.176s 0.33988439306358326A 1.176000000001s 0.33988439306358326A 1.188s 0.33988439306358326A 1.188000000001s 0.33988439306358326A 1.2s 0.33988439306358326A 1.200000000001s 0.33988439306358326A 1.212s 0.33988439306358326A 1.212000000001s 0.33988439306358326A 1.224s 0.33988439306358326A 1.224000000001s 0.33988439306358326A 1.236s 0.33988439306358326A 1.236000000001s 0.33988439306358326A 1.248s 0.33988439306358326A 1.248000000001s 0.33988439306358326A 1.26s 0.33988439306358326A 1.260000000001s 0.33988439306358326A 1.272s 0.33988439306358326A 1.272000000001s 0.33988439306358326A 1.284s 0.33988439306358326A 1.2840000000010001s 0.33988439306358326A 1.296s 0.33988439306358326A 1.2960000000010001s 0.33988439306358326A 1.308s 0.33988439306358326A 1.3080000000010001s 0.33988439306358326A 1.32s 0.33988439306358326A 1.3200000000010002s 0.33988439306358326A 1.332s 0.33988439306358326A 1.3320000000010002s 0.33988439306358326A 1.344s 0.33988439306358326A 1.3440000000010002s 0.33988439306358326A 1.356s 0.33988439306358326A 1.3560000000010002s 0.33988439306358326A 1.368s 0.33988439306358326A 1.3680000000010002s 0.33988439306358326A 1.3800000000000001s 0.33988439306358326A 1.3800000000010002s 0.33988439306358326A 1.3920000000000001s 0.33988439306358326A 1.3920000000010002s 0.33988439306358326A 1.4040000000000001s 0.33988439306358326A 1.4040000000010002s 0.33988439306358326A 1.416s 0.33988439306358326A 1.416000000001s 0.33988439306358326A 1.428s 0.33988439306358326A 1.428000000001s 0.33988439306358326A 1.44s 0.33988439306358326A 1.440000000001s 0.33988439306358326A 1.452s 0.33988439306358326A 1.452000000001s 0.33988439306358326A 1.464s 0.33988439306358326A 1.464000000001s 0.33988439306358326A 1.476s 0.33988439306358326A 1.476000000001s 0.33988439306358326A 1.488s 0.33988439306358326A 1.488000000001s 0.33988439306358326A 1.5s 0.33988439306358326A 1.500000000001s 0.33988439306358326A 1.512s 0.33988439306358326A 1.512000000001s 0.33988439306358326A 1.524s 0.33988439306358326A 1.524000000001s 0.33988439306358326A 1.536s 0.33988439306358326A 1.5360000000010001s 0.33988439306358326A 1.548s 0.33988439306358326A 1.5480000000010001s 0.33988439306358326A 1.56s 0.33988439306358326A 1.5600000000010001s 0.33988439306358326A 1.572s 0.33988439306358326A 1.5720000000010002s 0.33988439306358326A 1.584s 0.33988439306358326A 1.5840000000010002s 0.33988439306358326A 1.596s 0.33988439306358326A 1.5960000000010002s 0.33988439306358326A 1.608s 0.33988439306358326A 1.6080000000010002s 0.33988439306358326A 1.62s 0.33988439306358326A 1.6200000000010002s 0.33988439306358326A 1.6320000000000001s 0.33988439306358326A 1.6320000000010002s 0.33988439306358326A 1.6440000000000001s 0.33988439306358326A 1.6440000000010002s 0.33988439306358326A 1.6560000000000001s 0.33988439306358326A 1.6560000000010002s 0.33988439306358326A 1.668s 0.33988439306358326A 1.668000000001s 0.33988439306358326A 1.68s 0.33988439306358326A 1.680000000001s 0.33988439306358326A 1.692s 0.33988439306358326A 1.692000000001s 0.33988439306358326A 1.704s 0.33988439306358326A 1.704000000001s 0.33988439306358326A 1.716s 0.33988439306358326A 1.716000000001s 0.33988439306358326A 1.728s 0.33988439306358326A 1.728000000001s 0.33988439306358326A 1.74s 0.33988439306358326A 1.740000000001s 0.33988439306358326A 1.752s 0.33988439306358326A 1.752000000001s 0.33988439306358326A 1.764s 0.33988439306358326A 1.764000000001s 0.33988439306358326A 1.776s 0.33988439306358326A 1.7760000000010001s 0.33988439306358326A 1.788s 0.33988439306358326A 1.7880000000010001s 0.33988439306358326A 1.8s 0.33988439306358326A 1.8000000000010001s 0.33988439306358326A 1.812s 0.33988439306358326A 1.8120000000010001s 0.33988439306358326A 1.824s 0.33988439306358326A 1.8240000000010002s 0.33988439306358326A 1.836s 0.33988439306358326A 1.8360000000010002s 0.33988439306358326A 1.848s 0.33988439306358326A 1.8480000000010002s 0.33988439306358326A 1.86s 0.33988439306358326A 1.8600000000010002s 0.33988439306358326A 1.872s 0.33988439306358326A 1.8720000000010002s 0.33988439306358326A)
R_0_0_0_1 Node0_0_0 Node0_0_1 9.88780952380954
R_0_0_0_2 Node0_0_0 Node0_1_0 13.020765027322419
R_0_0_0_3 Node0_0_0 Node1_0_0 2.595018540202971
C_0_0_0 Node0_0_0 GND 0.0009924144753599982
I_0_0_1 GND Node0_0_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_1_1 Node0_0_1 Node0_0_2 9.88780952380954
R_0_0_1_2 Node0_0_1 Node0_1_1 13.020765027322419
R_0_0_1_3 Node0_0_1 Node1_0_1 2.5950185402029704
C_0_0_1 Node0_0_1 GND 0.0009924144753599984
I_0_0_2 GND Node0_0_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_2_1 Node0_0_2 Node0_0_3 9.88780952380954
R_0_0_2_2 Node0_0_2 Node0_1_2 13.020765027322419
R_0_0_2_3 Node0_0_2 Node1_0_2 2.5950185402029704
C_0_0_2 Node0_0_2 GND 0.0009924144753599984
I_0_0_3 GND Node0_0_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_3_1 Node0_0_3 Node0_0_4 9.88780952380954
R_0_0_3_2 Node0_0_3 Node0_1_3 13.020765027322419
R_0_0_3_3 Node0_0_3 Node1_0_3 2.5950185402029704
C_0_0_3 Node0_0_3 GND 0.0009924144753599984
I_0_0_4 GND Node0_0_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_4_1 Node0_0_4 Node0_0_5 9.88780952380954
R_0_0_4_2 Node0_0_4 Node0_1_4 13.020765027322419
R_0_0_4_3 Node0_0_4 Node1_0_4 2.5950185402029704
C_0_0_4 Node0_0_4 GND 0.0009924144753599984
I_0_0_5 GND Node0_0_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_5_1 Node0_0_5 Node0_0_6 9.88780952380954
R_0_0_5_2 Node0_0_5 Node0_1_5 13.020765027322419
R_0_0_5_3 Node0_0_5 Node1_0_5 2.5950185402029704
C_0_0_5 Node0_0_5 GND 0.0009924144753599984
I_0_0_6 GND Node0_0_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_6_1 Node0_0_6 Node0_0_7 9.88780952380954
R_0_0_6_2 Node0_0_6 Node0_1_6 13.020765027322419
R_0_0_6_3 Node0_0_6 Node1_0_6 2.5950185402029704
C_0_0_6 Node0_0_6 GND 0.0009924144753599984
I_0_0_7 GND Node0_0_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_7_1 Node0_0_7 Node0_0_8 9.88780952380954
R_0_0_7_2 Node0_0_7 Node0_1_7 13.020765027322419
R_0_0_7_3 Node0_0_7 Node1_0_7 2.5950185402029704
C_0_0_7 Node0_0_7 GND 0.0009924144753599984
I_0_0_8 GND Node0_0_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635833A 0.024s 0.3398843930635833A 0.024000000001s 0.3398843930635833A 0.036000000000000004s 0.3398843930635833A 0.036000000001s 0.3398843930635833A 0.048s 0.3398843930635833A 0.048000000001s 0.3398843930635833A 0.06s 0.3398843930635833A 0.060000000000999996s 0.3398843930635833A 0.07200000000000001s 0.3398843930635833A 0.07200000000100001s 0.3398843930635833A 0.084s 0.3398843930635833A 0.08400000000100001s 0.3398843930635833A 0.096s 0.3398843930635833A 0.09600000000100001s 0.3398843930635833A 0.108s 0.3398843930635833A 0.108000000001s 0.3398843930635833A 0.12s 0.3398843930635833A 0.120000000001s 0.3398843930635833A 0.132s 0.3398843930635833A 0.132000000001s 0.3398843930635833A 0.14400000000000002s 0.3398843930635833A 0.14400000000100002s 0.3398843930635833A 0.156s 0.3398843930635833A 0.156000000001s 0.3398843930635833A 0.168s 0.3398843930635833A 0.16800000000100002s 0.3398843930635833A 0.18s 0.3398843930635833A 0.180000000001s 0.3398843930635833A 0.192s 0.3398843930635833A 0.192000000001s 0.3398843930635833A 0.20400000000000001s 0.3398843930635833A 0.20400000000100002s 0.3398843930635833A 0.216s 0.3398843930635833A 0.216000000001s 0.3398843930635833A 0.228s 0.3398843930635833A 0.228000000001s 0.3398843930635833A 0.24s 0.3398843930635833A 0.240000000001s 0.3398843930635833A 0.252s 0.3398843930635833A 0.252000000001s 0.3398843930635833A 0.264s 0.3398843930635833A 0.264000000001s 0.3398843930635833A 0.276s 0.3398843930635833A 0.276000000001s 0.3398843930635833A 0.28800000000000003s 0.3398843930635833A 0.288000000001s 0.3398843930635833A 0.3s 0.3398843930635833A 0.30000000000099997s 0.3398843930635833A 0.312s 0.3398843930635833A 0.312000000001s 0.3398843930635833A 0.324s 0.3398843930635833A 0.324000000001s 0.3398843930635833A 0.336s 0.3398843930635833A 0.336000000001s 0.3398843930635833A 0.34800000000000003s 0.3398843930635833A 0.348000000001s 0.3398843930635833A 0.36s 0.3398843930635833A 0.36000000000099996s 0.3398843930635833A 0.372s 0.3398843930635833A 0.372000000001s 0.3398843930635833A 0.384s 0.3398843930635833A 0.384000000001s 0.3398843930635833A 0.396s 0.3398843930635833A 0.396000000001s 0.3398843930635833A 0.40800000000000003s 0.3398843930635833A 0.408000000001s 0.3398843930635833A 0.42s 0.3398843930635833A 0.42000000000099996s 0.3398843930635833A 0.432s 0.3398843930635833A 0.432000000001s 0.3398843930635833A 0.444s 0.3398843930635833A 0.444000000001s 0.3398843930635833A 0.456s 0.3398843930635833A 0.456000000001s 0.3398843930635833A 0.468s 0.3398843930635833A 0.468000000001s 0.3398843930635833A 0.48s 0.3398843930635833A 0.48000000000099996s 0.3398843930635833A 0.492s 0.3398843930635833A 0.49200000000099997s 0.3398843930635833A 0.504s 0.3398843930635833A 0.504000000001s 0.3398843930635833A 0.516s 0.3398843930635833A 0.516000000001s 0.3398843930635833A 0.528s 0.3398843930635833A 0.528000000001s 0.3398843930635833A 0.54s 0.3398843930635833A 0.540000000001s 0.3398843930635833A 0.552s 0.3398843930635833A 0.552000000001s 0.3398843930635833A 0.5640000000000001s 0.3398843930635833A 0.564000000001s 0.3398843930635833A 0.5760000000000001s 0.3398843930635833A 0.576000000001s 0.3398843930635833A 0.588s 0.3398843930635833A 0.588000000001s 0.3398843930635833A 0.6s 0.3398843930635833A 0.600000000001s 0.3398843930635833A 0.612s 0.3398843930635833A 0.612000000001s 0.3398843930635833A 0.624s 0.3398843930635833A 0.624000000001s 0.3398843930635833A 0.636s 0.3398843930635833A 0.636000000001s 0.3398843930635833A 0.648s 0.3398843930635833A 0.648000000001s 0.3398843930635833A 0.66s 0.3398843930635833A 0.660000000001s 0.3398843930635833A 0.672s 0.3398843930635833A 0.672000000001s 0.3398843930635833A 0.684s 0.3398843930635833A 0.684000000001s 0.3398843930635833A 0.6960000000000001s 0.3398843930635833A 0.696000000001s 0.3398843930635833A 0.708s 0.3398843930635833A 0.7080000000009999s 0.3398843930635833A 0.72s 0.3398843930635833A 0.720000000001s 0.3398843930635833A 0.732s 0.3398843930635833A 0.732000000001s 0.3398843930635833A 0.744s 0.3398843930635833A 0.744000000001s 0.3398843930635833A 0.756s 0.3398843930635833A 0.756000000001s 0.3398843930635833A 0.768s 0.3398843930635833A 0.768000000001s 0.3398843930635833A 0.78s 0.3398843930635833A 0.780000000001s 0.3398843930635833A 0.792s 0.3398843930635833A 0.792000000001s 0.3398843930635833A 0.804s 0.3398843930635833A 0.804000000001s 0.3398843930635833A 0.8160000000000001s 0.3398843930635833A 0.816000000001s 0.3398843930635833A 0.8280000000000001s 0.3398843930635833A 0.828000000001s 0.3398843930635833A 0.84s 0.3398843930635833A 0.840000000001s 0.3398843930635833A 0.852s 0.3398843930635833A 0.852000000001s 0.3398843930635833A 0.864s 0.3398843930635833A 0.864000000001s 0.3398843930635833A 0.876s 0.3398843930635833A 0.876000000001s 0.3398843930635833A 0.888s 0.3398843930635833A 0.888000000001s 0.3398843930635833A 0.9s 0.3398843930635833A 0.900000000001s 0.3398843930635833A 0.912s 0.3398843930635833A 0.912000000001s 0.3398843930635833A 0.924s 0.3398843930635833A 0.924000000001s 0.3398843930635833A 0.936s 0.3398843930635833A 0.936000000001s 0.3398843930635833A 0.9480000000000001s 0.3398843930635833A 0.948000000001s 0.3398843930635833A 0.96s 0.3398843930635833A 0.9600000000009999s 0.3398843930635833A 0.972s 0.3398843930635833A 0.972000000001s 0.3398843930635833A 0.984s 0.3398843930635833A 0.984000000001s 0.3398843930635833A 0.996s 0.3398843930635833A 0.996000000001s 0.3398843930635833A 1.008s 0.3398843930635833A 1.008000000001s 0.3398843930635833A 1.02s 0.3398843930635833A 1.020000000001s 0.3398843930635833A 1.032s 0.3398843930635833A 1.0320000000010001s 0.3398843930635833A 1.044s 0.3398843930635833A 1.0440000000010001s 0.3398843930635833A 1.056s 0.3398843930635833A 1.0560000000010001s 0.3398843930635833A 1.068s 0.3398843930635833A 1.0680000000010001s 0.3398843930635833A 1.08s 0.3398843930635833A 1.0800000000010002s 0.3398843930635833A 1.092s 0.3398843930635833A 1.0920000000010002s 0.3398843930635833A 1.104s 0.3398843930635833A 1.1040000000010002s 0.3398843930635833A 1.116s 0.3398843930635833A 1.1160000000010002s 0.3398843930635833A 1.1280000000000001s 0.3398843930635833A 1.1280000000010002s 0.3398843930635833A 1.1400000000000001s 0.3398843930635833A 1.1400000000010002s 0.3398843930635833A 1.1520000000000001s 0.3398843930635833A 1.1520000000010002s 0.3398843930635833A 1.164s 0.3398843930635833A 1.164000000001s 0.3398843930635833A 1.176s 0.3398843930635833A 1.176000000001s 0.3398843930635833A 1.188s 0.3398843930635833A 1.188000000001s 0.3398843930635833A 1.2s 0.3398843930635833A 1.200000000001s 0.3398843930635833A 1.212s 0.3398843930635833A 1.212000000001s 0.3398843930635833A 1.224s 0.3398843930635833A 1.224000000001s 0.3398843930635833A 1.236s 0.3398843930635833A 1.236000000001s 0.3398843930635833A 1.248s 0.3398843930635833A 1.248000000001s 0.3398843930635833A 1.26s 0.3398843930635833A 1.260000000001s 0.3398843930635833A 1.272s 0.3398843930635833A 1.272000000001s 0.3398843930635833A 1.284s 0.3398843930635833A 1.2840000000010001s 0.3398843930635833A 1.296s 0.3398843930635833A 1.2960000000010001s 0.3398843930635833A 1.308s 0.3398843930635833A 1.3080000000010001s 0.3398843930635833A 1.32s 0.3398843930635833A 1.3200000000010002s 0.3398843930635833A 1.332s 0.3398843930635833A 1.3320000000010002s 0.3398843930635833A 1.344s 0.3398843930635833A 1.3440000000010002s 0.3398843930635833A 1.356s 0.3398843930635833A 1.3560000000010002s 0.3398843930635833A 1.368s 0.3398843930635833A 1.3680000000010002s 0.3398843930635833A 1.3800000000000001s 0.3398843930635833A 1.3800000000010002s 0.3398843930635833A 1.3920000000000001s 0.3398843930635833A 1.3920000000010002s 0.3398843930635833A 1.4040000000000001s 0.3398843930635833A 1.4040000000010002s 0.3398843930635833A 1.416s 0.3398843930635833A 1.416000000001s 0.3398843930635833A 1.428s 0.3398843930635833A 1.428000000001s 0.3398843930635833A 1.44s 0.3398843930635833A 1.440000000001s 0.3398843930635833A 1.452s 0.3398843930635833A 1.452000000001s 0.3398843930635833A 1.464s 0.3398843930635833A 1.464000000001s 0.3398843930635833A 1.476s 0.3398843930635833A 1.476000000001s 0.3398843930635833A 1.488s 0.3398843930635833A 1.488000000001s 0.3398843930635833A 1.5s 0.3398843930635833A 1.500000000001s 0.3398843930635833A 1.512s 0.3398843930635833A 1.512000000001s 0.3398843930635833A 1.524s 0.3398843930635833A 1.524000000001s 0.3398843930635833A 1.536s 0.3398843930635833A 1.5360000000010001s 0.3398843930635833A 1.548s 0.3398843930635833A 1.5480000000010001s 0.3398843930635833A 1.56s 0.3398843930635833A 1.5600000000010001s 0.3398843930635833A 1.572s 0.3398843930635833A 1.5720000000010002s 0.3398843930635833A 1.584s 0.3398843930635833A 1.5840000000010002s 0.3398843930635833A 1.596s 0.3398843930635833A 1.5960000000010002s 0.3398843930635833A 1.608s 0.3398843930635833A 1.6080000000010002s 0.3398843930635833A 1.62s 0.3398843930635833A 1.6200000000010002s 0.3398843930635833A 1.6320000000000001s 0.3398843930635833A 1.6320000000010002s 0.3398843930635833A 1.6440000000000001s 0.3398843930635833A 1.6440000000010002s 0.3398843930635833A 1.6560000000000001s 0.3398843930635833A 1.6560000000010002s 0.3398843930635833A 1.668s 0.3398843930635833A 1.668000000001s 0.3398843930635833A 1.68s 0.3398843930635833A 1.680000000001s 0.3398843930635833A 1.692s 0.3398843930635833A 1.692000000001s 0.3398843930635833A 1.704s 0.3398843930635833A 1.704000000001s 0.3398843930635833A 1.716s 0.3398843930635833A 1.716000000001s 0.3398843930635833A 1.728s 0.3398843930635833A 1.728000000001s 0.3398843930635833A 1.74s 0.3398843930635833A 1.740000000001s 0.3398843930635833A 1.752s 0.3398843930635833A 1.752000000001s 0.3398843930635833A 1.764s 0.3398843930635833A 1.764000000001s 0.3398843930635833A 1.776s 0.3398843930635833A 1.7760000000010001s 0.3398843930635833A 1.788s 0.3398843930635833A 1.7880000000010001s 0.3398843930635833A 1.8s 0.3398843930635833A 1.8000000000010001s 0.3398843930635833A 1.812s 0.3398843930635833A 1.8120000000010001s 0.3398843930635833A 1.824s 0.3398843930635833A 1.8240000000010002s 0.3398843930635833A 1.836s 0.3398843930635833A 1.8360000000010002s 0.3398843930635833A 1.848s 0.3398843930635833A 1.8480000000010002s 0.3398843930635833A 1.86s 0.3398843930635833A 1.8600000000010002s 0.3398843930635833A 1.872s 0.3398843930635833A 1.8720000000010002s 0.3398843930635833A)
R_0_0_8_1 Node0_0_8 Node0_0_9 9.88780952380954
R_0_0_8_2 Node0_0_8 Node0_1_8 13.020765027322419
R_0_0_8_3 Node0_0_8 Node1_0_8 2.5950185402029704
C_0_0_8 Node0_0_8 GND 0.0009924144753599984
I_0_0_9 GND Node0_0_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.33988439306358326A 0.024s 0.33988439306358326A 0.024000000001s 0.33988439306358326A 0.036000000000000004s 0.33988439306358326A 0.036000000001s 0.33988439306358326A 0.048s 0.33988439306358326A 0.048000000001s 0.33988439306358326A 0.06s 0.33988439306358326A 0.060000000000999996s 0.33988439306358326A 0.07200000000000001s 0.33988439306358326A 0.07200000000100001s 0.33988439306358326A 0.084s 0.33988439306358326A 0.08400000000100001s 0.33988439306358326A 0.096s 0.33988439306358326A 0.09600000000100001s 0.33988439306358326A 0.108s 0.33988439306358326A 0.108000000001s 0.33988439306358326A 0.12s 0.33988439306358326A 0.120000000001s 0.33988439306358326A 0.132s 0.33988439306358326A 0.132000000001s 0.33988439306358326A 0.14400000000000002s 0.33988439306358326A 0.14400000000100002s 0.33988439306358326A 0.156s 0.33988439306358326A 0.156000000001s 0.33988439306358326A 0.168s 0.33988439306358326A 0.16800000000100002s 0.33988439306358326A 0.18s 0.33988439306358326A 0.180000000001s 0.33988439306358326A 0.192s 0.33988439306358326A 0.192000000001s 0.33988439306358326A 0.20400000000000001s 0.33988439306358326A 0.20400000000100002s 0.33988439306358326A 0.216s 0.33988439306358326A 0.216000000001s 0.33988439306358326A 0.228s 0.33988439306358326A 0.228000000001s 0.33988439306358326A 0.24s 0.33988439306358326A 0.240000000001s 0.33988439306358326A 0.252s 0.33988439306358326A 0.252000000001s 0.33988439306358326A 0.264s 0.33988439306358326A 0.264000000001s 0.33988439306358326A 0.276s 0.33988439306358326A 0.276000000001s 0.33988439306358326A 0.28800000000000003s 0.33988439306358326A 0.288000000001s 0.33988439306358326A 0.3s 0.33988439306358326A 0.30000000000099997s 0.33988439306358326A 0.312s 0.33988439306358326A 0.312000000001s 0.33988439306358326A 0.324s 0.33988439306358326A 0.324000000001s 0.33988439306358326A 0.336s 0.33988439306358326A 0.336000000001s 0.33988439306358326A 0.34800000000000003s 0.33988439306358326A 0.348000000001s 0.33988439306358326A 0.36s 0.33988439306358326A 0.36000000000099996s 0.33988439306358326A 0.372s 0.33988439306358326A 0.372000000001s 0.33988439306358326A 0.384s 0.33988439306358326A 0.384000000001s 0.33988439306358326A 0.396s 0.33988439306358326A 0.396000000001s 0.33988439306358326A 0.40800000000000003s 0.33988439306358326A 0.408000000001s 0.33988439306358326A 0.42s 0.33988439306358326A 0.42000000000099996s 0.33988439306358326A 0.432s 0.33988439306358326A 0.432000000001s 0.33988439306358326A 0.444s 0.33988439306358326A 0.444000000001s 0.33988439306358326A 0.456s 0.33988439306358326A 0.456000000001s 0.33988439306358326A 0.468s 0.33988439306358326A 0.468000000001s 0.33988439306358326A 0.48s 0.33988439306358326A 0.48000000000099996s 0.33988439306358326A 0.492s 0.33988439306358326A 0.49200000000099997s 0.33988439306358326A 0.504s 0.33988439306358326A 0.504000000001s 0.33988439306358326A 0.516s 0.33988439306358326A 0.516000000001s 0.33988439306358326A 0.528s 0.33988439306358326A 0.528000000001s 0.33988439306358326A 0.54s 0.33988439306358326A 0.540000000001s 0.33988439306358326A 0.552s 0.33988439306358326A 0.552000000001s 0.33988439306358326A 0.5640000000000001s 0.33988439306358326A 0.564000000001s 0.33988439306358326A 0.5760000000000001s 0.33988439306358326A 0.576000000001s 0.33988439306358326A 0.588s 0.33988439306358326A 0.588000000001s 0.33988439306358326A 0.6s 0.33988439306358326A 0.600000000001s 0.33988439306358326A 0.612s 0.33988439306358326A 0.612000000001s 0.33988439306358326A 0.624s 0.33988439306358326A 0.624000000001s 0.33988439306358326A 0.636s 0.33988439306358326A 0.636000000001s 0.33988439306358326A 0.648s 0.33988439306358326A 0.648000000001s 0.33988439306358326A 0.66s 0.33988439306358326A 0.660000000001s 0.33988439306358326A 0.672s 0.33988439306358326A 0.672000000001s 0.33988439306358326A 0.684s 0.33988439306358326A 0.684000000001s 0.33988439306358326A 0.6960000000000001s 0.33988439306358326A 0.696000000001s 0.33988439306358326A 0.708s 0.33988439306358326A 0.7080000000009999s 0.33988439306358326A 0.72s 0.33988439306358326A 0.720000000001s 0.33988439306358326A 0.732s 0.33988439306358326A 0.732000000001s 0.33988439306358326A 0.744s 0.33988439306358326A 0.744000000001s 0.33988439306358326A 0.756s 0.33988439306358326A 0.756000000001s 0.33988439306358326A 0.768s 0.33988439306358326A 0.768000000001s 0.33988439306358326A 0.78s 0.33988439306358326A 0.780000000001s 0.33988439306358326A 0.792s 0.33988439306358326A 0.792000000001s 0.33988439306358326A 0.804s 0.33988439306358326A 0.804000000001s 0.33988439306358326A 0.8160000000000001s 0.33988439306358326A 0.816000000001s 0.33988439306358326A 0.8280000000000001s 0.33988439306358326A 0.828000000001s 0.33988439306358326A 0.84s 0.33988439306358326A 0.840000000001s 0.33988439306358326A 0.852s 0.33988439306358326A 0.852000000001s 0.33988439306358326A 0.864s 0.33988439306358326A 0.864000000001s 0.33988439306358326A 0.876s 0.33988439306358326A 0.876000000001s 0.33988439306358326A 0.888s 0.33988439306358326A 0.888000000001s 0.33988439306358326A 0.9s 0.33988439306358326A 0.900000000001s 0.33988439306358326A 0.912s 0.33988439306358326A 0.912000000001s 0.33988439306358326A 0.924s 0.33988439306358326A 0.924000000001s 0.33988439306358326A 0.936s 0.33988439306358326A 0.936000000001s 0.33988439306358326A 0.9480000000000001s 0.33988439306358326A 0.948000000001s 0.33988439306358326A 0.96s 0.33988439306358326A 0.9600000000009999s 0.33988439306358326A 0.972s 0.33988439306358326A 0.972000000001s 0.33988439306358326A 0.984s 0.33988439306358326A 0.984000000001s 0.33988439306358326A 0.996s 0.33988439306358326A 0.996000000001s 0.33988439306358326A 1.008s 0.33988439306358326A 1.008000000001s 0.33988439306358326A 1.02s 0.33988439306358326A 1.020000000001s 0.33988439306358326A 1.032s 0.33988439306358326A 1.0320000000010001s 0.33988439306358326A 1.044s 0.33988439306358326A 1.0440000000010001s 0.33988439306358326A 1.056s 0.33988439306358326A 1.0560000000010001s 0.33988439306358326A 1.068s 0.33988439306358326A 1.0680000000010001s 0.33988439306358326A 1.08s 0.33988439306358326A 1.0800000000010002s 0.33988439306358326A 1.092s 0.33988439306358326A 1.0920000000010002s 0.33988439306358326A 1.104s 0.33988439306358326A 1.1040000000010002s 0.33988439306358326A 1.116s 0.33988439306358326A 1.1160000000010002s 0.33988439306358326A 1.1280000000000001s 0.33988439306358326A 1.1280000000010002s 0.33988439306358326A 1.1400000000000001s 0.33988439306358326A 1.1400000000010002s 0.33988439306358326A 1.1520000000000001s 0.33988439306358326A 1.1520000000010002s 0.33988439306358326A 1.164s 0.33988439306358326A 1.164000000001s 0.33988439306358326A 1.176s 0.33988439306358326A 1.176000000001s 0.33988439306358326A 1.188s 0.33988439306358326A 1.188000000001s 0.33988439306358326A 1.2s 0.33988439306358326A 1.200000000001s 0.33988439306358326A 1.212s 0.33988439306358326A 1.212000000001s 0.33988439306358326A 1.224s 0.33988439306358326A 1.224000000001s 0.33988439306358326A 1.236s 0.33988439306358326A 1.236000000001s 0.33988439306358326A 1.248s 0.33988439306358326A 1.248000000001s 0.33988439306358326A 1.26s 0.33988439306358326A 1.260000000001s 0.33988439306358326A 1.272s 0.33988439306358326A 1.272000000001s 0.33988439306358326A 1.284s 0.33988439306358326A 1.2840000000010001s 0.33988439306358326A 1.296s 0.33988439306358326A 1.2960000000010001s 0.33988439306358326A 1.308s 0.33988439306358326A 1.3080000000010001s 0.33988439306358326A 1.32s 0.33988439306358326A 1.3200000000010002s 0.33988439306358326A 1.332s 0.33988439306358326A 1.3320000000010002s 0.33988439306358326A 1.344s 0.33988439306358326A 1.3440000000010002s 0.33988439306358326A 1.356s 0.33988439306358326A 1.3560000000010002s 0.33988439306358326A 1.368s 0.33988439306358326A 1.3680000000010002s 0.33988439306358326A 1.3800000000000001s 0.33988439306358326A 1.3800000000010002s 0.33988439306358326A 1.3920000000000001s 0.33988439306358326A 1.3920000000010002s 0.33988439306358326A 1.4040000000000001s 0.33988439306358326A 1.4040000000010002s 0.33988439306358326A 1.416s 0.33988439306358326A 1.416000000001s 0.33988439306358326A 1.428s 0.33988439306358326A 1.428000000001s 0.33988439306358326A 1.44s 0.33988439306358326A 1.440000000001s 0.33988439306358326A 1.452s 0.33988439306358326A 1.452000000001s 0.33988439306358326A 1.464s 0.33988439306358326A 1.464000000001s 0.33988439306358326A 1.476s 0.33988439306358326A 1.476000000001s 0.33988439306358326A 1.488s 0.33988439306358326A 1.488000000001s 0.33988439306358326A 1.5s 0.33988439306358326A 1.500000000001s 0.33988439306358326A 1.512s 0.33988439306358326A 1.512000000001s 0.33988439306358326A 1.524s 0.33988439306358326A 1.524000000001s 0.33988439306358326A 1.536s 0.33988439306358326A 1.5360000000010001s 0.33988439306358326A 1.548s 0.33988439306358326A 1.5480000000010001s 0.33988439306358326A 1.56s 0.33988439306358326A 1.5600000000010001s 0.33988439306358326A 1.572s 0.33988439306358326A 1.5720000000010002s 0.33988439306358326A 1.584s 0.33988439306358326A 1.5840000000010002s 0.33988439306358326A 1.596s 0.33988439306358326A 1.5960000000010002s 0.33988439306358326A 1.608s 0.33988439306358326A 1.6080000000010002s 0.33988439306358326A 1.62s 0.33988439306358326A 1.6200000000010002s 0.33988439306358326A 1.6320000000000001s 0.33988439306358326A 1.6320000000010002s 0.33988439306358326A 1.6440000000000001s 0.33988439306358326A 1.6440000000010002s 0.33988439306358326A 1.6560000000000001s 0.33988439306358326A 1.6560000000010002s 0.33988439306358326A 1.668s 0.33988439306358326A 1.668000000001s 0.33988439306358326A 1.68s 0.33988439306358326A 1.680000000001s 0.33988439306358326A 1.692s 0.33988439306358326A 1.692000000001s 0.33988439306358326A 1.704s 0.33988439306358326A 1.704000000001s 0.33988439306358326A 1.716s 0.33988439306358326A 1.716000000001s 0.33988439306358326A 1.728s 0.33988439306358326A 1.728000000001s 0.33988439306358326A 1.74s 0.33988439306358326A 1.740000000001s 0.33988439306358326A 1.752s 0.33988439306358326A 1.752000000001s 0.33988439306358326A 1.764s 0.33988439306358326A 1.764000000001s 0.33988439306358326A 1.776s 0.33988439306358326A 1.7760000000010001s 0.33988439306358326A 1.788s 0.33988439306358326A 1.7880000000010001s 0.33988439306358326A 1.8s 0.33988439306358326A 1.8000000000010001s 0.33988439306358326A 1.812s 0.33988439306358326A 1.8120000000010001s 0.33988439306358326A 1.824s 0.33988439306358326A 1.8240000000010002s 0.33988439306358326A 1.836s 0.33988439306358326A 1.8360000000010002s 0.33988439306358326A 1.848s 0.33988439306358326A 1.8480000000010002s 0.33988439306358326A 1.86s 0.33988439306358326A 1.8600000000010002s 0.33988439306358326A 1.872s 0.33988439306358326A 1.8720000000010002s 0.33988439306358326A)
R_0_0_9_2 Node0_0_9 Node0_1_9 13.020765027322419
R_0_0_9_3 Node0_0_9 Node1_0_9 2.595018540202971
C_0_0_9 Node0_0_9 GND 0.0009924144753599982
I_0_1_0 GND Node0_1_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_0_1 Node0_1_0 Node0_1_1 9.887809523809523
R_0_1_0_2 Node0_1_0 Node0_2_0 13.020765027322398
R_0_1_0_3 Node0_1_0 Node1_1_0 2.595018540202966
C_0_1_0 Node0_1_0 GND 0.0009924144753600001
I_0_1_1 GND Node0_1_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_1_1 Node0_1_1 Node0_1_2 9.887809523809523
R_0_1_1_2 Node0_1_1 Node0_2_1 13.0207650273224
R_0_1_1_3 Node0_1_1 Node1_1_1 2.595018540202966
C_0_1_1 Node0_1_1 GND 0.0009924144753600001
I_0_1_2 GND Node0_1_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_2_1 Node0_1_2 Node0_1_3 9.887809523809523
R_0_1_2_2 Node0_1_2 Node0_2_2 13.0207650273224
R_0_1_2_3 Node0_1_2 Node1_1_2 2.595018540202966
C_0_1_2 Node0_1_2 GND 0.0009924144753600001
I_0_1_3 GND Node0_1_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_3_1 Node0_1_3 Node0_1_4 9.887809523809523
R_0_1_3_2 Node0_1_3 Node0_2_3 13.0207650273224
R_0_1_3_3 Node0_1_3 Node1_1_3 2.595018540202966
C_0_1_3 Node0_1_3 GND 0.0009924144753600001
I_0_1_4 GND Node0_1_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_4_1 Node0_1_4 Node0_1_5 9.887809523809523
R_0_1_4_2 Node0_1_4 Node0_2_4 13.020765027322401
R_0_1_4_3 Node0_1_4 Node1_1_4 2.595018540202966
C_0_1_4 Node0_1_4 GND 0.0009924144753600001
I_0_1_5 GND Node0_1_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_5_1 Node0_1_5 Node0_1_6 9.887809523809523
R_0_1_5_2 Node0_1_5 Node0_2_5 13.02076502732239
R_0_1_5_3 Node0_1_5 Node1_1_5 2.595018540202966
C_0_1_5 Node0_1_5 GND 0.0009924144753600001
I_0_1_6 GND Node0_1_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_6_1 Node0_1_6 Node0_1_7 9.887809523809523
R_0_1_6_2 Node0_1_6 Node0_2_6 13.0207650273224
R_0_1_6_3 Node0_1_6 Node1_1_6 2.595018540202966
C_0_1_6 Node0_1_6 GND 0.0009924144753600001
I_0_1_7 GND Node0_1_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_7_1 Node0_1_7 Node0_1_8 9.887809523809523
R_0_1_7_2 Node0_1_7 Node0_2_7 13.0207650273224
R_0_1_7_3 Node0_1_7 Node1_1_7 2.595018540202966
C_0_1_7 Node0_1_7 GND 0.0009924144753600001
I_0_1_8 GND Node0_1_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_8_1 Node0_1_8 Node0_1_9 9.887809523809523
R_0_1_8_2 Node0_1_8 Node0_2_8 13.020765027322405
R_0_1_8_3 Node0_1_8 Node1_1_8 2.595018540202966
C_0_1_8 Node0_1_8 GND 0.0009924144753600001
I_0_1_9 GND Node0_1_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.3398843930635839A 0.024s 0.3398843930635839A 0.024000000001s 0.3398843930635839A 0.036000000000000004s 0.3398843930635839A 0.036000000001s 0.3398843930635839A 0.048s 0.3398843930635839A 0.048000000001s 0.3398843930635839A 0.06s 0.3398843930635839A 0.060000000000999996s 0.3398843930635839A 0.07200000000000001s 0.3398843930635839A 0.07200000000100001s 0.3398843930635839A 0.084s 0.3398843930635839A 0.08400000000100001s 0.3398843930635839A 0.096s 0.3398843930635839A 0.09600000000100001s 0.3398843930635839A 0.108s 0.3398843930635839A 0.108000000001s 0.3398843930635839A 0.12s 0.3398843930635839A 0.120000000001s 0.3398843930635839A 0.132s 0.3398843930635839A 0.132000000001s 0.3398843930635839A 0.14400000000000002s 0.3398843930635839A 0.14400000000100002s 0.3398843930635839A 0.156s 0.3398843930635839A 0.156000000001s 0.3398843930635839A 0.168s 0.3398843930635839A 0.16800000000100002s 0.3398843930635839A 0.18s 0.3398843930635839A 0.180000000001s 0.3398843930635839A 0.192s 0.3398843930635839A 0.192000000001s 0.3398843930635839A 0.20400000000000001s 0.3398843930635839A 0.20400000000100002s 0.3398843930635839A 0.216s 0.3398843930635839A 0.216000000001s 0.3398843930635839A 0.228s 0.3398843930635839A 0.228000000001s 0.3398843930635839A 0.24s 0.3398843930635839A 0.240000000001s 0.3398843930635839A 0.252s 0.3398843930635839A 0.252000000001s 0.3398843930635839A 0.264s 0.3398843930635839A 0.264000000001s 0.3398843930635839A 0.276s 0.3398843930635839A 0.276000000001s 0.3398843930635839A 0.28800000000000003s 0.3398843930635839A 0.288000000001s 0.3398843930635839A 0.3s 0.3398843930635839A 0.30000000000099997s 0.3398843930635839A 0.312s 0.3398843930635839A 0.312000000001s 0.3398843930635839A 0.324s 0.3398843930635839A 0.324000000001s 0.3398843930635839A 0.336s 0.3398843930635839A 0.336000000001s 0.3398843930635839A 0.34800000000000003s 0.3398843930635839A 0.348000000001s 0.3398843930635839A 0.36s 0.3398843930635839A 0.36000000000099996s 0.3398843930635839A 0.372s 0.3398843930635839A 0.372000000001s 0.3398843930635839A 0.384s 0.3398843930635839A 0.384000000001s 0.3398843930635839A 0.396s 0.3398843930635839A 0.396000000001s 0.3398843930635839A 0.40800000000000003s 0.3398843930635839A 0.408000000001s 0.3398843930635839A 0.42s 0.3398843930635839A 0.42000000000099996s 0.3398843930635839A 0.432s 0.3398843930635839A 0.432000000001s 0.3398843930635839A 0.444s 0.3398843930635839A 0.444000000001s 0.3398843930635839A 0.456s 0.3398843930635839A 0.456000000001s 0.3398843930635839A 0.468s 0.3398843930635839A 0.468000000001s 0.3398843930635839A 0.48s 0.3398843930635839A 0.48000000000099996s 0.3398843930635839A 0.492s 0.3398843930635839A 0.49200000000099997s 0.3398843930635839A 0.504s 0.3398843930635839A 0.504000000001s 0.3398843930635839A 0.516s 0.3398843930635839A 0.516000000001s 0.3398843930635839A 0.528s 0.3398843930635839A 0.528000000001s 0.3398843930635839A 0.54s 0.3398843930635839A 0.540000000001s 0.3398843930635839A 0.552s 0.3398843930635839A 0.552000000001s 0.3398843930635839A 0.5640000000000001s 0.3398843930635839A 0.564000000001s 0.3398843930635839A 0.5760000000000001s 0.3398843930635839A 0.576000000001s 0.3398843930635839A 0.588s 0.3398843930635839A 0.588000000001s 0.3398843930635839A 0.6s 0.3398843930635839A 0.600000000001s 0.3398843930635839A 0.612s 0.3398843930635839A 0.612000000001s 0.3398843930635839A 0.624s 0.3398843930635839A 0.624000000001s 0.3398843930635839A 0.636s 0.3398843930635839A 0.636000000001s 0.3398843930635839A 0.648s 0.3398843930635839A 0.648000000001s 0.3398843930635839A 0.66s 0.3398843930635839A 0.660000000001s 0.3398843930635839A 0.672s 0.3398843930635839A 0.672000000001s 0.3398843930635839A 0.684s 0.3398843930635839A 0.684000000001s 0.3398843930635839A 0.6960000000000001s 0.3398843930635839A 0.696000000001s 0.3398843930635839A 0.708s 0.3398843930635839A 0.7080000000009999s 0.3398843930635839A 0.72s 0.3398843930635839A 0.720000000001s 0.3398843930635839A 0.732s 0.3398843930635839A 0.732000000001s 0.3398843930635839A 0.744s 0.3398843930635839A 0.744000000001s 0.3398843930635839A 0.756s 0.3398843930635839A 0.756000000001s 0.3398843930635839A 0.768s 0.3398843930635839A 0.768000000001s 0.3398843930635839A 0.78s 0.3398843930635839A 0.780000000001s 0.3398843930635839A 0.792s 0.3398843930635839A 0.792000000001s 0.3398843930635839A 0.804s 0.3398843930635839A 0.804000000001s 0.3398843930635839A 0.8160000000000001s 0.3398843930635839A 0.816000000001s 0.3398843930635839A 0.8280000000000001s 0.3398843930635839A 0.828000000001s 0.3398843930635839A 0.84s 0.3398843930635839A 0.840000000001s 0.3398843930635839A 0.852s 0.3398843930635839A 0.852000000001s 0.3398843930635839A 0.864s 0.3398843930635839A 0.864000000001s 0.3398843930635839A 0.876s 0.3398843930635839A 0.876000000001s 0.3398843930635839A 0.888s 0.3398843930635839A 0.888000000001s 0.3398843930635839A 0.9s 0.3398843930635839A 0.900000000001s 0.3398843930635839A 0.912s 0.3398843930635839A 0.912000000001s 0.3398843930635839A 0.924s 0.3398843930635839A 0.924000000001s 0.3398843930635839A 0.936s 0.3398843930635839A 0.936000000001s 0.3398843930635839A 0.9480000000000001s 0.3398843930635839A 0.948000000001s 0.3398843930635839A 0.96s 0.3398843930635839A 0.9600000000009999s 0.3398843930635839A 0.972s 0.3398843930635839A 0.972000000001s 0.3398843930635839A 0.984s 0.3398843930635839A 0.984000000001s 0.3398843930635839A 0.996s 0.3398843930635839A 0.996000000001s 0.3398843930635839A 1.008s 0.3398843930635839A 1.008000000001s 0.3398843930635839A 1.02s 0.3398843930635839A 1.020000000001s 0.3398843930635839A 1.032s 0.3398843930635839A 1.0320000000010001s 0.3398843930635839A 1.044s 0.3398843930635839A 1.0440000000010001s 0.3398843930635839A 1.056s 0.3398843930635839A 1.0560000000010001s 0.3398843930635839A 1.068s 0.3398843930635839A 1.0680000000010001s 0.3398843930635839A 1.08s 0.3398843930635839A 1.0800000000010002s 0.3398843930635839A 1.092s 0.3398843930635839A 1.0920000000010002s 0.3398843930635839A 1.104s 0.3398843930635839A 1.1040000000010002s 0.3398843930635839A 1.116s 0.3398843930635839A 1.1160000000010002s 0.3398843930635839A 1.1280000000000001s 0.3398843930635839A 1.1280000000010002s 0.3398843930635839A 1.1400000000000001s 0.3398843930635839A 1.1400000000010002s 0.3398843930635839A 1.1520000000000001s 0.3398843930635839A 1.1520000000010002s 0.3398843930635839A 1.164s 0.3398843930635839A 1.164000000001s 0.3398843930635839A 1.176s 0.3398843930635839A 1.176000000001s 0.3398843930635839A 1.188s 0.3398843930635839A 1.188000000001s 0.3398843930635839A 1.2s 0.3398843930635839A 1.200000000001s 0.3398843930635839A 1.212s 0.3398843930635839A 1.212000000001s 0.3398843930635839A 1.224s 0.3398843930635839A 1.224000000001s 0.3398843930635839A 1.236s 0.3398843930635839A 1.236000000001s 0.3398843930635839A 1.248s 0.3398843930635839A 1.248000000001s 0.3398843930635839A 1.26s 0.3398843930635839A 1.260000000001s 0.3398843930635839A 1.272s 0.3398843930635839A 1.272000000001s 0.3398843930635839A 1.284s 0.3398843930635839A 1.2840000000010001s 0.3398843930635839A 1.296s 0.3398843930635839A 1.2960000000010001s 0.3398843930635839A 1.308s 0.3398843930635839A 1.3080000000010001s 0.3398843930635839A 1.32s 0.3398843930635839A 1.3200000000010002s 0.3398843930635839A 1.332s 0.3398843930635839A 1.3320000000010002s 0.3398843930635839A 1.344s 0.3398843930635839A 1.3440000000010002s 0.3398843930635839A 1.356s 0.3398843930635839A 1.3560000000010002s 0.3398843930635839A 1.368s 0.3398843930635839A 1.3680000000010002s 0.3398843930635839A 1.3800000000000001s 0.3398843930635839A 1.3800000000010002s 0.3398843930635839A 1.3920000000000001s 0.3398843930635839A 1.3920000000010002s 0.3398843930635839A 1.4040000000000001s 0.3398843930635839A 1.4040000000010002s 0.3398843930635839A 1.416s 0.3398843930635839A 1.416000000001s 0.3398843930635839A 1.428s 0.3398843930635839A 1.428000000001s 0.3398843930635839A 1.44s 0.3398843930635839A 1.440000000001s 0.3398843930635839A 1.452s 0.3398843930635839A 1.452000000001s 0.3398843930635839A 1.464s 0.3398843930635839A 1.464000000001s 0.3398843930635839A 1.476s 0.3398843930635839A 1.476000000001s 0.3398843930635839A 1.488s 0.3398843930635839A 1.488000000001s 0.3398843930635839A 1.5s 0.3398843930635839A 1.500000000001s 0.3398843930635839A 1.512s 0.3398843930635839A 1.512000000001s 0.3398843930635839A 1.524s 0.3398843930635839A 1.524000000001s 0.3398843930635839A 1.536s 0.3398843930635839A 1.5360000000010001s 0.3398843930635839A 1.548s 0.3398843930635839A 1.5480000000010001s 0.3398843930635839A 1.56s 0.3398843930635839A 1.5600000000010001s 0.3398843930635839A 1.572s 0.3398843930635839A 1.5720000000010002s 0.3398843930635839A 1.584s 0.3398843930635839A 1.5840000000010002s 0.3398843930635839A 1.596s 0.3398843930635839A 1.5960000000010002s 0.3398843930635839A 1.608s 0.3398843930635839A 1.6080000000010002s 0.3398843930635839A 1.62s 0.3398843930635839A 1.6200000000010002s 0.3398843930635839A 1.6320000000000001s 0.3398843930635839A 1.6320000000010002s 0.3398843930635839A 1.6440000000000001s 0.3398843930635839A 1.6440000000010002s 0.3398843930635839A 1.6560000000000001s 0.3398843930635839A 1.6560000000010002s 0.3398843930635839A 1.668s 0.3398843930635839A 1.668000000001s 0.3398843930635839A 1.68s 0.3398843930635839A 1.680000000001s 0.3398843930635839A 1.692s 0.3398843930635839A 1.692000000001s 0.3398843930635839A 1.704s 0.3398843930635839A 1.704000000001s 0.3398843930635839A 1.716s 0.3398843930635839A 1.716000000001s 0.3398843930635839A 1.728s 0.3398843930635839A 1.728000000001s 0.3398843930635839A 1.74s 0.3398843930635839A 1.740000000001s 0.3398843930635839A 1.752s 0.3398843930635839A 1.752000000001s 0.3398843930635839A 1.764s 0.3398843930635839A 1.764000000001s 0.3398843930635839A 1.776s 0.3398843930635839A 1.7760000000010001s 0.3398843930635839A 1.788s 0.3398843930635839A 1.7880000000010001s 0.3398843930635839A 1.8s 0.3398843930635839A 1.8000000000010001s 0.3398843930635839A 1.812s 0.3398843930635839A 1.8120000000010001s 0.3398843930635839A 1.824s 0.3398843930635839A 1.8240000000010002s 0.3398843930635839A 1.836s 0.3398843930635839A 1.8360000000010002s 0.3398843930635839A 1.848s 0.3398843930635839A 1.8480000000010002s 0.3398843930635839A 1.86s 0.3398843930635839A 1.8600000000010002s 0.3398843930635839A 1.872s 0.3398843930635839A 1.8720000000010002s 0.3398843930635839A)
R_0_1_9_2 Node0_1_9 Node0_2_9 13.020765027322398
R_0_1_9_3 Node0_1_9 Node1_1_9 2.595018540202966
C_0_1_9 Node0_1_9 GND 0.0009924144753600001
I_0_2_0 GND Node0_2_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.2211635815884327A 0.024s 0.2211635815884327A 0.024000000001s 0.2211861893337217A 0.036000000000000004s 0.2211861893337217A 0.036000000001s 0.22119087379409794A 0.048s 0.22119087379409794A 0.048000000001s 0.22119551087194328A 0.06s 0.22119551087194328A 0.060000000000999996s 0.22119507230267307A 0.07200000000000001s 0.22119507230267307A 0.07200000000100001s 0.2211646676859171A 0.084s 0.2211646676859171A 0.08400000000100001s 0.2211830763609135A 0.096s 0.2211830763609135A 0.09600000000100001s 0.22118986937695978A 0.108s 0.22118986937695978A 0.108000000001s 0.2211945298156484A 0.12s 0.2211945298156484A 0.120000000001s 0.2211965048807849A 0.132s 0.2211965048807849A 0.132000000001s 0.22116572196375212A 0.14400000000000002s 0.22116572196375212A 0.14400000000100002s 0.22117948308652222A 0.156s 0.22117948308652222A 0.156000000001s 0.2211888008909739A 0.168s 0.2211888008909739A 0.16800000000100002s 0.22119293417422392A 0.18s 0.22119293417422392A 0.180000000001s 0.22119551087194328A 0.192s 0.22119551087194328A 0.192000000001s 0.2211774768956227A 0.20400000000000001s 0.2211774768956227A 0.20400000000100002s 0.2211676945507228A 0.216s 0.2211676945507228A 0.216000000001s 0.2211852591624322A 0.228s 0.2211852591624322A 0.228000000001s 0.22119138221460277A 0.24s 0.22119138221460277A 0.240000000001s 0.22119442583180957A 0.252s 0.22119442583180957A 0.252000000001s 0.22119250740102317A 0.264s 0.22119250740102317A 0.264000000001s 0.2211656680388633A 0.276s 0.2211656680388633A 0.276000000001s 0.22118105275676858A 0.28800000000000003s 0.22118105275676858A 0.288000000001s 0.22118986937695978A 0.3s 0.22118986937695978A 0.30000000000099997s 0.22119442583180957A 0.312s 0.22119442583180957A 0.312000000001s 0.2211965048807849A 0.324s 0.2211965048807849A 0.324000000001s 0.22116619179095418A 0.336s 0.22116619179095418A 0.336000000001s 0.2211774768956227A 0.34800000000000003s 0.2211774768956227A 0.348000000001s 0.22118831378269535A 0.36s 0.22118831378269535A 0.36000000000099996s 0.22119241223945474A 0.372s 0.22119241223945474A 0.372000000001s 0.22119595086202853A 0.384s 0.22119595086202853A 0.384000000001s 0.22117551815333858A 0.396s 0.22117551815333858A 0.396000000001s 0.22116560198748303A 0.40800000000000003s 0.22116560198748303A 0.408000000001s 0.22118572284378296A 0.42s 0.22118572284378296A 0.42000000000099996s 0.22119138221460277A 0.432s 0.22119138221460277A 0.432000000001s 0.22119442583180957A 0.444s 0.22119442583180957A 0.444000000001s 0.2211945298156484A 0.456s 0.2211945298156484A 0.456000000001s 0.22116515644630622A 0.468s 0.22116515644630622A 0.468000000001s 0.22118153771730345A 0.48s 0.22118153771730345A 0.48000000000099996s 0.22118986937695978A 0.492s 0.22118986937695978A 0.49200000000099997s 0.22119442583180957A 0.504s 0.22119442583180957A 0.504000000001s 0.2211965048807849A 0.516s 0.2211965048807849A 0.516000000001s 0.2211667596874393A 0.528s 0.2211667596874393A 0.528000000001s 0.2211765434861965A 0.54s 0.2211765434861965A 0.540000000001s 0.2211888008909739A 0.552s 0.2211888008909739A 0.552000000001s 0.22119198781225094A 0.5640000000000001s 0.22119198781225094A 0.564000000001s 0.22119496557633064A 0.5760000000000001s 0.22119496557633064A 0.576000000001s 0.22117801158468547A 0.588s 0.22117801158468547A 0.588000000001s 0.22116779714678877A 0.6s 0.22116779714678877A 0.600000000001s 0.22118467028414296A 0.612s 0.22118467028414296A 0.612000000001s 0.22119078636440695A 0.624s 0.22119078636440695A 0.624000000001s 0.2211945298156484A 0.636s 0.2211945298156484A 0.636000000001s 0.22119096224809756A 0.648s 0.22119096224809756A 0.648000000001s 0.2211662204715936A 0.66s 0.2211662204715936A 0.660000000001s 0.22117999956932657A 0.672s 0.22117999956932657A 0.672000000001s 0.22115275043087948A 0.684s 0.22115275043087948A 0.684000000001s 0.22114977681425807A 0.6960000000000001s 0.22114977681425807A 0.696000000001s 0.22114977599778507A 0.708s 0.22114977599778507A 0.7080000000009999s 0.22114977560127855A 0.72s 0.22114977560127855A 0.720000000001s 0.22114977558211404A 0.732s 0.22114977558211404A 0.732000000001s 0.22114977679443276A 0.744s 0.22114977679443276A 0.744000000001s 0.22114977573146485A 0.756s 0.22114977573146485A 0.756000000001s 0.2211497756158171A 0.768s 0.2211497756158171A 0.768000000001s 0.22114977605131345A 0.78s 0.22114977605131345A 0.780000000001s 0.22114977581373996A 0.792s 0.22114977581373996A 0.792000000001s 0.22114977627996554A 0.804s 0.22114977627996554A 0.804000000001s 0.22114976433685826A 0.8160000000000001s 0.22114976433685826A 0.816000000001s 0.22114978874646143A 0.8280000000000001s 0.22114978874646143A 0.828000000001s 0.22114978902533772A 0.84s 0.22114978902533772A 0.840000000001s 0.22114978872828822A 0.852s 0.22114978872828822A 0.852000000001s 0.22114978872234062A 0.864s 0.22114978872234062A 0.864000000001s 0.22114978872234062A 0.876s 0.22114978872234062A 0.876000000001s 0.22114978864997814A 0.888s 0.22114978864997814A 0.888000000001s 0.22114978878875546A 0.9s 0.22114978878875546A 0.900000000001s 0.22114978887367398A 0.912s 0.22114978887367398A 0.912000000001s 0.22114978876463467A 0.924s 0.22114978876463467A 0.924000000001s 0.221149769416107A 0.936s 0.221149769416107A 0.936000000001s 0.22114978736595783A 0.9480000000000001s 0.22114978736595783A 0.948000000001s 0.22114978712408884A 0.96s 0.22114978712408884A 0.9600000000009999s 0.2211497878582868A 0.972s 0.2211497878582868A 0.972000000001s 0.22114978749019654A 0.984s 0.22114978749019654A 0.984000000001s 0.22114978749614417A 0.996s 0.22114978749614417A 0.996000000001s 0.22114978734811508A 1.008s 0.22114978734811508A 1.008000000001s 0.22114978800763757A 1.02s 0.22114978800763757A 1.020000000001s 0.2211497878883552A 1.032s 0.2211497878883552A 1.0320000000010001s 0.22114978690667111A 1.044s 0.22114978690667111A 1.0440000000010001s 0.2211496997776642A 1.056s 0.2211496997776642A 1.0560000000010001s 0.2211496949928216A 1.068s 0.2211496949928216A 1.0680000000010001s 0.2211501354858093A 1.08s 0.2211501354858093A 1.0800000000010002s 0.22115013564143812A 1.092s 0.22115013564143812A 1.0920000000010002s 0.2211501355247991A 1.104s 0.2211501355247991A 1.1040000000010002s 0.22115013529218194A 1.116s 0.22115013529218194A 1.1160000000010002s 0.2211501355558588A 1.1280000000000001s 0.2211501355558588A 1.1280000000010002s 0.2211501360861863A 1.1400000000000001s 0.2211501360861863A 1.1400000000010002s 0.22115013583605675A 1.1520000000000001s 0.22115013583605675A 1.1520000000010002s 0.22115013510648474A 1.164s 0.22115013510648474A 1.164000000001s 0.22115013564903785A 1.176s 0.22115013564903785A 1.176000000001s 0.22114978510983568A 1.188s 0.22114978510983568A 1.188000000001s 0.22114978902533772A 1.2s 0.22114978902533772A 1.200000000001s 0.221149788922246A 1.212s 0.221149788922246A 1.212000000001s 0.22114978884955316A 1.224s 0.22114978884955316A 1.224000000001s 0.22114978889184717A 1.236s 0.22114978889184717A 1.236000000001s 0.22114978857166814A 1.248s 0.22114978857166814A 1.248000000001s 0.2211497887405138A 1.26s 0.2211497887405138A 1.260000000001s 0.22114978866187335A 1.272s 0.22114978866187335A 1.272000000001s 0.22114978858951093A 1.284s 0.22114978858951093A 1.2840000000010001s 0.2211497888555007A 1.296s 0.2211497888555007A 1.2960000000010001s 0.22114976940751602A 1.308s 0.22114976940751602A 1.3080000000010001s 0.22114977535147942A 1.32s 0.22114977535147942A 1.3200000000010002s 0.22114977562077343A 1.332s 0.22114977562077343A 1.3320000000010002s 0.2211497759009714A 1.344s 0.2211497759009714A 1.3440000000010002s 0.22114977593467444A 1.356s 0.22114977593467444A 1.3560000000010002s 0.22114977633845026A 1.368s 0.22114977633845026A 1.3680000000010002s 0.2211497755338724A 1.3800000000000001s 0.2211497755338724A 1.3800000000010002s 0.22114977614350123A 1.3920000000000001s 0.22114977614350123A 1.3920000000010002s 0.22114977617290882A 1.4040000000000001s 0.22114977617290882A 1.4040000000010002s 0.22114977598820282A 1.416s 0.22114977598820282A 1.416000000001s 0.22114977565447652A 1.428s 0.22114977565447652A 1.428000000001s 0.2211497328116149A 1.44s 0.2211497328116149A 1.440000000001s 0.22114969437691478A 1.452s 0.22114969437691478A 1.452000000001s 0.22114970909358522A 1.464s 0.22114970909358522A 1.464000000001s 0.2211501355092693A 1.476s 0.2211501355092693A 1.476000000001s 0.22115013568042793A 1.488s 0.22115013568042793A 1.488000000001s 0.2211501349677074A 1.5s 0.2211501349677074A 1.500000000001s 0.2211501356959578A 1.512s 0.2211501356959578A 1.512000000001s 0.22115013550133916A 1.524s 0.22115013550133916A 1.524000000001s 0.22115013528425184A 1.536s 0.22115013528425184A 1.5360000000010001s 0.22115013533084138A 1.548s 0.22115013533084138A 1.5480000000010001s 0.22115013545474968A 1.56s 0.22115013545474968A 1.5600000000010001s 0.22115013593749638A 1.572s 0.22115013593749638A 1.5720000000010002s 0.2211497801733293A 1.584s 0.2211497801733293A 1.5840000000010002s 0.22114978900088647A 1.596s 0.22114978900088647A 1.5960000000010002s 0.22114978877686028A 1.608s 0.22114978877686028A 1.6080000000010002s 0.2211497889585924A 1.62s 0.2211497889585924A 1.6200000000010002s 0.22114978892819362A 1.6320000000000001s 0.22114978892819362A 1.6320000000010002s 0.2211497884993057A 1.6440000000000001s 0.2211497884993057A 1.6440000000010002s 0.22114978881915426A 1.6560000000000001s 0.22114978881915426A 1.6560000000010002s 0.22114978861363171A 1.668s 0.22114978861363171A 1.668000000001s 0.22114978871639301A 1.68s 0.22114978871639301A 1.680000000001s 0.22114978874646143A 1.692s 0.22114978874646143A 1.692000000001s 0.22114976473369521A 1.704s 0.22114976473369521A 1.704000000001s 0.2211497757460034A 1.716s 0.2211497757460034A 1.716000000001s 0.221149776475245A 1.728s 0.221149776475245A 1.728000000001s 0.22114977611442405A 1.74s 0.22114977611442405A 1.740000000001s 0.22114977551966422A 1.752s 0.22114977551966422A 1.752000000001s 0.22114977528440374A 1.764s 0.22114977528440374A 1.764000000001s 0.2211497757460034A 1.776s 0.2211497757460034A 1.7760000000010001s 0.22114977607543426A 1.788s 0.22114977607543426A 1.7880000000010001s 0.22114977585735565A 1.8s 0.22114977585735565A 1.8000000000010001s 0.2211497758718942A 1.812s 0.2211497758718942A 1.8120000000010001s 0.2211497755916963A 1.824s 0.2211497755916963A 1.8240000000010002s 0.22114970519592603A 1.836s 0.22114970519592603A 1.8360000000010002s 0.22114969437096715A 1.848s 0.22114969437096715A 1.8480000000010002s 0.22114975042146143A 1.86s 0.22114975042146143A 1.8600000000010002s 0.221150135516869A 1.872s 0.221150135516869A 1.8720000000010002s 0.22115072447412917A)
R_0_2_0_1 Node0_2_0 Node0_2_1 9.887809523809512
R_0_2_0_2 Node0_2_0 Node0_3_0 13.020765027322398
R_0_2_0_3 Node0_2_0 Node1_2_0 2.5950185402029624
C_0_2_0 Node0_2_0 GND 0.0009924144753600014
I_0_2_1 GND Node0_2_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.22116358158843266A 0.024s 0.22116358158843266A 0.024000000001s 0.22118618933372167A 0.036000000000000004s 0.22118618933372167A 0.036000000001s 0.2211908737940979A 0.048s 0.2211908737940979A 0.048000000001s 0.22119551087194325A 0.06s 0.22119551087194325A 0.060000000000999996s 0.22119507230267305A 0.07200000000000001s 0.22119507230267305A 0.07200000000100001s 0.22116466768591708A 0.084s 0.22116466768591708A 0.08400000000100001s 0.22118307636091347A 0.096s 0.22118307636091347A 0.09600000000100001s 0.22118986937695975A 0.108s 0.22118986937695975A 0.108000000001s 0.22119452981564838A 0.12s 0.22119452981564838A 0.120000000001s 0.22119650488078488A 0.132s 0.22119650488078488A 0.132000000001s 0.22116572196375212A 0.14400000000000002s 0.22116572196375212A 0.14400000000100002s 0.2211794830865222A 0.156s 0.2211794830865222A 0.156000000001s 0.2211888008909739A 0.168s 0.2211888008909739A 0.16800000000100002s 0.2211929341742239A 0.18s 0.2211929341742239A 0.180000000001s 0.22119551087194325A 0.192s 0.22119551087194325A 0.192000000001s 0.22117747689562267A 0.20400000000000001s 0.22117747689562267A 0.20400000000100002s 0.22116769455072277A 0.216s 0.22116769455072277A 0.216000000001s 0.2211852591624322A 0.228s 0.2211852591624322A 0.228000000001s 0.22119138221460274A 0.24s 0.22119138221460274A 0.240000000001s 0.22119442583180954A 0.252s 0.22119442583180954A 0.252000000001s 0.22119250740102314A 0.264s 0.22119250740102314A 0.264000000001s 0.22116566803886328A 0.276s 0.22116566803886328A 0.276000000001s 0.22118105275676855A 0.28800000000000003s 0.22118105275676855A 0.288000000001s 0.22118986937695975A 0.3s 0.22118986937695975A 0.30000000000099997s 0.22119442583180954A 0.312s 0.22119442583180954A 0.312000000001s 0.22119650488078488A 0.324s 0.22119650488078488A 0.324000000001s 0.22116619179095415A 0.336s 0.22116619179095415A 0.336000000001s 0.22117747689562267A 0.34800000000000003s 0.22117747689562267A 0.348000000001s 0.22118831378269532A 0.36s 0.22118831378269532A 0.36000000000099996s 0.2211924122394547A 0.372s 0.2211924122394547A 0.372000000001s 0.2211959508620285A 0.384s 0.2211959508620285A 0.384000000001s 0.22117551815333855A 0.396s 0.22117551815333855A 0.396000000001s 0.221165601987483A 0.40800000000000003s 0.221165601987483A 0.408000000001s 0.22118572284378293A 0.42s 0.22118572284378293A 0.42000000000099996s 0.22119138221460274A 0.432s 0.22119138221460274A 0.432000000001s 0.22119442583180954A 0.444s 0.22119442583180954A 0.444000000001s 0.22119452981564838A 0.456s 0.22119452981564838A 0.456000000001s 0.2211651564463062A 0.468s 0.2211651564463062A 0.468000000001s 0.22118153771730342A 0.48s 0.22118153771730342A 0.48000000000099996s 0.22118986937695975A 0.492s 0.22118986937695975A 0.49200000000099997s 0.22119442583180954A 0.504s 0.22119442583180954A 0.504000000001s 0.22119650488078488A 0.516s 0.22119650488078488A 0.516000000001s 0.22116675968743926A 0.528s 0.22116675968743926A 0.528000000001s 0.22117654348619648A 0.54s 0.22117654348619648A 0.540000000001s 0.2211888008909739A 0.552s 0.2211888008909739A 0.552000000001s 0.22119198781225094A 0.5640000000000001s 0.22119198781225094A 0.564000000001s 0.22119496557633064A 0.5760000000000001s 0.22119496557633064A 0.576000000001s 0.22117801158468545A 0.588s 0.22117801158468545A 0.588000000001s 0.22116779714678875A 0.6s 0.22116779714678875A 0.600000000001s 0.22118467028414293A 0.612s 0.22118467028414293A 0.612000000001s 0.22119078636440692A 0.624s 0.22119078636440692A 0.624000000001s 0.22119452981564838A 0.636s 0.22119452981564838A 0.636000000001s 0.22119096224809753A 0.648s 0.22119096224809753A 0.648000000001s 0.2211662204715936A 0.66s 0.2211662204715936A 0.660000000001s 0.22117999956932655A 0.672s 0.22117999956932655A 0.672000000001s 0.22115275043087945A 0.684s 0.22115275043087945A 0.684000000001s 0.22114977681425807A 0.6960000000000001s 0.22114977681425807A 0.696000000001s 0.22114977599778504A 0.708s 0.22114977599778504A 0.7080000000009999s 0.22114977560127852A 0.72s 0.22114977560127852A 0.720000000001s 0.22114977558211402A 0.732s 0.22114977558211402A 0.732000000001s 0.22114977679443273A 0.744s 0.22114977679443273A 0.744000000001s 0.22114977573146483A 0.756s 0.22114977573146483A 0.756000000001s 0.22114977561581708A 0.768s 0.22114977561581708A 0.768000000001s 0.22114977605131342A 0.78s 0.22114977605131342A 0.780000000001s 0.22114977581373993A 0.792s 0.22114977581373993A 0.792000000001s 0.22114977627996552A 0.804s 0.22114977627996552A 0.804000000001s 0.22114976433685823A 0.8160000000000001s 0.22114976433685823A 0.816000000001s 0.2211497887464614A 0.8280000000000001s 0.2211497887464614A 0.828000000001s 0.2211497890253377A 0.84s 0.2211497890253377A 0.840000000001s 0.2211497887282882A 0.852s 0.2211497887282882A 0.852000000001s 0.2211497887223406A 0.864s 0.2211497887223406A 0.864000000001s 0.2211497887223406A 0.876s 0.2211497887223406A 0.876000000001s 0.2211497886499781A 0.888s 0.2211497886499781A 0.888000000001s 0.22114978878875544A 0.9s 0.22114978878875544A 0.900000000001s 0.22114978887367395A 0.912s 0.22114978887367395A 0.912000000001s 0.22114978876463465A 0.924s 0.22114978876463465A 0.924000000001s 0.22114976941610698A 0.936s 0.22114976941610698A 0.936000000001s 0.22114978736595783A 0.9480000000000001s 0.22114978736595783A 0.948000000001s 0.2211497871240888A 0.96s 0.2211497871240888A 0.9600000000009999s 0.22114978785828676A 0.972s 0.22114978785828676A 0.972000000001s 0.22114978749019654A 0.984s 0.22114978749019654A 0.984000000001s 0.22114978749614414A 0.996s 0.22114978749614414A 0.996000000001s 0.22114978734811505A 1.008s 0.22114978734811505A 1.008000000001s 0.22114978800763754A 1.02s 0.22114978800763754A 1.020000000001s 0.22114978788835518A 1.032s 0.22114978788835518A 1.0320000000010001s 0.2211497869066711A 1.044s 0.2211497869066711A 1.0440000000010001s 0.22114969977766416A 1.056s 0.22114969977766416A 1.0560000000010001s 0.22114969499282158A 1.068s 0.22114969499282158A 1.0680000000010001s 0.22115013548580928A 1.08s 0.22115013548580928A 1.0800000000010002s 0.2211501356414381A 1.092s 0.2211501356414381A 1.0920000000010002s 0.22115013552479906A 1.104s 0.22115013552479906A 1.1040000000010002s 0.22115013529218192A 1.116s 0.22115013529218192A 1.1160000000010002s 0.22115013555585877A 1.1280000000000001s 0.22115013555585877A 1.1280000000010002s 0.22115013608618628A 1.1400000000000001s 0.22115013608618628A 1.1400000000010002s 0.22115013583605672A 1.1520000000000001s 0.22115013583605672A 1.1520000000010002s 0.2211501351064847A 1.164s 0.2211501351064847A 1.164000000001s 0.22115013564903782A 1.176s 0.22115013564903782A 1.176000000001s 0.22114978510983566A 1.188s 0.22114978510983566A 1.188000000001s 0.2211497890253377A 1.2s 0.2211497890253377A 1.200000000001s 0.22114978892224596A 1.212s 0.22114978892224596A 1.212000000001s 0.22114978884955314A 1.224s 0.22114978884955314A 1.224000000001s 0.22114978889184714A 1.236s 0.22114978889184714A 1.236000000001s 0.22114978857166812A 1.248s 0.22114978857166812A 1.248000000001s 0.2211497887405138A 1.26s 0.2211497887405138A 1.260000000001s 0.22114978866187332A 1.272s 0.22114978866187332A 1.272000000001s 0.2211497885895109A 1.284s 0.2211497885895109A 1.2840000000010001s 0.2211497888555007A 1.296s 0.2211497888555007A 1.2960000000010001s 0.221149769407516A 1.308s 0.221149769407516A 1.3080000000010001s 0.2211497753514794A 1.32s 0.2211497753514794A 1.3200000000010002s 0.2211497756207734A 1.332s 0.2211497756207734A 1.3320000000010002s 0.22114977590097137A 1.344s 0.22114977590097137A 1.3440000000010002s 0.22114977593467441A 1.356s 0.22114977593467441A 1.3560000000010002s 0.22114977633845023A 1.368s 0.22114977633845023A 1.3680000000010002s 0.22114977553387238A 1.3800000000000001s 0.22114977553387238A 1.3800000000010002s 0.2211497761435012A 1.3920000000000001s 0.2211497761435012A 1.3920000000010002s 0.2211497761729088A 1.4040000000000001s 0.2211497761729088A 1.4040000000010002s 0.2211497759882028A 1.416s 0.2211497759882028A 1.416000000001s 0.2211497756544765A 1.428s 0.2211497756544765A 1.428000000001s 0.2211497328116149A 1.44s 0.2211497328116149A 1.440000000001s 0.22114969437691476A 1.452s 0.22114969437691476A 1.452000000001s 0.2211497090935852A 1.464s 0.2211497090935852A 1.464000000001s 0.22115013550926926A 1.476s 0.22115013550926926A 1.476000000001s 0.2211501356804279A 1.488s 0.2211501356804279A 1.488000000001s 0.2211501349677074A 1.5s 0.2211501349677074A 1.500000000001s 0.2211501356959578A 1.512s 0.2211501356959578A 1.512000000001s 0.22115013550133913A 1.524s 0.22115013550133913A 1.524000000001s 0.22115013528425181A 1.536s 0.22115013528425181A 1.5360000000010001s 0.22115013533084135A 1.548s 0.22115013533084135A 1.5480000000010001s 0.22115013545474965A 1.56s 0.22115013545474965A 1.5600000000010001s 0.22115013593749636A 1.572s 0.22115013593749636A 1.5720000000010002s 0.22114978017332929A 1.584s 0.22114978017332929A 1.5840000000010002s 0.22114978900088644A 1.596s 0.22114978900088644A 1.5960000000010002s 0.22114978877686026A 1.608s 0.22114978877686026A 1.6080000000010002s 0.22114978895859239A 1.62s 0.22114978895859239A 1.6200000000010002s 0.2211497889281936A 1.6320000000000001s 0.2211497889281936A 1.6320000000010002s 0.22114978849930567A 1.6440000000000001s 0.22114978849930567A 1.6440000000010002s 0.22114978881915423A 1.6560000000000001s 0.22114978881915423A 1.6560000000010002s 0.2211497886136317A 1.668s 0.2211497886136317A 1.668000000001s 0.221149788716393A 1.68s 0.221149788716393A 1.680000000001s 0.2211497887464614A 1.692s 0.2211497887464614A 1.692000000001s 0.2211497647336952A 1.704s 0.2211497647336952A 1.704000000001s 0.2211497757460034A 1.716s 0.2211497757460034A 1.716000000001s 0.22114977647524497A 1.728s 0.22114977647524497A 1.728000000001s 0.22114977611442405A 1.74s 0.22114977611442405A 1.740000000001s 0.22114977551966422A 1.752s 0.22114977551966422A 1.752000000001s 0.22114977528440372A 1.764s 0.22114977528440372A 1.764000000001s 0.2211497757460034A 1.776s 0.2211497757460034A 1.7760000000010001s 0.22114977607543423A 1.788s 0.22114977607543423A 1.7880000000010001s 0.22114977585735562A 1.8s 0.22114977585735562A 1.8000000000010001s 0.22114977587189416A 1.812s 0.22114977587189416A 1.8120000000010001s 0.22114977559169627A 1.824s 0.22114977559169627A 1.8240000000010002s 0.221149705195926A 1.836s 0.221149705195926A 1.8360000000010002s 0.22114969437096713A 1.848s 0.22114969437096713A 1.8480000000010002s 0.2211497504214614A 1.86s 0.2211497504214614A 1.8600000000010002s 0.22115013551686896A 1.872s 0.22115013551686896A 1.8720000000010002s 0.22115072447412915A)
R_0_2_1_1 Node0_2_1 Node0_2_2 9.887809523809512
R_0_2_1_2 Node0_2_1 Node0_3_1 13.020765027322401
R_0_2_1_3 Node0_2_1 Node1_2_1 2.595018540202963
C_0_2_1 Node0_2_1 GND 0.0009924144753600012
I_0_2_2 GND Node0_2_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.16027932310418047A 0.024s 0.16027932310418047A 0.024000000001s 0.16029310521637713A 0.036000000000000004s 0.16029310521637713A 0.036000000001s 0.16029595148323178A 0.048s 0.16029595148323178A 0.048000000001s 0.16029877632437917A 0.06s 0.16029877632437917A 0.060000000000999996s 0.1602984971184276A 0.07200000000000001s 0.1602984971184276A 0.07200000000100001s 0.16027997600434932A 0.084s 0.16027997600434932A 0.08400000000100001s 0.1602912122273495A 0.096s 0.1602912122273495A 0.09600000000100001s 0.16029533551775504A 0.108s 0.16029533551775504A 0.108000000001s 0.16029817092234386A 0.12s 0.16029817092234386A 0.120000000001s 0.1602993875833721A 0.132s 0.1602993875833721A 0.132000000001s 0.16028061451612477A 0.14400000000000002s 0.16028061451612477A 0.14400000000100002s 0.1602890211616113A 0.156s 0.1602890211616113A 0.156000000001s 0.16029469058125564A 0.168s 0.16029469058125564A 0.16800000000100002s 0.16029720672248615A 0.18s 0.16029720672248615A 0.180000000001s 0.16029877632437917A 0.192s 0.16029877632437917A 0.192000000001s 0.16028779042595526A 0.20400000000000001s 0.16028779042595526A 0.20400000000100002s 0.1602818300565616A 0.216s 0.1602818300565616A 0.216000000001s 0.16029252282381828A 0.228s 0.16029252282381828A 0.228000000001s 0.16029626227491925A 0.24s 0.16029626227491925A 0.240000000001s 0.1602981239023293A 0.252s 0.1602981239023293A 0.252000000001s 0.16029693285054958A 0.264s 0.16029693285054958A 0.264000000001s 0.1602805901320562A 0.276s 0.1602805901320562A 0.276000000001s 0.16028997361767128A 0.28800000000000003s 0.16028997361767128A 0.288000000001s 0.16029533551775504A 0.3s 0.16029533551775504A 0.30000000000099997s 0.1602981239023293A 0.312s 0.1602981239023293A 0.312000000001s 0.1602993875833721A 0.324s 0.1602993875833721A 0.324000000001s 0.16028090785646903A 0.336s 0.16028090785646903A 0.336000000001s 0.16028779042595526A 0.34800000000000003s 0.16028779042595526A 0.348000000001s 0.1602943894266541A 0.36s 0.1602943894266541A 0.36000000000099996s 0.16029688981984036A 0.372s 0.16029688981984036A 0.372000000001s 0.16029905617280313A 0.384s 0.16029905617280313A 0.384000000001s 0.16028658114588895A 0.396s 0.16028658114588895A 0.396000000001s 0.16028056026456047A 0.40800000000000003s 0.16028056026456047A 0.408000000001s 0.16029281338509593A 0.42s 0.16029281338509593A 0.42000000000099996s 0.16029626227491925A 0.432s 0.16029626227491925A 0.432000000001s 0.1602981239023293A 0.444s 0.1602981239023293A 0.444000000001s 0.16029817092234386A 0.456s 0.16029817092234386A 0.456000000001s 0.16028027790601176A 0.468s 0.16028027790601176A 0.468000000001s 0.16029027380109362A 0.48s 0.16029027380109362A 0.48000000000099996s 0.16029533551775504A 0.492s 0.16029533551775504A 0.49200000000099997s 0.1602981239023293A 0.504s 0.1602981239023293A 0.504000000001s 0.1602993875833721A 0.516s 0.1602993875833721A 0.516000000001s 0.16028124554234974A 0.528s 0.16028124554234974A 0.528000000001s 0.16028720656915701A 0.54s 0.16028720656915701A 0.540000000001s 0.16029469058125564A 0.552s 0.16029469058125564A 0.552000000001s 0.16029661700873027A 0.5640000000000001s 0.16029661700873027A 0.564000000001s 0.16029844885829192A 0.5760000000000001s 0.16029844885829192A 0.576000000001s 0.1602881130959114A 0.588s 0.1602881130959114A 0.588000000001s 0.16028187644904499A 0.6s 0.16028187644904499A 0.600000000001s 0.16029217565026385A 0.612s 0.16029217565026385A 0.612000000001s 0.1602959119487677A 0.624s 0.1602959119487677A 0.624000000001s 0.16029817092234386A 0.636s 0.16029817092234386A 0.636000000001s 0.1602959914808737A 0.648s 0.1602959914808737A 0.648000000001s 0.1602809208254467A 0.66s 0.1602809208254467A 0.660000000001s 0.16028933559895606A 0.672s 0.16028933559895606A 0.672000000001s 0.16027272669428888A 0.684s 0.16027272669428888A 0.684000000001s 0.160270896720149A 0.6960000000000001s 0.160270896720149A 0.696000000001s 0.1602708963509515A 0.708s 0.1602708963509515A 0.7080000000009999s 0.1602708961716569A 0.72s 0.1602708961716569A 0.720000000001s 0.16027089616299098A 0.732s 0.16027089616299098A 0.732000000001s 0.16027089671118427A 0.744s 0.16027089671118427A 0.744000000001s 0.1602708962305253A 0.756s 0.1602708962305253A 0.756000000001s 0.16027089617823104A 0.768s 0.16027089617823104A 0.768000000001s 0.1602708963751563A 0.78s 0.1602708963751563A 0.780000000001s 0.16027089626772895A 0.792s 0.16027089626772895A 0.792000000001s 0.16027089647854953A 0.804s 0.16027089647854953A 0.804000000001s 0.1602708910780461A 0.8160000000000001s 0.1602708910780461A 0.816000000001s 0.16027090211572184A 0.8280000000000001s 0.16027090211572184A 0.828000000001s 0.16027090224182572A 0.84s 0.16027090224182572A 0.840000000001s 0.16027090210750417A 0.852s 0.16027090210750417A 0.852000000001s 0.16027090210481476A 0.864s 0.16027090210481476A 0.864000000001s 0.16027090210481476A 0.876s 0.16027090210481476A 0.876000000001s 0.16027090207209346A 0.888s 0.16027090207209346A 0.888000000001s 0.1602709021348466A 0.9s 0.1602709021348466A 0.900000000001s 0.16027090217324555A 0.912s 0.16027090217324555A 0.912000000001s 0.16027090212393952A 0.924s 0.16027090212393952A 0.924000000001s 0.1602708933748102A 0.936s 0.1602708933748102A 0.936000000001s 0.1602709014914777A 0.9480000000000001s 0.1602709014914777A 0.948000000001s 0.160270901382108A 0.96s 0.160270901382108A 0.9600000000009999s 0.16027090171410188A 0.972s 0.16027090171410188A 0.972000000001s 0.16027090154765672A 0.984s 0.16027090154765672A 0.984000000001s 0.16027090155034612A 0.996s 0.16027090155034612A 0.996000000001s 0.1602709014834095A 1.008s 0.1602709014834095A 1.008000000001s 0.16027090178163617A 1.02s 0.16027090178163617A 1.020000000001s 0.1602709017276984A 1.032s 0.1602709017276984A 1.0320000000010001s 0.1602709012837948A 1.044s 0.1602709012837948A 1.0440000000010001s 0.16027086188529577A 1.056s 0.16027086188529577A 1.0560000000010001s 0.16027085972165794A 1.068s 0.16027085972165794A 1.0680000000010001s 0.16027113979748722A 1.08s 0.16027113979748722A 1.0800000000010002s 0.16027113986786037A 1.092s 0.16027113986786037A 1.0920000000010002s 0.16027113981511787A 1.104s 0.16027113981511787A 1.1040000000010002s 0.1602711397099317A 1.116s 0.1602711397099317A 1.1160000000010002s 0.1602711398291626A 1.1280000000000001s 0.1602711398291626A 1.1280000000010002s 0.1602711400689692A 1.1400000000000001s 0.1602711400689692A 1.1400000000010002s 0.16027113995586414A 1.1520000000000001s 0.16027113995586414A 1.1520000000010002s 0.16027113962596207A 1.164s 0.16027113962596207A 1.164000000001s 0.16027113987129687A 1.176s 0.16027113987129687A 1.176000000001s 0.16027090047129133A 1.188s 0.16027090047129133A 1.188000000001s 0.16027090224182572A 1.2s 0.16027090224182572A 1.200000000001s 0.16027090219520912A 1.212s 0.16027090219520912A 1.212000000001s 0.16027090216233847A 1.224s 0.16027090216233847A 1.224000000001s 0.1602709021814632A 1.236s 0.1602709021814632A 1.236000000001s 0.1602709020366828A 1.248s 0.1602709020366828A 1.248000000001s 0.1602709021130324A 1.26s 0.1602709021130324A 1.260000000001s 0.1602709020774723A 1.272s 0.1602709020774723A 1.272000000001s 0.16027090204475103A 1.284s 0.16027090204475103A 1.2840000000010001s 0.16027090216502787A 1.296s 0.16027090216502787A 1.2960000000010001s 0.16027089337092548A 1.308s 0.16027089337092548A 1.3080000000010001s 0.1602708960587013A 1.32s 0.1602708960587013A 1.3200000000010002s 0.1602708961804722A 1.332s 0.1602708961804722A 1.3320000000010002s 0.16027089630717375A 1.344s 0.16027089630717375A 1.3440000000010002s 0.1602708963224138A 1.356s 0.1602708963224138A 1.3560000000010002s 0.16027089650499549A 1.368s 0.16027089650499549A 1.3680000000010002s 0.1602708961411768A 1.3800000000000001s 0.1602708961411768A 1.3800000000010002s 0.16027089641684228A 1.3920000000000001s 0.16027089641684228A 1.3920000000010002s 0.16027089643013998A 1.4040000000000001s 0.16027089643013998A 1.4040000000010002s 0.16027089634661856A 1.416s 0.16027089634661856A 1.416000000001s 0.16027089619571228A 1.428s 0.16027089619571228A 1.428000000001s 0.16027087682277896A 1.44s 0.16027087682277896A 1.440000000001s 0.1602708594431536A 1.452s 0.1602708594431536A 1.452000000001s 0.1602708660978229A 1.464s 0.1602708660978229A 1.464000000001s 0.16027113980809551A 1.476s 0.16027113980809551A 1.476000000001s 0.16027113988549102A 1.488s 0.16027113988549102A 1.488000000001s 0.16027113956320893A 1.5s 0.16027113956320893A 1.500000000001s 0.1602711398925134A 1.512s 0.1602711398925134A 1.512000000001s 0.1602711398045096A 1.524s 0.1602711398045096A 1.524000000001s 0.16027113970634582A 1.536s 0.16027113970634582A 1.5360000000010001s 0.16027113972741294A 1.548s 0.16027113972741294A 1.5480000000010001s 0.1602711397834425A 1.56s 0.1602711397834425A 1.5600000000010001s 0.1602711400017337A 1.572s 0.1602711400017337A 1.5720000000010002s 0.1602708982390733A 1.584s 0.1602708982390733A 1.5840000000010002s 0.16027090223076923A 1.596s 0.16027090223076923A 1.5960000000010002s 0.16027090212946776A 1.608s 0.16027090212946776A 1.6080000000010002s 0.16027090221164447A 1.62s 0.16027090221164447A 1.6200000000010002s 0.16027090219789855A 1.6320000000000001s 0.16027090219789855A 1.6320000000010002s 0.16027090200396155A 1.6440000000000001s 0.16027090200396155A 1.6440000000010002s 0.16027090214859252A 1.6560000000000001s 0.16027090214859252A 1.6560000000010002s 0.16027090205565814A 1.668s 0.16027090205565814A 1.668000000001s 0.16027090210212533A 1.68s 0.16027090210212533A 1.680000000001s 0.16027090211572184A 1.692s 0.16027090211572184A 1.692000000001s 0.1602708912574901A 1.704s 0.1602708912574901A 1.704000000001s 0.16027089623709942A 1.716s 0.16027089623709942A 1.716000000001s 0.16027089656685212A 1.728s 0.16027089656685212A 1.728000000001s 0.16027089640369402A 1.74s 0.16027089640369402A 1.740000000001s 0.16027089613475207A 1.752s 0.16027089613475207A 1.752000000001s 0.1602708960283706A 1.764s 0.1602708960283706A 1.764000000001s 0.16027089623709942A 1.776s 0.16027089623709942A 1.7760000000010001s 0.1602708963860634A 1.788s 0.1602708963860634A 1.7880000000010001s 0.16027089628745134A 1.8s 0.16027089628745134A 1.8000000000010001s 0.16027089629402547A 1.812s 0.16027089629402547A 1.8120000000010001s 0.16027089616732393A 1.824s 0.16027089616732393A 1.8240000000010002s 0.16027086433535678A 1.836s 0.16027086433535678A 1.8360000000010002s 0.16027085944046418A 1.848s 0.16027085944046418A 1.8480000000010002s 0.16027088478570134A 1.86s 0.16027088478570134A 1.8600000000010002s 0.160271139811532A 1.872s 0.160271139811532A 1.8720000000010002s 0.16027148702079597A)
R_0_2_2_1 Node0_2_2 Node0_2_3 9.887809523809512
R_0_2_2_2 Node0_2_2 Node0_3_2 13.020765027322401
R_0_2_2_3 Node0_2_2 Node1_2_2 2.595018540202963
C_0_2_2 Node0_2_2 GND 0.0009924144753600012
I_0_2_3 GND Node0_2_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.11002323941767812A 0.024s 0.11002323941767812A 0.024000000001s 0.11002973653098802A 0.036000000000000004s 0.11002973653098802A 0.036000000001s 0.11003106548598325A 0.048s 0.11003106548598325A 0.048000000001s 0.11003239444097847A 0.06s 0.11003239444097847A 0.060000000000999996s 0.11003224677931235A 0.07200000000000001s 0.11003224677931235A 0.07200000000100001s 0.11002353474101037A 0.084s 0.11002353474101037A 0.08400000000100001s 0.11002885056099124A 0.096s 0.11002885056099124A 0.09600000000100001s 0.11003077016265098A 0.108s 0.11003077016265098A 0.108000000001s 0.11003209911764618A 0.12s 0.11003209911764618A 0.120000000001s 0.11003268976431071A 0.132s 0.11003268976431071A 0.132000000001s 0.11002383006434265A 0.14400000000000002s 0.11002383006434265A 0.14400000000100002s 0.11002781692932828A 0.156s 0.11002781692932828A 0.156000000001s 0.1100304748393187A 0.168s 0.1100304748393187A 0.16800000000100002s 0.11003165613264779A 0.18s 0.11003165613264779A 0.180000000001s 0.11003239444097847A 0.192s 0.11003239444097847A 0.192000000001s 0.11002722628266375A 0.20400000000000001s 0.11002722628266375A 0.20400000000100002s 0.11002442071100718A 0.216s 0.11002442071100718A 0.216000000001s 0.11002944120765577A 0.228s 0.11002944120765577A 0.228000000001s 0.11003121314764938A 0.24s 0.11003121314764938A 0.240000000001s 0.11003209911764618A 0.252s 0.11003209911764618A 0.252000000001s 0.11003150847098164A 0.264s 0.11003150847098164A 0.264000000001s 0.11002383006434265A 0.276s 0.11002383006434265A 0.276000000001s 0.11002825991432669A 0.28800000000000003s 0.11002825991432669A 0.288000000001s 0.11003077016265098A 0.3s 0.11003077016265098A 0.30000000000099997s 0.11003209911764618A 0.312s 0.11003209911764618A 0.312000000001s 0.11003268976431071A 0.324s 0.11003268976431071A 0.324000000001s 0.11002397772600878A 0.336s 0.11002397772600878A 0.336000000001s 0.11002722628266375A 0.34800000000000003s 0.11002722628266375A 0.348000000001s 0.11003032717765257A 0.36s 0.11003032717765257A 0.36000000000099996s 0.11003150847098164A 0.372s 0.11003150847098164A 0.372000000001s 0.11003254210264458A 0.384s 0.11003254210264458A 0.384000000001s 0.11002663563599921A 0.396s 0.11002663563599921A 0.396000000001s 0.11002383006434265A 0.40800000000000003s 0.11002383006434265A 0.408000000001s 0.11002958886932189A 0.42s 0.11002958886932189A 0.42000000000099996s 0.11003121314764938A 0.432s 0.11003121314764938A 0.432000000001s 0.11003209911764618A 0.444s 0.11003209911764618A 0.444000000001s 0.11003209911764618A 0.456s 0.11003209911764618A 0.456000000001s 0.11002368240267653A 0.468s 0.11002368240267653A 0.468000000001s 0.11002840757599282A 0.48s 0.11002840757599282A 0.48000000000099996s 0.11003077016265098A 0.492s 0.11003077016265098A 0.49200000000099997s 0.11003209911764618A 0.504s 0.11003209911764618A 0.504000000001s 0.11003268976431071A 0.516s 0.11003268976431071A 0.516000000001s 0.1100241253876749A 0.528s 0.1100241253876749A 0.528000000001s 0.11002693095933146A 0.54s 0.11002693095933146A 0.540000000001s 0.1100304748393187A 0.552s 0.1100304748393187A 0.552000000001s 0.11003136080931551A 0.5640000000000001s 0.11003136080931551A 0.564000000001s 0.11003224677931235A 0.5760000000000001s 0.11003224677931235A 0.576000000001s 0.11002737394432988A 0.588s 0.11002737394432988A 0.588000000001s 0.11002442071100718A 0.6s 0.11002442071100718A 0.600000000001s 0.11002929354598964A 0.612s 0.11002929354598964A 0.612000000001s 0.11003106548598325A 0.624s 0.11003106548598325A 0.624000000001s 0.11003209911764618A 0.636s 0.11003209911764618A 0.636000000001s 0.11003106548598325A 0.648s 0.11003106548598325A 0.648000000001s 0.11002397772600878A 0.66s 0.11002397772600878A 0.660000000001s 0.11002796459099441A 0.672s 0.11002796459099441A 0.672000000001s 0.11002013852268927A 0.684s 0.11002013852268927A 0.684000000001s 0.11001925255269247A 0.6960000000000001s 0.11001925255269247A 0.696000000001s 0.11001925255269247A 0.708s 0.11001925255269247A 0.7080000000009999s 0.11001925255269247A 0.72s 0.11001925255269247A 0.720000000001s 0.11001925255269247A 0.732s 0.11001925255269247A 0.732000000001s 0.11001925255269247A 0.744s 0.11001925255269247A 0.744000000001s 0.11001925255269247A 0.756s 0.11001925255269247A 0.756000000001s 0.11001925255269247A 0.768s 0.11001925255269247A 0.768000000001s 0.11001925255269247A 0.78s 0.11001925255269247A 0.780000000001s 0.11001925255269247A 0.792s 0.11001925255269247A 0.792000000001s 0.11001925255269247A 0.804s 0.11001925255269247A 0.804000000001s 0.11001925255269247A 0.8160000000000001s 0.11001925255269247A 0.816000000001s 0.11001925255269247A 0.8280000000000001s 0.11001925255269247A 0.828000000001s 0.11001925255269247A 0.84s 0.11001925255269247A 0.840000000001s 0.11001925255269247A 0.852s 0.11001925255269247A 0.852000000001s 0.11001925255269247A 0.864s 0.11001925255269247A 0.864000000001s 0.11001925255269247A 0.876s 0.11001925255269247A 0.876000000001s 0.11001925255269247A 0.888s 0.11001925255269247A 0.888000000001s 0.11001925255269247A 0.9s 0.11001925255269247A 0.900000000001s 0.11001925255269247A 0.912s 0.11001925255269247A 0.912000000001s 0.11001925255269247A 0.924s 0.11001925255269247A 0.924000000001s 0.11001925255269247A 0.936s 0.11001925255269247A 0.936000000001s 0.11001925255269247A 0.9480000000000001s 0.11001925255269247A 0.948000000001s 0.11001925255269247A 0.96s 0.11001925255269247A 0.9600000000009999s 0.11001925255269247A 0.972s 0.11001925255269247A 0.972000000001s 0.11001925255269247A 0.984s 0.11001925255269247A 0.984000000001s 0.11001925255269247A 0.996s 0.11001925255269247A 0.996000000001s 0.11001925255269247A 1.008s 0.11001925255269247A 1.008000000001s 0.11001925255269247A 1.02s 0.11001925255269247A 1.020000000001s 0.11001925255269247A 1.032s 0.11001925255269247A 1.0320000000010001s 0.11001925255269247A 1.044s 0.11001925255269247A 1.0440000000010001s 0.11001925255269247A 1.056s 0.11001925255269247A 1.0560000000010001s 0.11001925255269247A 1.068s 0.11001925255269247A 1.0680000000010001s 0.1100194002143586A 1.08s 0.1100194002143586A 1.0800000000010002s 0.1100194002143586A 1.092s 0.1100194002143586A 1.0920000000010002s 0.1100194002143586A 1.104s 0.1100194002143586A 1.1040000000010002s 0.1100194002143586A 1.116s 0.1100194002143586A 1.1160000000010002s 0.1100194002143586A 1.1280000000000001s 0.1100194002143586A 1.1280000000010002s 0.1100194002143586A 1.1400000000000001s 0.1100194002143586A 1.1400000000010002s 0.1100194002143586A 1.1520000000000001s 0.1100194002143586A 1.1520000000010002s 0.1100194002143586A 1.164s 0.1100194002143586A 1.164000000001s 0.1100194002143586A 1.176s 0.1100194002143586A 1.176000000001s 0.11001925255269247A 1.188s 0.11001925255269247A 1.188000000001s 0.11001925255269247A 1.2s 0.11001925255269247A 1.200000000001s 0.11001925255269247A 1.212s 0.11001925255269247A 1.212000000001s 0.11001925255269247A 1.224s 0.11001925255269247A 1.224000000001s 0.11001925255269247A 1.236s 0.11001925255269247A 1.236000000001s 0.11001925255269247A 1.248s 0.11001925255269247A 1.248000000001s 0.11001925255269247A 1.26s 0.11001925255269247A 1.260000000001s 0.11001925255269247A 1.272s 0.11001925255269247A 1.272000000001s 0.11001925255269247A 1.284s 0.11001925255269247A 1.2840000000010001s 0.11001925255269247A 1.296s 0.11001925255269247A 1.2960000000010001s 0.11001925255269247A 1.308s 0.11001925255269247A 1.3080000000010001s 0.11001925255269247A 1.32s 0.11001925255269247A 1.3200000000010002s 0.11001925255269247A 1.332s 0.11001925255269247A 1.3320000000010002s 0.11001925255269247A 1.344s 0.11001925255269247A 1.3440000000010002s 0.11001925255269247A 1.356s 0.11001925255269247A 1.3560000000010002s 0.11001925255269247A 1.368s 0.11001925255269247A 1.3680000000010002s 0.11001925255269247A 1.3800000000000001s 0.11001925255269247A 1.3800000000010002s 0.11001925255269247A 1.3920000000000001s 0.11001925255269247A 1.3920000000010002s 0.11001925255269247A 1.4040000000000001s 0.11001925255269247A 1.4040000000010002s 0.11001925255269247A 1.416s 0.11001925255269247A 1.416000000001s 0.11001925255269247A 1.428s 0.11001925255269247A 1.428000000001s 0.11001925255269247A 1.44s 0.11001925255269247A 1.440000000001s 0.11001925255269247A 1.452s 0.11001925255269247A 1.452000000001s 0.11001925255269247A 1.464s 0.11001925255269247A 1.464000000001s 0.1100194002143586A 1.476s 0.1100194002143586A 1.476000000001s 0.1100194002143586A 1.488s 0.1100194002143586A 1.488000000001s 0.1100194002143586A 1.5s 0.1100194002143586A 1.500000000001s 0.1100194002143586A 1.512s 0.1100194002143586A 1.512000000001s 0.1100194002143586A 1.524s 0.1100194002143586A 1.524000000001s 0.1100194002143586A 1.536s 0.1100194002143586A 1.5360000000010001s 0.1100194002143586A 1.548s 0.1100194002143586A 1.5480000000010001s 0.1100194002143586A 1.56s 0.1100194002143586A 1.5600000000010001s 0.1100194002143586A 1.572s 0.1100194002143586A 1.5720000000010002s 0.11001925255269247A 1.584s 0.11001925255269247A 1.5840000000010002s 0.11001925255269247A 1.596s 0.11001925255269247A 1.5960000000010002s 0.11001925255269247A 1.608s 0.11001925255269247A 1.6080000000010002s 0.11001925255269247A 1.62s 0.11001925255269247A 1.6200000000010002s 0.11001925255269247A 1.6320000000000001s 0.11001925255269247A 1.6320000000010002s 0.11001925255269247A 1.6440000000000001s 0.11001925255269247A 1.6440000000010002s 0.11001925255269247A 1.6560000000000001s 0.11001925255269247A 1.6560000000010002s 0.11001925255269247A 1.668s 0.11001925255269247A 1.668000000001s 0.11001925255269247A 1.68s 0.11001925255269247A 1.680000000001s 0.11001925255269247A 1.692s 0.11001925255269247A 1.692000000001s 0.11001925255269247A 1.704s 0.11001925255269247A 1.704000000001s 0.11001925255269247A 1.716s 0.11001925255269247A 1.716000000001s 0.11001925255269247A 1.728s 0.11001925255269247A 1.728000000001s 0.11001925255269247A 1.74s 0.11001925255269247A 1.740000000001s 0.11001925255269247A 1.752s 0.11001925255269247A 1.752000000001s 0.11001925255269247A 1.764s 0.11001925255269247A 1.764000000001s 0.11001925255269247A 1.776s 0.11001925255269247A 1.7760000000010001s 0.11001925255269247A 1.788s 0.11001925255269247A 1.7880000000010001s 0.11001925255269247A 1.8s 0.11001925255269247A 1.8000000000010001s 0.11001925255269247A 1.812s 0.11001925255269247A 1.8120000000010001s 0.11001925255269247A 1.824s 0.11001925255269247A 1.8240000000010002s 0.11001925255269247A 1.836s 0.11001925255269247A 1.8360000000010002s 0.11001925255269247A 1.848s 0.11001925255269247A 1.8480000000010002s 0.11001925255269247A 1.86s 0.11001925255269247A 1.8600000000010002s 0.1100194002143586A 1.872s 0.1100194002143586A 1.8720000000010002s 0.11001954787602473A)
R_0_2_3_1 Node0_2_3 Node0_2_4 9.887809523809512
R_0_2_3_2 Node0_2_3 Node0_3_3 13.020765027322401
R_0_2_3_3 Node0_2_3 Node1_2_3 2.595018540202963
C_0_2_3 Node0_2_3 GND 0.0009924144753600012
I_0_2_4 GND Node0_2_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.11002323941767811A 0.024s 0.11002323941767811A 0.024000000001s 0.110029736530988A 0.036000000000000004s 0.110029736530988A 0.036000000001s 0.11003106548598324A 0.048s 0.11003106548598324A 0.048000000001s 0.11003239444097845A 0.06s 0.11003239444097845A 0.060000000000999996s 0.11003224677931234A 0.07200000000000001s 0.11003224677931234A 0.07200000000100001s 0.11002353474101036A 0.084s 0.11002353474101036A 0.08400000000100001s 0.11002885056099122A 0.096s 0.11002885056099122A 0.09600000000100001s 0.11003077016265096A 0.108s 0.11003077016265096A 0.108000000001s 0.11003209911764616A 0.12s 0.11003209911764616A 0.120000000001s 0.1100326897643107A 0.132s 0.1100326897643107A 0.132000000001s 0.11002383006434263A 0.14400000000000002s 0.11002383006434263A 0.14400000000100002s 0.11002781692932827A 0.156s 0.11002781692932827A 0.156000000001s 0.1100304748393187A 0.168s 0.1100304748393187A 0.16800000000100002s 0.11003165613264777A 0.18s 0.11003165613264777A 0.180000000001s 0.11003239444097845A 0.192s 0.11003239444097845A 0.192000000001s 0.11002722628266373A 0.20400000000000001s 0.11002722628266373A 0.20400000000100002s 0.11002442071100717A 0.216s 0.11002442071100717A 0.216000000001s 0.11002944120765576A 0.228s 0.11002944120765576A 0.228000000001s 0.11003121314764937A 0.24s 0.11003121314764937A 0.240000000001s 0.11003209911764616A 0.252s 0.11003209911764616A 0.252000000001s 0.11003150847098163A 0.264s 0.11003150847098163A 0.264000000001s 0.11002383006434263A 0.276s 0.11002383006434263A 0.276000000001s 0.11002825991432667A 0.28800000000000003s 0.11002825991432667A 0.288000000001s 0.11003077016265096A 0.3s 0.11003077016265096A 0.30000000000099997s 0.11003209911764616A 0.312s 0.11003209911764616A 0.312000000001s 0.1100326897643107A 0.324s 0.1100326897643107A 0.324000000001s 0.11002397772600876A 0.336s 0.11002397772600876A 0.336000000001s 0.11002722628266373A 0.34800000000000003s 0.11002722628266373A 0.348000000001s 0.11003032717765256A 0.36s 0.11003032717765256A 0.36000000000099996s 0.11003150847098163A 0.372s 0.11003150847098163A 0.372000000001s 0.11003254210264457A 0.384s 0.11003254210264457A 0.384000000001s 0.1100266356359992A 0.396s 0.1100266356359992A 0.396000000001s 0.11002383006434263A 0.40800000000000003s 0.11002383006434263A 0.408000000001s 0.11002958886932188A 0.42s 0.11002958886932188A 0.42000000000099996s 0.11003121314764937A 0.432s 0.11003121314764937A 0.432000000001s 0.11003209911764616A 0.444s 0.11003209911764616A 0.444000000001s 0.11003209911764616A 0.456s 0.11003209911764616A 0.456000000001s 0.11002368240267651A 0.468s 0.11002368240267651A 0.468000000001s 0.1100284075759928A 0.48s 0.1100284075759928A 0.48000000000099996s 0.11003077016265096A 0.492s 0.11003077016265096A 0.49200000000099997s 0.11003209911764616A 0.504s 0.11003209911764616A 0.504000000001s 0.1100326897643107A 0.516s 0.1100326897643107A 0.516000000001s 0.11002412538767489A 0.528s 0.11002412538767489A 0.528000000001s 0.11002693095933144A 0.54s 0.11002693095933144A 0.540000000001s 0.1100304748393187A 0.552s 0.1100304748393187A 0.552000000001s 0.11003136080931551A 0.5640000000000001s 0.11003136080931551A 0.564000000001s 0.11003224677931234A 0.5760000000000001s 0.11003224677931234A 0.576000000001s 0.11002737394432986A 0.588s 0.11002737394432986A 0.588000000001s 0.11002442071100717A 0.6s 0.11002442071100717A 0.600000000001s 0.11002929354598963A 0.612s 0.11002929354598963A 0.612000000001s 0.11003106548598324A 0.624s 0.11003106548598324A 0.624000000001s 0.11003209911764616A 0.636s 0.11003209911764616A 0.636000000001s 0.11003106548598324A 0.648s 0.11003106548598324A 0.648000000001s 0.11002397772600876A 0.66s 0.11002397772600876A 0.660000000001s 0.1100279645909944A 0.672s 0.1100279645909944A 0.672000000001s 0.11002013852268926A 0.684s 0.11002013852268926A 0.684000000001s 0.11001925255269246A 0.6960000000000001s 0.11001925255269246A 0.696000000001s 0.11001925255269246A 0.708s 0.11001925255269246A 0.7080000000009999s 0.11001925255269246A 0.72s 0.11001925255269246A 0.720000000001s 0.11001925255269246A 0.732s 0.11001925255269246A 0.732000000001s 0.11001925255269246A 0.744s 0.11001925255269246A 0.744000000001s 0.11001925255269246A 0.756s 0.11001925255269246A 0.756000000001s 0.11001925255269246A 0.768s 0.11001925255269246A 0.768000000001s 0.11001925255269246A 0.78s 0.11001925255269246A 0.780000000001s 0.11001925255269246A 0.792s 0.11001925255269246A 0.792000000001s 0.11001925255269246A 0.804s 0.11001925255269246A 0.804000000001s 0.11001925255269246A 0.8160000000000001s 0.11001925255269246A 0.816000000001s 0.11001925255269246A 0.8280000000000001s 0.11001925255269246A 0.828000000001s 0.11001925255269246A 0.84s 0.11001925255269246A 0.840000000001s 0.11001925255269246A 0.852s 0.11001925255269246A 0.852000000001s 0.11001925255269246A 0.864s 0.11001925255269246A 0.864000000001s 0.11001925255269246A 0.876s 0.11001925255269246A 0.876000000001s 0.11001925255269246A 0.888s 0.11001925255269246A 0.888000000001s 0.11001925255269246A 0.9s 0.11001925255269246A 0.900000000001s 0.11001925255269246A 0.912s 0.11001925255269246A 0.912000000001s 0.11001925255269246A 0.924s 0.11001925255269246A 0.924000000001s 0.11001925255269246A 0.936s 0.11001925255269246A 0.936000000001s 0.11001925255269246A 0.9480000000000001s 0.11001925255269246A 0.948000000001s 0.11001925255269246A 0.96s 0.11001925255269246A 0.9600000000009999s 0.11001925255269246A 0.972s 0.11001925255269246A 0.972000000001s 0.11001925255269246A 0.984s 0.11001925255269246A 0.984000000001s 0.11001925255269246A 0.996s 0.11001925255269246A 0.996000000001s 0.11001925255269246A 1.008s 0.11001925255269246A 1.008000000001s 0.11001925255269246A 1.02s 0.11001925255269246A 1.020000000001s 0.11001925255269246A 1.032s 0.11001925255269246A 1.0320000000010001s 0.11001925255269246A 1.044s 0.11001925255269246A 1.0440000000010001s 0.11001925255269246A 1.056s 0.11001925255269246A 1.0560000000010001s 0.11001925255269246A 1.068s 0.11001925255269246A 1.0680000000010001s 0.11001940021435859A 1.08s 0.11001940021435859A 1.0800000000010002s 0.11001940021435859A 1.092s 0.11001940021435859A 1.0920000000010002s 0.11001940021435859A 1.104s 0.11001940021435859A 1.1040000000010002s 0.11001940021435859A 1.116s 0.11001940021435859A 1.1160000000010002s 0.11001940021435859A 1.1280000000000001s 0.11001940021435859A 1.1280000000010002s 0.11001940021435859A 1.1400000000000001s 0.11001940021435859A 1.1400000000010002s 0.11001940021435859A 1.1520000000000001s 0.11001940021435859A 1.1520000000010002s 0.11001940021435859A 1.164s 0.11001940021435859A 1.164000000001s 0.11001940021435859A 1.176s 0.11001940021435859A 1.176000000001s 0.11001925255269246A 1.188s 0.11001925255269246A 1.188000000001s 0.11001925255269246A 1.2s 0.11001925255269246A 1.200000000001s 0.11001925255269246A 1.212s 0.11001925255269246A 1.212000000001s 0.11001925255269246A 1.224s 0.11001925255269246A 1.224000000001s 0.11001925255269246A 1.236s 0.11001925255269246A 1.236000000001s 0.11001925255269246A 1.248s 0.11001925255269246A 1.248000000001s 0.11001925255269246A 1.26s 0.11001925255269246A 1.260000000001s 0.11001925255269246A 1.272s 0.11001925255269246A 1.272000000001s 0.11001925255269246A 1.284s 0.11001925255269246A 1.2840000000010001s 0.11001925255269246A 1.296s 0.11001925255269246A 1.2960000000010001s 0.11001925255269246A 1.308s 0.11001925255269246A 1.3080000000010001s 0.11001925255269246A 1.32s 0.11001925255269246A 1.3200000000010002s 0.11001925255269246A 1.332s 0.11001925255269246A 1.3320000000010002s 0.11001925255269246A 1.344s 0.11001925255269246A 1.3440000000010002s 0.11001925255269246A 1.356s 0.11001925255269246A 1.3560000000010002s 0.11001925255269246A 1.368s 0.11001925255269246A 1.3680000000010002s 0.11001925255269246A 1.3800000000000001s 0.11001925255269246A 1.3800000000010002s 0.11001925255269246A 1.3920000000000001s 0.11001925255269246A 1.3920000000010002s 0.11001925255269246A 1.4040000000000001s 0.11001925255269246A 1.4040000000010002s 0.11001925255269246A 1.416s 0.11001925255269246A 1.416000000001s 0.11001925255269246A 1.428s 0.11001925255269246A 1.428000000001s 0.11001925255269246A 1.44s 0.11001925255269246A 1.440000000001s 0.11001925255269246A 1.452s 0.11001925255269246A 1.452000000001s 0.11001925255269246A 1.464s 0.11001925255269246A 1.464000000001s 0.11001940021435859A 1.476s 0.11001940021435859A 1.476000000001s 0.11001940021435859A 1.488s 0.11001940021435859A 1.488000000001s 0.11001940021435859A 1.5s 0.11001940021435859A 1.500000000001s 0.11001940021435859A 1.512s 0.11001940021435859A 1.512000000001s 0.11001940021435859A 1.524s 0.11001940021435859A 1.524000000001s 0.11001940021435859A 1.536s 0.11001940021435859A 1.5360000000010001s 0.11001940021435859A 1.548s 0.11001940021435859A 1.5480000000010001s 0.11001940021435859A 1.56s 0.11001940021435859A 1.5600000000010001s 0.11001940021435859A 1.572s 0.11001940021435859A 1.5720000000010002s 0.11001925255269246A 1.584s 0.11001925255269246A 1.5840000000010002s 0.11001925255269246A 1.596s 0.11001925255269246A 1.5960000000010002s 0.11001925255269246A 1.608s 0.11001925255269246A 1.6080000000010002s 0.11001925255269246A 1.62s 0.11001925255269246A 1.6200000000010002s 0.11001925255269246A 1.6320000000000001s 0.11001925255269246A 1.6320000000010002s 0.11001925255269246A 1.6440000000000001s 0.11001925255269246A 1.6440000000010002s 0.11001925255269246A 1.6560000000000001s 0.11001925255269246A 1.6560000000010002s 0.11001925255269246A 1.668s 0.11001925255269246A 1.668000000001s 0.11001925255269246A 1.68s 0.11001925255269246A 1.680000000001s 0.11001925255269246A 1.692s 0.11001925255269246A 1.692000000001s 0.11001925255269246A 1.704s 0.11001925255269246A 1.704000000001s 0.11001925255269246A 1.716s 0.11001925255269246A 1.716000000001s 0.11001925255269246A 1.728s 0.11001925255269246A 1.728000000001s 0.11001925255269246A 1.74s 0.11001925255269246A 1.740000000001s 0.11001925255269246A 1.752s 0.11001925255269246A 1.752000000001s 0.11001925255269246A 1.764s 0.11001925255269246A 1.764000000001s 0.11001925255269246A 1.776s 0.11001925255269246A 1.7760000000010001s 0.11001925255269246A 1.788s 0.11001925255269246A 1.7880000000010001s 0.11001925255269246A 1.8s 0.11001925255269246A 1.8000000000010001s 0.11001925255269246A 1.812s 0.11001925255269246A 1.8120000000010001s 0.11001925255269246A 1.824s 0.11001925255269246A 1.8240000000010002s 0.11001925255269246A 1.836s 0.11001925255269246A 1.8360000000010002s 0.11001925255269246A 1.848s 0.11001925255269246A 1.8480000000010002s 0.11001925255269246A 1.86s 0.11001925255269246A 1.8600000000010002s 0.11001940021435859A 1.872s 0.11001940021435859A 1.8720000000010002s 0.11001954787602472A)
R_0_2_4_1 Node0_2_4 Node0_2_5 9.887809523809505
R_0_2_4_2 Node0_2_4 Node0_3_4 13.020765027322401
R_0_2_4_3 Node0_2_4 Node1_2_4 2.595018540202963
C_0_2_4 Node0_2_4 GND 0.000992414475360001
I_0_2_5 GND Node0_2_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.13841564923452407A 0.024s 0.13841564923452407A 0.024000000001s 0.13842626204206906A 0.036000000000000004s 0.13842626204206906A 0.036000000001s 0.13842844820950453A 0.048s 0.13842844820950453A 0.048000000001s 0.13843062227238634A 0.06s 0.13843062227238634A 0.060000000000999996s 0.13843040029416015A 0.07200000000000001s 0.13843040029416015A 0.07200000000100001s 0.1384161465725646A 0.084s 0.1384161465725646A 0.08400000000100001s 0.13842480715195515A 0.096s 0.13842480715195515A 0.09600000000100001s 0.13842797173789123A 0.108s 0.13842797173789123A 0.108000000001s 0.1384301517686387A 0.12s 0.1384301517686387A 0.120000000001s 0.13843109608504953A 0.132s 0.13843109608504953A 0.132000000001s 0.13841663578181493A 0.14400000000000002s 0.13841663578181493A 0.14400000000100002s 0.1384231196224914A 0.156s 0.1384231196224914A 0.156000000001s 0.13842747889896304A 0.168s 0.13842747889896304A 0.16800000000100002s 0.1384294143208648A 0.18s 0.1384294143208648A 0.180000000001s 0.13843062227238634A 0.192s 0.13843062227238634A 0.192000000001s 0.1384221673545537A 0.20400000000000001s 0.1384221673545537A 0.20400000000100002s 0.13841757946514235A 0.216s 0.13841757946514235A 0.216000000001s 0.138425804537633A 0.228s 0.138425804537633A 0.228000000001s 0.1384286880322401A 0.24s 0.1384286880322401A 0.240000000001s 0.1384301252044613A 0.252s 0.1384301252044613A 0.252000000001s 0.1384291953561154A 0.264s 0.1384291953561154A 0.264000000001s 0.1384166220059212A 0.276s 0.1384166220059212A 0.276000000001s 0.13842385043555178A 0.28800000000000003s 0.13842385043555178A 0.288000000001s 0.13842797173789123A 0.3s 0.13842797173789123A 0.30000000000099997s 0.1384301252044613A 0.312s 0.1384301252044613A 0.312000000001s 0.13843109608504953A 0.324s 0.13843109608504953A 0.324000000001s 0.13841686574533243A 0.336s 0.13841686574533243A 0.336000000001s 0.1384221673545537A 0.34800000000000003s 0.1384221673545537A 0.348000000001s 0.13842724452074429A 0.36s 0.13842724452074429A 0.36000000000099996s 0.1384291710457147A 0.372s 0.1384291710457147A 0.372000000001s 0.13843084461358027A 0.384s 0.13843084461358027A 0.384000000001s 0.13842122720805192A 0.396s 0.13842122720805192A 0.396000000001s 0.13841660513213963A 0.40800000000000003s 0.13841660513213963A 0.408000000001s 0.1384260329311038A 0.42s 0.1384260329311038A 0.42000000000099996s 0.1384286880322401A 0.432s 0.1384286880322401A 0.432000000001s 0.1384301252044613A 0.444s 0.1384301252044613A 0.444000000001s 0.1384301517686387A 0.456s 0.1384301517686387A 0.456000000001s 0.13841638137283893A 0.468s 0.13841638137283893A 0.468000000001s 0.1384240842650983A 0.48s 0.1384240842650983A 0.48000000000099996s 0.13842797173789123A 0.492s 0.13842797173789123A 0.49200000000099997s 0.1384301252044613A 0.504s 0.1384301252044613A 0.504000000001s 0.13843109608504953A 0.516s 0.13843109608504953A 0.516000000001s 0.13841712076206844A 0.528s 0.13841712076206844A 0.528000000001s 0.1384217090228887A 0.54s 0.1384217090228887A 0.540000000001s 0.13842747889896304A 0.552s 0.13842747889896304A 0.552000000001s 0.13842895268028418A 0.5640000000000001s 0.13842895268028418A 0.564000000001s 0.13843037302937047A 0.5760000000000001s 0.13843037302937047A 0.576000000001s 0.1384224138879728A 0.588s 0.1384224138879728A 0.588000000001s 0.13841760567479308A 0.6s 0.13841760567479308A 0.600000000001s 0.13842554416079128A 0.612s 0.13842554416079128A 0.612000000001s 0.1384284258743239A 0.624s 0.1384284258743239A 0.624000000001s 0.1384301517686387A 0.636s 0.1384301517686387A 0.636000000001s 0.13842847080635962A 0.648s 0.13842847080635962A 0.648000000001s 0.1384168730722171A 0.66s 0.1384168730722171A 0.660000000001s 0.13842336150485815A 0.672s 0.13842336150485815A 0.672000000001s 0.13841057353202219A 0.684s 0.13841057353202219A 0.684000000001s 0.1384091542424642A 0.6960000000000001s 0.1384091542424642A 0.696000000001s 0.13840915403388435A 0.708s 0.13840915403388435A 0.7080000000009999s 0.138409153932591A 0.72s 0.138409153932591A 0.720000000001s 0.13840915392769515A 0.732s 0.13840915392769515A 0.732000000001s 0.13840915423739952A 0.744s 0.13840915423739952A 0.744000000001s 0.13840915396584896A 0.756s 0.13840915396584896A 0.756000000001s 0.1384091539363051A 0.768s 0.1384091539363051A 0.768000000001s 0.13840915404755894A 0.78s 0.13840915404755894A 0.780000000001s 0.13840915398686734A 0.792s 0.13840915398686734A 0.792000000001s 0.13840915410597143A 0.804s 0.13840915410597143A 0.804000000001s 0.13840915105493173A 0.8160000000000001s 0.13840915105493173A 0.816000000001s 0.13840915729071832A 0.8280000000000001s 0.13840915729071832A 0.828000000001s 0.1384091573619613A 0.84s 0.1384091573619613A 0.840000000001s 0.13840915728607572A 0.852s 0.13840915728607572A 0.852000000001s 0.1384091572845563A 0.864s 0.1384091572845563A 0.864000000001s 0.1384091572845563A 0.876s 0.1384091572845563A 0.876000000001s 0.13840915726607028A 0.888s 0.13840915726607028A 0.888000000001s 0.13840915730152295A 0.9s 0.13840915730152295A 0.900000000001s 0.1384091573232166A 0.912s 0.1384091573232166A 0.912000000001s 0.13840915729536094A 0.924s 0.13840915729536094A 0.924000000001s 0.13840915235249937A 0.936s 0.13840915235249937A 0.936000000001s 0.1384091569380487A 0.9480000000000001s 0.1384091569380487A 0.948000000001s 0.13840915687625976A 0.96s 0.13840915687625976A 0.9600000000009999s 0.13840915706382126A 0.972s 0.13840915706382126A 0.972000000001s 0.13840915696978726A 0.984s 0.13840915696978726A 0.984000000001s 0.13840915697130668A 0.996s 0.13840915697130668A 0.996000000001s 0.1384091569334905A 1.008s 0.1384091569334905A 1.008000000001s 0.13840915710197507A 1.02s 0.13840915710197507A 1.020000000001s 0.13840915707150267A 1.032s 0.13840915707150267A 1.0320000000010001s 0.13840915682071725A 1.044s 0.13840915682071725A 1.0440000000010001s 0.1384091345623507A 1.056s 0.1384091345623507A 1.0560000000010001s 0.13840913333999338A 1.068s 0.13840913333999338A 1.0680000000010001s 0.13840935580966107A 1.08s 0.13840935580966107A 1.0800000000010002s 0.1384093558494187A 1.092s 0.1384093558494187A 1.0920000000010002s 0.1384093558196216A 1.104s 0.1384093558196216A 1.1040000000010002s 0.13840935576019617A 1.116s 0.13840935576019617A 1.1160000000010002s 0.13840935582755623A 1.1280000000000001s 0.13840935582755623A 1.1280000000010002s 0.13840935596303608A 1.1400000000000001s 0.13840935596303608A 1.1400000000010002s 0.13840935589913686A 1.1520000000000001s 0.13840935589913686A 1.1520000000010002s 0.13840935571275714A 1.164s 0.13840935571275714A 1.164000000001s 0.1384093558513602A 1.176s 0.1384093558513602A 1.176000000001s 0.1384091563616896A 1.188s 0.1384091563616896A 1.188000000001s 0.1384091573619613A 1.2s 0.1384091573619613A 1.200000000001s 0.13840915733562503A 1.212s 0.13840915733562503A 1.212000000001s 0.1384091573170546A 1.224s 0.1384091573170546A 1.224000000001s 0.13840915732785922A 1.236s 0.13840915732785922A 1.236000000001s 0.13840915724606484A 1.248s 0.13840915724606484A 1.248000000001s 0.13840915728919892A 1.26s 0.13840915728919892A 1.260000000001s 0.13840915726910907A 1.272s 0.13840915726910907A 1.272000000001s 0.13840915725062305A 1.284s 0.13840915725062305A 1.2840000000010001s 0.13840915731857398A 1.296s 0.13840915731857398A 1.2960000000010001s 0.13840915235030468A 1.308s 0.13840915235030468A 1.3080000000010001s 0.1384091538687762A 1.32s 0.1384091538687762A 1.3200000000010002s 0.13840915393757125A 1.332s 0.13840915393757125A 1.3320000000010002s 0.13840915400915188A 1.344s 0.13840915400915188A 1.3440000000010002s 0.1384091540177618A 1.356s 0.1384091540177618A 1.3560000000010002s 0.13840915412091218A 1.368s 0.13840915412091218A 1.3680000000010002s 0.13840915391537112A 1.3800000000000001s 0.13840915391537112A 1.3800000000010002s 0.13840915407110962A 1.3920000000000001s 0.13840915407110962A 1.3920000000010002s 0.13840915407862223A 1.4040000000000001s 0.13840915407862223A 1.4040000000010002s 0.13840915403143642A 1.416s 0.13840915403143642A 1.416000000001s 0.1384091539461812A 1.428s 0.1384091539461812A 1.428000000001s 0.1384091430013518A 1.44s 0.1384091430013518A 1.440000000001s 0.13840913318265108A 1.452s 0.13840913318265108A 1.452000000001s 0.13840913694223766A 1.464s 0.13840913694223766A 1.464000000001s 0.13840935581565428A 1.476s 0.13840935581565428A 1.476000000001s 0.13840935585937925A 1.488s 0.13840935585937925A 1.488000000001s 0.13840935567730445A 1.5s 0.13840935567730445A 1.500000000001s 0.13840935586334657A 1.512s 0.13840935586334657A 1.512000000001s 0.1384093558136284A 1.524s 0.1384093558136284A 1.524000000001s 0.13840935575817032A 1.536s 0.13840935575817032A 1.5360000000010001s 0.1384093557700723A 1.548s 0.1384093557700723A 1.5480000000010001s 0.13840935580172645A 1.56s 0.13840935580172645A 1.5600000000010001s 0.1384093559250511A 1.572s 0.1384093559250511A 1.5720000000010002s 0.13840915510058757A 1.584s 0.13840915510058757A 1.5840000000010002s 0.13840915735571488A 1.596s 0.13840915735571488A 1.5960000000010002s 0.13840915729848416A 1.608s 0.13840915729848416A 1.6080000000010002s 0.13840915734491024A 1.62s 0.13840915734491024A 1.6200000000010002s 0.13840915733714443A 1.6320000000000001s 0.13840915733714443A 1.6320000000010002s 0.13840915722757882A 1.6440000000000001s 0.13840915722757882A 1.6440000000010002s 0.13840915730928877A 1.6560000000000001s 0.13840915730928877A 1.6560000000010002s 0.13840915725678504A 1.668s 0.13840915725678504A 1.668000000001s 0.1384091572830369A 1.68s 0.1384091572830369A 1.680000000001s 0.13840915729071832A 1.692s 0.13840915729071832A 1.692000000001s 0.13840915115630947A 1.704s 0.13840915115630947A 1.704000000001s 0.13840915396956305A 1.716s 0.13840915396956305A 1.716000000001s 0.1384091541558584A 1.728s 0.1384091541558584A 1.728000000001s 0.13840915406368146A 1.74s 0.13840915406368146A 1.740000000001s 0.13840915391174144A 1.752s 0.13840915391174144A 1.752000000001s 0.13840915385164074A 1.764s 0.13840915385164074A 1.764000000001s 0.13840915396956305A 1.776s 0.13840915396956305A 1.7760000000010001s 0.13840915405372095A 1.788s 0.13840915405372095A 1.7880000000010001s 0.1384091539980096A 1.8s 0.1384091539980096A 1.8000000000010001s 0.13840915400172368A 1.812s 0.13840915400172368A 1.8120000000010001s 0.13840915393014308A 1.824s 0.13840915393014308A 1.8240000000010002s 0.13840913594652415A 1.836s 0.13840913594652415A 1.8360000000010002s 0.13840913318113168A 1.848s 0.13840913318113168A 1.8480000000010002s 0.1384091475000421A 1.86s 0.1384091475000421A 1.8600000000010002s 0.13840935581759573A 1.872s 0.13840935581759573A 1.8720000000010002s 0.1384096162146117A)
R_0_2_5_1 Node0_2_5 Node0_2_6 9.887809523809505
R_0_2_5_2 Node0_2_5 Node0_3_5 13.020765027322383
R_0_2_5_3 Node0_2_5 Node1_2_5 2.5950185402029597
C_0_2_5 Node0_2_5 GND 0.0009924144753600023
I_0_2_6 GND Node0_2_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.22116358158843266A 0.024s 0.22116358158843266A 0.024000000001s 0.22118618933372167A 0.036000000000000004s 0.22118618933372167A 0.036000000001s 0.2211908737940979A 0.048s 0.2211908737940979A 0.048000000001s 0.22119551087194325A 0.06s 0.22119551087194325A 0.060000000000999996s 0.22119507230267305A 0.07200000000000001s 0.22119507230267305A 0.07200000000100001s 0.22116466768591708A 0.084s 0.22116466768591708A 0.08400000000100001s 0.22118307636091347A 0.096s 0.22118307636091347A 0.09600000000100001s 0.22118986937695975A 0.108s 0.22118986937695975A 0.108000000001s 0.22119452981564838A 0.12s 0.22119452981564838A 0.120000000001s 0.22119650488078488A 0.132s 0.22119650488078488A 0.132000000001s 0.22116572196375212A 0.14400000000000002s 0.22116572196375212A 0.14400000000100002s 0.2211794830865222A 0.156s 0.2211794830865222A 0.156000000001s 0.2211888008909739A 0.168s 0.2211888008909739A 0.16800000000100002s 0.2211929341742239A 0.18s 0.2211929341742239A 0.180000000001s 0.22119551087194325A 0.192s 0.22119551087194325A 0.192000000001s 0.22117747689562267A 0.20400000000000001s 0.22117747689562267A 0.20400000000100002s 0.22116769455072277A 0.216s 0.22116769455072277A 0.216000000001s 0.2211852591624322A 0.228s 0.2211852591624322A 0.228000000001s 0.22119138221460274A 0.24s 0.22119138221460274A 0.240000000001s 0.22119442583180954A 0.252s 0.22119442583180954A 0.252000000001s 0.22119250740102314A 0.264s 0.22119250740102314A 0.264000000001s 0.22116566803886328A 0.276s 0.22116566803886328A 0.276000000001s 0.22118105275676855A 0.28800000000000003s 0.22118105275676855A 0.288000000001s 0.22118986937695975A 0.3s 0.22118986937695975A 0.30000000000099997s 0.22119442583180954A 0.312s 0.22119442583180954A 0.312000000001s 0.22119650488078488A 0.324s 0.22119650488078488A 0.324000000001s 0.22116619179095415A 0.336s 0.22116619179095415A 0.336000000001s 0.22117747689562267A 0.34800000000000003s 0.22117747689562267A 0.348000000001s 0.22118831378269532A 0.36s 0.22118831378269532A 0.36000000000099996s 0.2211924122394547A 0.372s 0.2211924122394547A 0.372000000001s 0.2211959508620285A 0.384s 0.2211959508620285A 0.384000000001s 0.22117551815333855A 0.396s 0.22117551815333855A 0.396000000001s 0.221165601987483A 0.40800000000000003s 0.221165601987483A 0.408000000001s 0.22118572284378293A 0.42s 0.22118572284378293A 0.42000000000099996s 0.22119138221460274A 0.432s 0.22119138221460274A 0.432000000001s 0.22119442583180954A 0.444s 0.22119442583180954A 0.444000000001s 0.22119452981564838A 0.456s 0.22119452981564838A 0.456000000001s 0.2211651564463062A 0.468s 0.2211651564463062A 0.468000000001s 0.22118153771730342A 0.48s 0.22118153771730342A 0.48000000000099996s 0.22118986937695975A 0.492s 0.22118986937695975A 0.49200000000099997s 0.22119442583180954A 0.504s 0.22119442583180954A 0.504000000001s 0.22119650488078488A 0.516s 0.22119650488078488A 0.516000000001s 0.22116675968743926A 0.528s 0.22116675968743926A 0.528000000001s 0.22117654348619648A 0.54s 0.22117654348619648A 0.540000000001s 0.2211888008909739A 0.552s 0.2211888008909739A 0.552000000001s 0.22119198781225094A 0.5640000000000001s 0.22119198781225094A 0.564000000001s 0.22119496557633064A 0.5760000000000001s 0.22119496557633064A 0.576000000001s 0.22117801158468545A 0.588s 0.22117801158468545A 0.588000000001s 0.22116779714678875A 0.6s 0.22116779714678875A 0.600000000001s 0.22118467028414293A 0.612s 0.22118467028414293A 0.612000000001s 0.22119078636440692A 0.624s 0.22119078636440692A 0.624000000001s 0.22119452981564838A 0.636s 0.22119452981564838A 0.636000000001s 0.22119096224809753A 0.648s 0.22119096224809753A 0.648000000001s 0.2211662204715936A 0.66s 0.2211662204715936A 0.660000000001s 0.22117999956932655A 0.672s 0.22117999956932655A 0.672000000001s 0.22115275043087945A 0.684s 0.22115275043087945A 0.684000000001s 0.22114977681425807A 0.6960000000000001s 0.22114977681425807A 0.696000000001s 0.22114977599778504A 0.708s 0.22114977599778504A 0.7080000000009999s 0.22114977560127852A 0.72s 0.22114977560127852A 0.720000000001s 0.22114977558211402A 0.732s 0.22114977558211402A 0.732000000001s 0.22114977679443273A 0.744s 0.22114977679443273A 0.744000000001s 0.22114977573146483A 0.756s 0.22114977573146483A 0.756000000001s 0.22114977561581708A 0.768s 0.22114977561581708A 0.768000000001s 0.22114977605131342A 0.78s 0.22114977605131342A 0.780000000001s 0.22114977581373993A 0.792s 0.22114977581373993A 0.792000000001s 0.22114977627996552A 0.804s 0.22114977627996552A 0.804000000001s 0.22114976433685823A 0.8160000000000001s 0.22114976433685823A 0.816000000001s 0.2211497887464614A 0.8280000000000001s 0.2211497887464614A 0.828000000001s 0.2211497890253377A 0.84s 0.2211497890253377A 0.840000000001s 0.2211497887282882A 0.852s 0.2211497887282882A 0.852000000001s 0.2211497887223406A 0.864s 0.2211497887223406A 0.864000000001s 0.2211497887223406A 0.876s 0.2211497887223406A 0.876000000001s 0.2211497886499781A 0.888s 0.2211497886499781A 0.888000000001s 0.22114978878875544A 0.9s 0.22114978878875544A 0.900000000001s 0.22114978887367395A 0.912s 0.22114978887367395A 0.912000000001s 0.22114978876463465A 0.924s 0.22114978876463465A 0.924000000001s 0.22114976941610698A 0.936s 0.22114976941610698A 0.936000000001s 0.22114978736595783A 0.9480000000000001s 0.22114978736595783A 0.948000000001s 0.2211497871240888A 0.96s 0.2211497871240888A 0.9600000000009999s 0.22114978785828676A 0.972s 0.22114978785828676A 0.972000000001s 0.22114978749019654A 0.984s 0.22114978749019654A 0.984000000001s 0.22114978749614414A 0.996s 0.22114978749614414A 0.996000000001s 0.22114978734811505A 1.008s 0.22114978734811505A 1.008000000001s 0.22114978800763754A 1.02s 0.22114978800763754A 1.020000000001s 0.22114978788835518A 1.032s 0.22114978788835518A 1.0320000000010001s 0.2211497869066711A 1.044s 0.2211497869066711A 1.0440000000010001s 0.22114969977766416A 1.056s 0.22114969977766416A 1.0560000000010001s 0.22114969499282158A 1.068s 0.22114969499282158A 1.0680000000010001s 0.22115013548580928A 1.08s 0.22115013548580928A 1.0800000000010002s 0.2211501356414381A 1.092s 0.2211501356414381A 1.0920000000010002s 0.22115013552479906A 1.104s 0.22115013552479906A 1.1040000000010002s 0.22115013529218192A 1.116s 0.22115013529218192A 1.1160000000010002s 0.22115013555585877A 1.1280000000000001s 0.22115013555585877A 1.1280000000010002s 0.22115013608618628A 1.1400000000000001s 0.22115013608618628A 1.1400000000010002s 0.22115013583605672A 1.1520000000000001s 0.22115013583605672A 1.1520000000010002s 0.2211501351064847A 1.164s 0.2211501351064847A 1.164000000001s 0.22115013564903782A 1.176s 0.22115013564903782A 1.176000000001s 0.22114978510983566A 1.188s 0.22114978510983566A 1.188000000001s 0.2211497890253377A 1.2s 0.2211497890253377A 1.200000000001s 0.22114978892224596A 1.212s 0.22114978892224596A 1.212000000001s 0.22114978884955314A 1.224s 0.22114978884955314A 1.224000000001s 0.22114978889184714A 1.236s 0.22114978889184714A 1.236000000001s 0.22114978857166812A 1.248s 0.22114978857166812A 1.248000000001s 0.2211497887405138A 1.26s 0.2211497887405138A 1.260000000001s 0.22114978866187332A 1.272s 0.22114978866187332A 1.272000000001s 0.2211497885895109A 1.284s 0.2211497885895109A 1.2840000000010001s 0.2211497888555007A 1.296s 0.2211497888555007A 1.2960000000010001s 0.221149769407516A 1.308s 0.221149769407516A 1.3080000000010001s 0.2211497753514794A 1.32s 0.2211497753514794A 1.3200000000010002s 0.2211497756207734A 1.332s 0.2211497756207734A 1.3320000000010002s 0.22114977590097137A 1.344s 0.22114977590097137A 1.3440000000010002s 0.22114977593467441A 1.356s 0.22114977593467441A 1.3560000000010002s 0.22114977633845023A 1.368s 0.22114977633845023A 1.3680000000010002s 0.22114977553387238A 1.3800000000000001s 0.22114977553387238A 1.3800000000010002s 0.2211497761435012A 1.3920000000000001s 0.2211497761435012A 1.3920000000010002s 0.2211497761729088A 1.4040000000000001s 0.2211497761729088A 1.4040000000010002s 0.2211497759882028A 1.416s 0.2211497759882028A 1.416000000001s 0.2211497756544765A 1.428s 0.2211497756544765A 1.428000000001s 0.2211497328116149A 1.44s 0.2211497328116149A 1.440000000001s 0.22114969437691476A 1.452s 0.22114969437691476A 1.452000000001s 0.2211497090935852A 1.464s 0.2211497090935852A 1.464000000001s 0.22115013550926926A 1.476s 0.22115013550926926A 1.476000000001s 0.2211501356804279A 1.488s 0.2211501356804279A 1.488000000001s 0.2211501349677074A 1.5s 0.2211501349677074A 1.500000000001s 0.2211501356959578A 1.512s 0.2211501356959578A 1.512000000001s 0.22115013550133913A 1.524s 0.22115013550133913A 1.524000000001s 0.22115013528425181A 1.536s 0.22115013528425181A 1.5360000000010001s 0.22115013533084135A 1.548s 0.22115013533084135A 1.5480000000010001s 0.22115013545474965A 1.56s 0.22115013545474965A 1.5600000000010001s 0.22115013593749636A 1.572s 0.22115013593749636A 1.5720000000010002s 0.22114978017332929A 1.584s 0.22114978017332929A 1.5840000000010002s 0.22114978900088644A 1.596s 0.22114978900088644A 1.5960000000010002s 0.22114978877686026A 1.608s 0.22114978877686026A 1.6080000000010002s 0.22114978895859239A 1.62s 0.22114978895859239A 1.6200000000010002s 0.2211497889281936A 1.6320000000000001s 0.2211497889281936A 1.6320000000010002s 0.22114978849930567A 1.6440000000000001s 0.22114978849930567A 1.6440000000010002s 0.22114978881915423A 1.6560000000000001s 0.22114978881915423A 1.6560000000010002s 0.2211497886136317A 1.668s 0.2211497886136317A 1.668000000001s 0.221149788716393A 1.68s 0.221149788716393A 1.680000000001s 0.2211497887464614A 1.692s 0.2211497887464614A 1.692000000001s 0.2211497647336952A 1.704s 0.2211497647336952A 1.704000000001s 0.2211497757460034A 1.716s 0.2211497757460034A 1.716000000001s 0.22114977647524497A 1.728s 0.22114977647524497A 1.728000000001s 0.22114977611442405A 1.74s 0.22114977611442405A 1.740000000001s 0.22114977551966422A 1.752s 0.22114977551966422A 1.752000000001s 0.22114977528440372A 1.764s 0.22114977528440372A 1.764000000001s 0.2211497757460034A 1.776s 0.2211497757460034A 1.7760000000010001s 0.22114977607543423A 1.788s 0.22114977607543423A 1.7880000000010001s 0.22114977585735562A 1.8s 0.22114977585735562A 1.8000000000010001s 0.22114977587189416A 1.812s 0.22114977587189416A 1.8120000000010001s 0.22114977559169627A 1.824s 0.22114977559169627A 1.8240000000010002s 0.221149705195926A 1.836s 0.221149705195926A 1.8360000000010002s 0.22114969437096713A 1.848s 0.22114969437096713A 1.8480000000010002s 0.2211497504214614A 1.86s 0.2211497504214614A 1.8600000000010002s 0.22115013551686896A 1.872s 0.22115013551686896A 1.8720000000010002s 0.22115072447412915A)
R_0_2_6_1 Node0_2_6 Node0_2_7 9.887809523809512
R_0_2_6_2 Node0_2_6 Node0_3_6 13.020765027322401
R_0_2_6_3 Node0_2_6 Node1_2_6 2.595018540202963
C_0_2_6 Node0_2_6 GND 0.0009924144753600012
I_0_2_7 GND Node0_2_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.22116358158843266A 0.024s 0.22116358158843266A 0.024000000001s 0.22118618933372167A 0.036000000000000004s 0.22118618933372167A 0.036000000001s 0.2211908737940979A 0.048s 0.2211908737940979A 0.048000000001s 0.22119551087194325A 0.06s 0.22119551087194325A 0.060000000000999996s 0.22119507230267305A 0.07200000000000001s 0.22119507230267305A 0.07200000000100001s 0.22116466768591708A 0.084s 0.22116466768591708A 0.08400000000100001s 0.22118307636091347A 0.096s 0.22118307636091347A 0.09600000000100001s 0.22118986937695975A 0.108s 0.22118986937695975A 0.108000000001s 0.22119452981564838A 0.12s 0.22119452981564838A 0.120000000001s 0.22119650488078488A 0.132s 0.22119650488078488A 0.132000000001s 0.22116572196375212A 0.14400000000000002s 0.22116572196375212A 0.14400000000100002s 0.2211794830865222A 0.156s 0.2211794830865222A 0.156000000001s 0.2211888008909739A 0.168s 0.2211888008909739A 0.16800000000100002s 0.2211929341742239A 0.18s 0.2211929341742239A 0.180000000001s 0.22119551087194325A 0.192s 0.22119551087194325A 0.192000000001s 0.22117747689562267A 0.20400000000000001s 0.22117747689562267A 0.20400000000100002s 0.22116769455072277A 0.216s 0.22116769455072277A 0.216000000001s 0.2211852591624322A 0.228s 0.2211852591624322A 0.228000000001s 0.22119138221460274A 0.24s 0.22119138221460274A 0.240000000001s 0.22119442583180954A 0.252s 0.22119442583180954A 0.252000000001s 0.22119250740102314A 0.264s 0.22119250740102314A 0.264000000001s 0.22116566803886328A 0.276s 0.22116566803886328A 0.276000000001s 0.22118105275676855A 0.28800000000000003s 0.22118105275676855A 0.288000000001s 0.22118986937695975A 0.3s 0.22118986937695975A 0.30000000000099997s 0.22119442583180954A 0.312s 0.22119442583180954A 0.312000000001s 0.22119650488078488A 0.324s 0.22119650488078488A 0.324000000001s 0.22116619179095415A 0.336s 0.22116619179095415A 0.336000000001s 0.22117747689562267A 0.34800000000000003s 0.22117747689562267A 0.348000000001s 0.22118831378269532A 0.36s 0.22118831378269532A 0.36000000000099996s 0.2211924122394547A 0.372s 0.2211924122394547A 0.372000000001s 0.2211959508620285A 0.384s 0.2211959508620285A 0.384000000001s 0.22117551815333855A 0.396s 0.22117551815333855A 0.396000000001s 0.221165601987483A 0.40800000000000003s 0.221165601987483A 0.408000000001s 0.22118572284378293A 0.42s 0.22118572284378293A 0.42000000000099996s 0.22119138221460274A 0.432s 0.22119138221460274A 0.432000000001s 0.22119442583180954A 0.444s 0.22119442583180954A 0.444000000001s 0.22119452981564838A 0.456s 0.22119452981564838A 0.456000000001s 0.2211651564463062A 0.468s 0.2211651564463062A 0.468000000001s 0.22118153771730342A 0.48s 0.22118153771730342A 0.48000000000099996s 0.22118986937695975A 0.492s 0.22118986937695975A 0.49200000000099997s 0.22119442583180954A 0.504s 0.22119442583180954A 0.504000000001s 0.22119650488078488A 0.516s 0.22119650488078488A 0.516000000001s 0.22116675968743926A 0.528s 0.22116675968743926A 0.528000000001s 0.22117654348619648A 0.54s 0.22117654348619648A 0.540000000001s 0.2211888008909739A 0.552s 0.2211888008909739A 0.552000000001s 0.22119198781225094A 0.5640000000000001s 0.22119198781225094A 0.564000000001s 0.22119496557633064A 0.5760000000000001s 0.22119496557633064A 0.576000000001s 0.22117801158468545A 0.588s 0.22117801158468545A 0.588000000001s 0.22116779714678875A 0.6s 0.22116779714678875A 0.600000000001s 0.22118467028414293A 0.612s 0.22118467028414293A 0.612000000001s 0.22119078636440692A 0.624s 0.22119078636440692A 0.624000000001s 0.22119452981564838A 0.636s 0.22119452981564838A 0.636000000001s 0.22119096224809753A 0.648s 0.22119096224809753A 0.648000000001s 0.2211662204715936A 0.66s 0.2211662204715936A 0.660000000001s 0.22117999956932655A 0.672s 0.22117999956932655A 0.672000000001s 0.22115275043087945A 0.684s 0.22115275043087945A 0.684000000001s 0.22114977681425807A 0.6960000000000001s 0.22114977681425807A 0.696000000001s 0.22114977599778504A 0.708s 0.22114977599778504A 0.7080000000009999s 0.22114977560127852A 0.72s 0.22114977560127852A 0.720000000001s 0.22114977558211402A 0.732s 0.22114977558211402A 0.732000000001s 0.22114977679443273A 0.744s 0.22114977679443273A 0.744000000001s 0.22114977573146483A 0.756s 0.22114977573146483A 0.756000000001s 0.22114977561581708A 0.768s 0.22114977561581708A 0.768000000001s 0.22114977605131342A 0.78s 0.22114977605131342A 0.780000000001s 0.22114977581373993A 0.792s 0.22114977581373993A 0.792000000001s 0.22114977627996552A 0.804s 0.22114977627996552A 0.804000000001s 0.22114976433685823A 0.8160000000000001s 0.22114976433685823A 0.816000000001s 0.2211497887464614A 0.8280000000000001s 0.2211497887464614A 0.828000000001s 0.2211497890253377A 0.84s 0.2211497890253377A 0.840000000001s 0.2211497887282882A 0.852s 0.2211497887282882A 0.852000000001s 0.2211497887223406A 0.864s 0.2211497887223406A 0.864000000001s 0.2211497887223406A 0.876s 0.2211497887223406A 0.876000000001s 0.2211497886499781A 0.888s 0.2211497886499781A 0.888000000001s 0.22114978878875544A 0.9s 0.22114978878875544A 0.900000000001s 0.22114978887367395A 0.912s 0.22114978887367395A 0.912000000001s 0.22114978876463465A 0.924s 0.22114978876463465A 0.924000000001s 0.22114976941610698A 0.936s 0.22114976941610698A 0.936000000001s 0.22114978736595783A 0.9480000000000001s 0.22114978736595783A 0.948000000001s 0.2211497871240888A 0.96s 0.2211497871240888A 0.9600000000009999s 0.22114978785828676A 0.972s 0.22114978785828676A 0.972000000001s 0.22114978749019654A 0.984s 0.22114978749019654A 0.984000000001s 0.22114978749614414A 0.996s 0.22114978749614414A 0.996000000001s 0.22114978734811505A 1.008s 0.22114978734811505A 1.008000000001s 0.22114978800763754A 1.02s 0.22114978800763754A 1.020000000001s 0.22114978788835518A 1.032s 0.22114978788835518A 1.0320000000010001s 0.2211497869066711A 1.044s 0.2211497869066711A 1.0440000000010001s 0.22114969977766416A 1.056s 0.22114969977766416A 1.0560000000010001s 0.22114969499282158A 1.068s 0.22114969499282158A 1.0680000000010001s 0.22115013548580928A 1.08s 0.22115013548580928A 1.0800000000010002s 0.2211501356414381A 1.092s 0.2211501356414381A 1.0920000000010002s 0.22115013552479906A 1.104s 0.22115013552479906A 1.1040000000010002s 0.22115013529218192A 1.116s 0.22115013529218192A 1.1160000000010002s 0.22115013555585877A 1.1280000000000001s 0.22115013555585877A 1.1280000000010002s 0.22115013608618628A 1.1400000000000001s 0.22115013608618628A 1.1400000000010002s 0.22115013583605672A 1.1520000000000001s 0.22115013583605672A 1.1520000000010002s 0.2211501351064847A 1.164s 0.2211501351064847A 1.164000000001s 0.22115013564903782A 1.176s 0.22115013564903782A 1.176000000001s 0.22114978510983566A 1.188s 0.22114978510983566A 1.188000000001s 0.2211497890253377A 1.2s 0.2211497890253377A 1.200000000001s 0.22114978892224596A 1.212s 0.22114978892224596A 1.212000000001s 0.22114978884955314A 1.224s 0.22114978884955314A 1.224000000001s 0.22114978889184714A 1.236s 0.22114978889184714A 1.236000000001s 0.22114978857166812A 1.248s 0.22114978857166812A 1.248000000001s 0.2211497887405138A 1.26s 0.2211497887405138A 1.260000000001s 0.22114978866187332A 1.272s 0.22114978866187332A 1.272000000001s 0.2211497885895109A 1.284s 0.2211497885895109A 1.2840000000010001s 0.2211497888555007A 1.296s 0.2211497888555007A 1.2960000000010001s 0.221149769407516A 1.308s 0.221149769407516A 1.3080000000010001s 0.2211497753514794A 1.32s 0.2211497753514794A 1.3200000000010002s 0.2211497756207734A 1.332s 0.2211497756207734A 1.3320000000010002s 0.22114977590097137A 1.344s 0.22114977590097137A 1.3440000000010002s 0.22114977593467441A 1.356s 0.22114977593467441A 1.3560000000010002s 0.22114977633845023A 1.368s 0.22114977633845023A 1.3680000000010002s 0.22114977553387238A 1.3800000000000001s 0.22114977553387238A 1.3800000000010002s 0.2211497761435012A 1.3920000000000001s 0.2211497761435012A 1.3920000000010002s 0.2211497761729088A 1.4040000000000001s 0.2211497761729088A 1.4040000000010002s 0.2211497759882028A 1.416s 0.2211497759882028A 1.416000000001s 0.2211497756544765A 1.428s 0.2211497756544765A 1.428000000001s 0.2211497328116149A 1.44s 0.2211497328116149A 1.440000000001s 0.22114969437691476A 1.452s 0.22114969437691476A 1.452000000001s 0.2211497090935852A 1.464s 0.2211497090935852A 1.464000000001s 0.22115013550926926A 1.476s 0.22115013550926926A 1.476000000001s 0.2211501356804279A 1.488s 0.2211501356804279A 1.488000000001s 0.2211501349677074A 1.5s 0.2211501349677074A 1.500000000001s 0.2211501356959578A 1.512s 0.2211501356959578A 1.512000000001s 0.22115013550133913A 1.524s 0.22115013550133913A 1.524000000001s 0.22115013528425181A 1.536s 0.22115013528425181A 1.5360000000010001s 0.22115013533084135A 1.548s 0.22115013533084135A 1.5480000000010001s 0.22115013545474965A 1.56s 0.22115013545474965A 1.5600000000010001s 0.22115013593749636A 1.572s 0.22115013593749636A 1.5720000000010002s 0.22114978017332929A 1.584s 0.22114978017332929A 1.5840000000010002s 0.22114978900088644A 1.596s 0.22114978900088644A 1.5960000000010002s 0.22114978877686026A 1.608s 0.22114978877686026A 1.6080000000010002s 0.22114978895859239A 1.62s 0.22114978895859239A 1.6200000000010002s 0.2211497889281936A 1.6320000000000001s 0.2211497889281936A 1.6320000000010002s 0.22114978849930567A 1.6440000000000001s 0.22114978849930567A 1.6440000000010002s 0.22114978881915423A 1.6560000000000001s 0.22114978881915423A 1.6560000000010002s 0.2211497886136317A 1.668s 0.2211497886136317A 1.668000000001s 0.221149788716393A 1.68s 0.221149788716393A 1.680000000001s 0.2211497887464614A 1.692s 0.2211497887464614A 1.692000000001s 0.2211497647336952A 1.704s 0.2211497647336952A 1.704000000001s 0.2211497757460034A 1.716s 0.2211497757460034A 1.716000000001s 0.22114977647524497A 1.728s 0.22114977647524497A 1.728000000001s 0.22114977611442405A 1.74s 0.22114977611442405A 1.740000000001s 0.22114977551966422A 1.752s 0.22114977551966422A 1.752000000001s 0.22114977528440372A 1.764s 0.22114977528440372A 1.764000000001s 0.2211497757460034A 1.776s 0.2211497757460034A 1.7760000000010001s 0.22114977607543423A 1.788s 0.22114977607543423A 1.7880000000010001s 0.22114977585735562A 1.8s 0.22114977585735562A 1.8000000000010001s 0.22114977587189416A 1.812s 0.22114977587189416A 1.8120000000010001s 0.22114977559169627A 1.824s 0.22114977559169627A 1.8240000000010002s 0.221149705195926A 1.836s 0.221149705195926A 1.8360000000010002s 0.22114969437096713A 1.848s 0.22114969437096713A 1.8480000000010002s 0.2211497504214614A 1.86s 0.2211497504214614A 1.8600000000010002s 0.22115013551686896A 1.872s 0.22115013551686896A 1.8720000000010002s 0.22115072447412915A)
R_0_2_7_1 Node0_2_7 Node0_2_8 9.887809523809516
R_0_2_7_2 Node0_2_7 Node0_3_7 13.020765027322401
R_0_2_7_3 Node0_2_7 Node1_2_7 2.595018540202963
C_0_2_7 Node0_2_7 GND 0.0009924144753600012
I_0_2_8 GND Node0_2_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.05975889276770481A 0.024s 0.05975889276770481A 0.024000000001s 0.059763340193007566A 0.036000000000000004s 0.059763340193007566A 0.036000000001s 0.059764261726196324A 0.048s 0.059764261726196324A 0.048000000001s 0.05976517393823148A 0.06s 0.05976517393823148A 0.060000000000999996s 0.059765087662309466A 0.07200000000000001s 0.059765087662309466A 0.07200000000100001s 0.05975910642622634A 0.084s 0.05975910642622634A 0.08400000000100001s 0.05976272780491415A 0.096s 0.05976272780491415A 0.09600000000100001s 0.05976406413593964A 0.108s 0.05976406413593964A 0.108000000001s 0.059764980943550525A 0.12s 0.059764980943550525A 0.120000000001s 0.05976536948095443A 0.132s 0.05976536948095443A 0.132000000001s 0.0597593138251447A 0.14400000000000002s 0.0597593138251447A 0.14400000000100002s 0.0597620209312634A 0.156s 0.0597620209312634A 0.156000000001s 0.05976385394197521A 0.168s 0.05976385394197521A 0.16800000000100002s 0.05976466704687686A 0.18s 0.05976466704687686A 0.180000000001s 0.05976517393823148A 0.192s 0.05976517393823148A 0.192000000001s 0.05976162627075858A 0.20400000000000001s 0.05976162627075858A 0.20400000000100002s 0.059759701875040566A 0.216s 0.059759701875040566A 0.216000000001s 0.059763157208491596A 0.228s 0.059763157208491596A 0.228000000001s 0.05976436174334482A 0.24s 0.05976436174334482A 0.240000000001s 0.059764960487713376A 0.252s 0.059764960487713376A 0.252000000001s 0.0597645830914931A 0.264s 0.0597645830914931A 0.264000000001s 0.059759303216969845A 0.276s 0.059759303216969845A 0.276000000001s 0.059762329718852855A 0.28800000000000003s 0.059762329718852855A 0.288000000001s 0.05976406413593964A 0.3s 0.05976406413593964A 0.30000000000099997s 0.059764960487713376A 0.312s 0.059764960487713376A 0.312000000001s 0.05976536948095443A 0.324s 0.05976536948095443A 0.324000000001s 0.059759406250168054A 0.336s 0.059759406250168054A 0.336000000001s 0.05976162627075858A 0.34800000000000003s 0.05976162627075858A 0.348000000001s 0.059763758117395815A 0.36s 0.059763758117395815A 0.36000000000099996s 0.05976456437118455A 0.372s 0.05976456437118455A 0.372000000001s 0.05976526049365809A 0.384s 0.05976526049365809A 0.384000000001s 0.0597612409444076A 0.396s 0.0597612409444076A 0.396000000001s 0.0597592902232557A 0.40800000000000003s 0.0597592902232557A 0.408000000001s 0.05976324842449503A 0.42s 0.05976324842449503A 0.42000000000099996s 0.05976436174334482A 0.432s 0.05976436174334482A 0.432000000001s 0.059764960487713376A 0.444s 0.059764960487713376A 0.444000000001s 0.059764980943550525A 0.456s 0.059764980943550525A 0.456000000001s 0.05975920257581108A 0.468s 0.05975920257581108A 0.468000000001s 0.05976242512092528A 0.48s 0.05976242512092528A 0.48000000000099996s 0.05976406413593964A 0.492s 0.05976406413593964A 0.49200000000099997s 0.059764960487713376A 0.504s 0.059764960487713376A 0.504000000001s 0.05976536948095443A 0.516s 0.05976536948095443A 0.516000000001s 0.059759517967509376A 0.528s 0.059759517967509376A 0.528000000001s 0.05976144264923211A 0.54s 0.05976144264923211A 0.540000000001s 0.05976385394197521A 0.552s 0.05976385394197521A 0.552000000001s 0.0597644808773084A 0.5640000000000001s 0.0597644808773084A 0.564000000001s 0.05976506666696342A 0.5760000000000001s 0.05976506666696342A 0.576000000001s 0.05976173145549224A 0.588s 0.05976173145549224A 0.588000000001s 0.05975972205787322A 0.6s 0.05975972205787322A 0.600000000001s 0.05976304136358224A 0.612s 0.05976304136358224A 0.612000000001s 0.059764244526912855A 0.624s 0.059764244526912855A 0.624000000001s 0.059764980943550525A 0.636s 0.059764980943550525A 0.636000000001s 0.059764279126983136A 0.648s 0.059764279126983136A 0.648000000001s 0.059759411892261055A 0.66s 0.059759411892261055A 0.660000000001s 0.059762122534438036A 0.672s 0.059762122534438036A 0.672000000001s 0.05975676204818614A 0.684s 0.05975676204818614A 0.684000000001s 0.05975617707442456A 0.6960000000000001s 0.05975617707442456A 0.696000000001s 0.05975617691380691A 0.708s 0.05975617691380691A 0.7080000000009999s 0.05975617683580563A 0.72s 0.05975617683580563A 0.720000000001s 0.05975617683203556A 0.732s 0.05975617683203556A 0.732000000001s 0.0597561770705245A 0.744s 0.0597561770705245A 0.744000000001s 0.05975617686141606A 0.756s 0.05975617686141606A 0.756000000001s 0.05975617683866567A 0.768s 0.05975617683866567A 0.768000000001s 0.05975617692433709A 0.78s 0.05975617692433709A 0.780000000001s 0.05975617687760132A 0.792s 0.05975617687760132A 0.792000000001s 0.05975617696931783A 0.804s 0.05975617696931783A 0.804000000001s 0.05975617461985411A 0.8160000000000001s 0.05975617461985411A 0.816000000001s 0.059756179421743244A 0.8280000000000001s 0.059756179421743244A 0.828000000001s 0.05975617947660415A 0.84s 0.05975617947660415A 0.840000000001s 0.05975617941816819A 0.852s 0.05975617941816819A 0.852000000001s 0.059756179416998165A 0.864s 0.059756179416998165A 0.864000000001s 0.059756179416998165A 0.876s 0.059756179416998165A 0.876000000001s 0.05975617940276293A 0.888s 0.05975617940276293A 0.888000000001s 0.05975617943006338A 0.9s 0.05975617943006338A 0.900000000001s 0.05975617944676867A 0.912s 0.05975617944676867A 0.912000000001s 0.059756179425318315A 0.924s 0.059756179425318315A 0.924000000001s 0.05975617561905057A 0.936s 0.05975617561905057A 0.936000000001s 0.05975617915016877A 0.9480000000000001s 0.05975617915016877A 0.948000000001s 0.059756179102587986A 0.96s 0.059756179102587986A 0.9600000000009999s 0.05975617924702037A 0.972s 0.05975617924702037A 0.972000000001s 0.05975617917460917A 0.984s 0.05975617917460917A 0.984000000001s 0.0597561791757792A 0.996s 0.0597561791757792A 0.996000000001s 0.05975617914665872A 1.008s 0.05975617914665872A 1.008000000001s 0.05975617927640085A 1.02s 0.05975617927640085A 1.020000000001s 0.05975617925293547A 1.032s 0.05975617925293547A 1.0320000000010001s 0.05975617905981728A 1.044s 0.05975617905981728A 1.0440000000010001s 0.059756161919684775A 1.056s 0.059756161919684775A 1.0560000000010001s 0.05975616097840426A 1.068s 0.05975616097840426A 1.0680000000010001s 0.05975624763276251A 1.08s 0.05975624763276251A 1.0800000000010002s 0.059756247663378004A 1.092s 0.059756247663378004A 1.0920000000010002s 0.05975624764043262A 1.104s 0.05975624764043262A 1.1040000000010002s 0.05975624759467188A 1.116s 0.05975624759467188A 1.1160000000010002s 0.059756247646542734A 1.1280000000000001s 0.059756247646542734A 1.1280000000010002s 0.05975624775086945A 1.1400000000000001s 0.05975624775086945A 1.1400000000010002s 0.05975624770166364A 1.1520000000000001s 0.05975624770166364A 1.1520000000010002s 0.05975624755814128A 1.164s 0.05975624755814128A 1.164000000001s 0.05975624766487303A 1.176s 0.05975624766487303A 1.176000000001s 0.059756178706341465A 1.188s 0.059756178706341465A 1.188000000001s 0.05975617947660415A 1.2s 0.05975617947660415A 1.200000000001s 0.05975617945632382A 1.212s 0.05975617945632382A 1.212000000001s 0.05975617944202359A 1.224s 0.05975617944202359A 1.224000000001s 0.05975617945034371A 1.236s 0.05975617945034371A 1.236000000001s 0.05975617938735768A 1.248s 0.05975617938735768A 1.248000000001s 0.05975617942057322A 1.26s 0.05975617942057322A 1.260000000001s 0.05975617940510297A 1.272s 0.05975617940510297A 1.272000000001s 0.059756179390867734A 1.284s 0.059756179390867734A 1.2840000000010001s 0.0597561794431936A 1.296s 0.0597561794431936A 1.2960000000010001s 0.059756175617360546A 1.308s 0.059756175617360546A 1.3080000000010001s 0.059756176786664825A 1.32s 0.059756176786664825A 1.3200000000010002s 0.059756176839640684A 1.332s 0.059756176839640684A 1.3320000000010002s 0.059756176894761606A 1.344s 0.059756176894761606A 1.3440000000010002s 0.059756176901391705A 1.356s 0.059756176901391705A 1.3560000000010002s 0.059756176980823014A 1.368s 0.059756176980823014A 1.3680000000010002s 0.0597561768225454A 1.3800000000000001s 0.0597561768225454A 1.3800000000010002s 0.059756176942472386A 1.3920000000000001s 0.059756176942472386A 1.3920000000010002s 0.05975617694825748A 1.4040000000000001s 0.05975617694825748A 1.4040000000010002s 0.05975617691192188A 1.416s 0.05975617691192188A 1.416000000001s 0.0597561768462708A 1.428s 0.0597561768462708A 1.428000000001s 0.05975616841816689A 1.44s 0.05975616841816689A 1.440000000001s 0.059756160857242266A 1.452s 0.059756160857242266A 1.452000000001s 0.05975616375232498A 1.464s 0.05975616375232498A 1.464000000001s 0.05975624763737758A 1.476s 0.05975624763737758A 1.476000000001s 0.05975624767104813A 1.488s 0.05975624767104813A 1.488000000001s 0.059756247530840814A 1.5s 0.059756247530840814A 1.500000000001s 0.05975624767410319A 1.512s 0.05975624767410319A 1.512000000001s 0.05975624763581755A 1.524s 0.05975624763581755A 1.524000000001s 0.05975624759311185A 1.536s 0.05975624759311185A 1.5360000000010001s 0.059756247602277004A 1.548s 0.059756247602277004A 1.5480000000010001s 0.05975624762665241A 1.56s 0.05975624762665241A 1.5600000000010001s 0.05975624772161897A 1.572s 0.05975624772161897A 1.5720000000010002s 0.05975617773522546A 1.584s 0.05975617773522546A 1.5840000000010002s 0.05975617947179407A 1.596s 0.05975617947179407A 1.5960000000010002s 0.05975617942772335A 1.608s 0.05975617942772335A 1.6080000000010002s 0.05975617946347393A 1.62s 0.05975617946347393A 1.6200000000010002s 0.05975617945749384A 1.6320000000000001s 0.05975617945749384A 1.6320000000010002s 0.05975617937312244A 1.6440000000000001s 0.05975617937312244A 1.6440000000010002s 0.05975617943604347A 1.6560000000000001s 0.05975617943604347A 1.6560000000010002s 0.05975617939561281A 1.668s 0.05975617939561281A 1.668000000001s 0.059756179415828156A 1.68s 0.059756179415828156A 1.680000000001s 0.059756179421743244A 1.692s 0.059756179421743244A 1.692000000001s 0.05975617469792038A 1.704s 0.05975617469792038A 1.704000000001s 0.05975617686427609A 1.716s 0.05975617686427609A 1.716000000001s 0.05975617700773346A 1.728s 0.05975617700773346A 1.728000000001s 0.059756176936752295A 1.74s 0.059756176936752295A 1.740000000001s 0.05975617681975036A 1.752s 0.05975617681975036A 1.752000000001s 0.0597561767734696A 1.764s 0.0597561767734696A 1.764000000001s 0.05975617686427609A 1.776s 0.05975617686427609A 1.7760000000010001s 0.059756176929082166A 1.788s 0.059756176929082166A 1.7880000000010001s 0.059756176886181456A 1.8s 0.059756176886181456A 1.8000000000010001s 0.0597561768890415A 1.812s 0.0597561768890415A 1.8120000000010001s 0.05975617683392059A 1.824s 0.05975617683392059A 1.8240000000010002s 0.05975616298557235A 1.836s 0.05975616298557235A 1.8360000000010002s 0.059756160856072243A 1.848s 0.059756160856072243A 1.8480000000010002s 0.059756171882398984A 1.86s 0.059756171882398984A 1.8600000000010002s 0.059756247638872606A 1.872s 0.059756247638872606A 1.8720000000010002s 0.05975636349931723A)
R_0_2_8_1 Node0_2_8 Node0_2_9 9.887809523809516
R_0_2_8_2 Node0_2_8 Node0_3_8 13.020765027322415
R_0_2_8_3 Node0_2_8 Node1_2_8 2.595018540202965
C_0_2_8 Node0_2_8 GND 0.0009924144753600003
I_0_2_9 GND Node0_2_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.020231213872832953A 0.024s 0.020231213872832953A 0.024000000001s 0.020231213872832953A 0.036000000000000004s 0.020231213872832953A 0.036000000001s 0.020231213872832953A 0.048s 0.020231213872832953A 0.048000000001s 0.020231213872832953A 0.06s 0.020231213872832953A 0.060000000000999996s 0.020231213872832953A 0.07200000000000001s 0.020231213872832953A 0.07200000000100001s 0.020231213872832953A 0.084s 0.020231213872832953A 0.08400000000100001s 0.020231213872832953A 0.096s 0.020231213872832953A 0.09600000000100001s 0.020231213872832953A 0.108s 0.020231213872832953A 0.108000000001s 0.020231213872832953A 0.12s 0.020231213872832953A 0.120000000001s 0.020231213872832953A 0.132s 0.020231213872832953A 0.132000000001s 0.020231213872832953A 0.14400000000000002s 0.020231213872832953A 0.14400000000100002s 0.020231213872832953A 0.156s 0.020231213872832953A 0.156000000001s 0.020231213872832953A 0.168s 0.020231213872832953A 0.16800000000100002s 0.020231213872832953A 0.18s 0.020231213872832953A 0.180000000001s 0.020231213872832953A 0.192s 0.020231213872832953A 0.192000000001s 0.020231213872832953A 0.20400000000000001s 0.020231213872832953A 0.20400000000100002s 0.020231213872832953A 0.216s 0.020231213872832953A 0.216000000001s 0.020231213872832953A 0.228s 0.020231213872832953A 0.228000000001s 0.020231213872832953A 0.24s 0.020231213872832953A 0.240000000001s 0.020231213872832953A 0.252s 0.020231213872832953A 0.252000000001s 0.020231213872832953A 0.264s 0.020231213872832953A 0.264000000001s 0.020231213872832953A 0.276s 0.020231213872832953A 0.276000000001s 0.020231213872832953A 0.28800000000000003s 0.020231213872832953A 0.288000000001s 0.020231213872832953A 0.3s 0.020231213872832953A 0.30000000000099997s 0.020231213872832953A 0.312s 0.020231213872832953A 0.312000000001s 0.020231213872832953A 0.324s 0.020231213872832953A 0.324000000001s 0.020231213872832953A 0.336s 0.020231213872832953A 0.336000000001s 0.020231213872832953A 0.34800000000000003s 0.020231213872832953A 0.348000000001s 0.020231213872832953A 0.36s 0.020231213872832953A 0.36000000000099996s 0.020231213872832953A 0.372s 0.020231213872832953A 0.372000000001s 0.020231213872832953A 0.384s 0.020231213872832953A 0.384000000001s 0.020231213872832953A 0.396s 0.020231213872832953A 0.396000000001s 0.020231213872832953A 0.40800000000000003s 0.020231213872832953A 0.408000000001s 0.020231213872832953A 0.42s 0.020231213872832953A 0.42000000000099996s 0.020231213872832953A 0.432s 0.020231213872832953A 0.432000000001s 0.020231213872832953A 0.444s 0.020231213872832953A 0.444000000001s 0.020231213872832953A 0.456s 0.020231213872832953A 0.456000000001s 0.020231213872832953A 0.468s 0.020231213872832953A 0.468000000001s 0.020231213872832953A 0.48s 0.020231213872832953A 0.48000000000099996s 0.020231213872832953A 0.492s 0.020231213872832953A 0.49200000000099997s 0.020231213872832953A 0.504s 0.020231213872832953A 0.504000000001s 0.020231213872832953A 0.516s 0.020231213872832953A 0.516000000001s 0.020231213872832953A 0.528s 0.020231213872832953A 0.528000000001s 0.020231213872832953A 0.54s 0.020231213872832953A 0.540000000001s 0.020231213872832953A 0.552s 0.020231213872832953A 0.552000000001s 0.020231213872832953A 0.5640000000000001s 0.020231213872832953A 0.564000000001s 0.020231213872832953A 0.5760000000000001s 0.020231213872832953A 0.576000000001s 0.020231213872832953A 0.588s 0.020231213872832953A 0.588000000001s 0.020231213872832953A 0.6s 0.020231213872832953A 0.600000000001s 0.020231213872832953A 0.612s 0.020231213872832953A 0.612000000001s 0.020231213872832953A 0.624s 0.020231213872832953A 0.624000000001s 0.020231213872832953A 0.636s 0.020231213872832953A 0.636000000001s 0.020231213872832953A 0.648s 0.020231213872832953A 0.648000000001s 0.020231213872832953A 0.66s 0.020231213872832953A 0.660000000001s 0.020231213872832953A 0.672s 0.020231213872832953A 0.672000000001s 0.020231213872832953A 0.684s 0.020231213872832953A 0.684000000001s 0.020231213872832953A 0.6960000000000001s 0.020231213872832953A 0.696000000001s 0.020231213872832953A 0.708s 0.020231213872832953A 0.7080000000009999s 0.020231213872832953A 0.72s 0.020231213872832953A 0.720000000001s 0.020231213872832953A 0.732s 0.020231213872832953A 0.732000000001s 0.020231213872832953A 0.744s 0.020231213872832953A 0.744000000001s 0.020231213872832953A 0.756s 0.020231213872832953A 0.756000000001s 0.020231213872832953A 0.768s 0.020231213872832953A 0.768000000001s 0.020231213872832953A 0.78s 0.020231213872832953A 0.780000000001s 0.020231213872832953A 0.792s 0.020231213872832953A 0.792000000001s 0.020231213872832953A 0.804s 0.020231213872832953A 0.804000000001s 0.020231213872832953A 0.8160000000000001s 0.020231213872832953A 0.816000000001s 0.020231213872832953A 0.8280000000000001s 0.020231213872832953A 0.828000000001s 0.020231213872832953A 0.84s 0.020231213872832953A 0.840000000001s 0.020231213872832953A 0.852s 0.020231213872832953A 0.852000000001s 0.020231213872832953A 0.864s 0.020231213872832953A 0.864000000001s 0.020231213872832953A 0.876s 0.020231213872832953A 0.876000000001s 0.020231213872832953A 0.888s 0.020231213872832953A 0.888000000001s 0.020231213872832953A 0.9s 0.020231213872832953A 0.900000000001s 0.020231213872832953A 0.912s 0.020231213872832953A 0.912000000001s 0.020231213872832953A 0.924s 0.020231213872832953A 0.924000000001s 0.020231213872832953A 0.936s 0.020231213872832953A 0.936000000001s 0.020231213872832953A 0.9480000000000001s 0.020231213872832953A 0.948000000001s 0.020231213872832953A 0.96s 0.020231213872832953A 0.9600000000009999s 0.020231213872832953A 0.972s 0.020231213872832953A 0.972000000001s 0.020231213872832953A 0.984s 0.020231213872832953A 0.984000000001s 0.020231213872832953A 0.996s 0.020231213872832953A 0.996000000001s 0.020231213872832953A 1.008s 0.020231213872832953A 1.008000000001s 0.020231213872832953A 1.02s 0.020231213872832953A 1.020000000001s 0.020231213872832953A 1.032s 0.020231213872832953A 1.0320000000010001s 0.020231213872832953A 1.044s 0.020231213872832953A 1.0440000000010001s 0.020231213872832953A 1.056s 0.020231213872832953A 1.0560000000010001s 0.020231213872832953A 1.068s 0.020231213872832953A 1.0680000000010001s 0.020231213872832953A 1.08s 0.020231213872832953A 1.0800000000010002s 0.020231213872832953A 1.092s 0.020231213872832953A 1.0920000000010002s 0.020231213872832953A 1.104s 0.020231213872832953A 1.1040000000010002s 0.020231213872832953A 1.116s 0.020231213872832953A 1.1160000000010002s 0.020231213872832953A 1.1280000000000001s 0.020231213872832953A 1.1280000000010002s 0.020231213872832953A 1.1400000000000001s 0.020231213872832953A 1.1400000000010002s 0.020231213872832953A 1.1520000000000001s 0.020231213872832953A 1.1520000000010002s 0.020231213872832953A 1.164s 0.020231213872832953A 1.164000000001s 0.020231213872832953A 1.176s 0.020231213872832953A 1.176000000001s 0.020231213872832953A 1.188s 0.020231213872832953A 1.188000000001s 0.020231213872832953A 1.2s 0.020231213872832953A 1.200000000001s 0.020231213872832953A 1.212s 0.020231213872832953A 1.212000000001s 0.020231213872832953A 1.224s 0.020231213872832953A 1.224000000001s 0.020231213872832953A 1.236s 0.020231213872832953A 1.236000000001s 0.020231213872832953A 1.248s 0.020231213872832953A 1.248000000001s 0.020231213872832953A 1.26s 0.020231213872832953A 1.260000000001s 0.020231213872832953A 1.272s 0.020231213872832953A 1.272000000001s 0.020231213872832953A 1.284s 0.020231213872832953A 1.2840000000010001s 0.020231213872832953A 1.296s 0.020231213872832953A 1.2960000000010001s 0.020231213872832953A 1.308s 0.020231213872832953A 1.3080000000010001s 0.020231213872832953A 1.32s 0.020231213872832953A 1.3200000000010002s 0.020231213872832953A 1.332s 0.020231213872832953A 1.3320000000010002s 0.020231213872832953A 1.344s 0.020231213872832953A 1.3440000000010002s 0.020231213872832953A 1.356s 0.020231213872832953A 1.3560000000010002s 0.020231213872832953A 1.368s 0.020231213872832953A 1.3680000000010002s 0.020231213872832953A 1.3800000000000001s 0.020231213872832953A 1.3800000000010002s 0.020231213872832953A 1.3920000000000001s 0.020231213872832953A 1.3920000000010002s 0.020231213872832953A 1.4040000000000001s 0.020231213872832953A 1.4040000000010002s 0.020231213872832953A 1.416s 0.020231213872832953A 1.416000000001s 0.020231213872832953A 1.428s 0.020231213872832953A 1.428000000001s 0.020231213872832953A 1.44s 0.020231213872832953A 1.440000000001s 0.020231213872832953A 1.452s 0.020231213872832953A 1.452000000001s 0.020231213872832953A 1.464s 0.020231213872832953A 1.464000000001s 0.020231213872832953A 1.476s 0.020231213872832953A 1.476000000001s 0.020231213872832953A 1.488s 0.020231213872832953A 1.488000000001s 0.020231213872832953A 1.5s 0.020231213872832953A 1.500000000001s 0.020231213872832953A 1.512s 0.020231213872832953A 1.512000000001s 0.020231213872832953A 1.524s 0.020231213872832953A 1.524000000001s 0.020231213872832953A 1.536s 0.020231213872832953A 1.5360000000010001s 0.020231213872832953A 1.548s 0.020231213872832953A 1.5480000000010001s 0.020231213872832953A 1.56s 0.020231213872832953A 1.5600000000010001s 0.020231213872832953A 1.572s 0.020231213872832953A 1.5720000000010002s 0.020231213872832953A 1.584s 0.020231213872832953A 1.5840000000010002s 0.020231213872832953A 1.596s 0.020231213872832953A 1.5960000000010002s 0.020231213872832953A 1.608s 0.020231213872832953A 1.6080000000010002s 0.020231213872832953A 1.62s 0.020231213872832953A 1.6200000000010002s 0.020231213872832953A 1.6320000000000001s 0.020231213872832953A 1.6320000000010002s 0.020231213872832953A 1.6440000000000001s 0.020231213872832953A 1.6440000000010002s 0.020231213872832953A 1.6560000000000001s 0.020231213872832953A 1.6560000000010002s 0.020231213872832953A 1.668s 0.020231213872832953A 1.668000000001s 0.020231213872832953A 1.68s 0.020231213872832953A 1.680000000001s 0.020231213872832953A 1.692s 0.020231213872832953A 1.692000000001s 0.020231213872832953A 1.704s 0.020231213872832953A 1.704000000001s 0.020231213872832953A 1.716s 0.020231213872832953A 1.716000000001s 0.020231213872832953A 1.728s 0.020231213872832953A 1.728000000001s 0.020231213872832953A 1.74s 0.020231213872832953A 1.740000000001s 0.020231213872832953A 1.752s 0.020231213872832953A 1.752000000001s 0.020231213872832953A 1.764s 0.020231213872832953A 1.764000000001s 0.020231213872832953A 1.776s 0.020231213872832953A 1.7760000000010001s 0.020231213872832953A 1.788s 0.020231213872832953A 1.7880000000010001s 0.020231213872832953A 1.8s 0.020231213872832953A 1.8000000000010001s 0.020231213872832953A 1.812s 0.020231213872832953A 1.8120000000010001s 0.020231213872832953A 1.824s 0.020231213872832953A 1.8240000000010002s 0.020231213872832953A 1.836s 0.020231213872832953A 1.8360000000010002s 0.020231213872832953A 1.848s 0.020231213872832953A 1.8480000000010002s 0.020231213872832953A 1.86s 0.020231213872832953A 1.8600000000010002s 0.020231213872832953A 1.872s 0.020231213872832953A 1.8720000000010002s 0.020231213872832953A)
R_0_2_9_2 Node0_2_9 Node0_3_9 13.020765027322398
R_0_2_9_3 Node0_2_9 Node1_2_9 2.5950185402029624
C_0_2_9 Node0_2_9 GND 0.0009924144753600014
I_0_3_0 GND Node0_3_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861248A 0.024s 0.21364960617861248A 0.024000000001s 0.21367364479385648A 0.036000000000000004s 0.21367364479385648A 0.036000000001s 0.21367862573906665A 0.048s 0.21367862573906665A 0.048000000001s 0.21368355630285157A 0.06s 0.21368355630285157A 0.060000000000999996s 0.21368308997603264A 0.07200000000000001s 0.21368308997603264A 0.07200000000100001s 0.21365076101644404A 0.084s 0.21365076101644404A 0.08400000000100001s 0.21367033479745282A 0.096s 0.21367033479745282A 0.09600000000100001s 0.21367755775122355A 0.108s 0.21367755775122355A 0.108000000001s 0.21368251315438613A 0.12s 0.21368251315438613A 0.120000000001s 0.21368461322364524A 0.132s 0.21368461322364524A 0.132000000001s 0.2136518820207243A 0.14400000000000002s 0.2136518820207243A 0.14400000000100002s 0.2136665141006317A 0.156s 0.2136665141006317A 0.156000000001s 0.21367642163954237A 0.168s 0.21367642163954237A 0.16800000000100002s 0.2136808165229981A 0.18s 0.2136808165229981A 0.180000000001s 0.21368355630285157A 0.192s 0.21368355630285157A 0.192000000001s 0.21366438093562462A 0.20400000000000001s 0.21366438093562462A 0.20400000000100002s 0.21365397945497158A 0.216s 0.21365397945497158A 0.216000000001s 0.21367265575096642A 0.228s 0.21367265575096642A 0.228000000001s 0.21367916633808448A 0.24s 0.21367916633808448A 0.240000000001s 0.21368240258929166A 0.252s 0.21368240258929166A 0.252000000001s 0.21368036273883528A 0.264s 0.21368036273883528A 0.264000000001s 0.2136518246828678A 0.276s 0.2136518246828678A 0.276000000001s 0.21366818311709623A 0.28800000000000003s 0.21366818311709623A 0.288000000001s 0.21367755775122355A 0.3s 0.21367755775122355A 0.30000000000099997s 0.21368240258929166A 0.312s 0.21368240258929166A 0.312000000001s 0.21368461322364524A 0.324s 0.21368461322364524A 0.324000000001s 0.2136523815838252A 0.336s 0.2136523815838252A 0.336000000001s 0.21366438093562462A 0.34800000000000003s 0.21366438093562462A 0.348000000001s 0.21367590370162595A 0.36s 0.21367590370162595A 0.36000000000099996s 0.21368026155438274A 0.372s 0.21368026155438274A 0.372000000001s 0.21368402414041057A 0.384s 0.21368402414041057A 0.384000000001s 0.21366229822230987A 0.396s 0.21366229822230987A 0.396000000001s 0.21365175445102044A 0.40800000000000003s 0.21365175445102044A 0.408000000001s 0.21367314877923807A 0.42s 0.21367314877923807A 0.42000000000099996s 0.21367916633808448A 0.432s 0.21367916633808448A 0.432000000001s 0.21368240258929166A 0.444s 0.21368240258929166A 0.444000000001s 0.21368251315438613A 0.456s 0.21368251315438613A 0.456000000001s 0.21365128071103498A 0.468s 0.21365128071103498A 0.468000000001s 0.21366869877133582A 0.48s 0.21366869877133582A 0.48000000000099996s 0.21367755775122355A 0.492s 0.21367755775122355A 0.49200000000099997s 0.21368240258929166A 0.504s 0.21368240258929166A 0.504000000001s 0.21368461322364524A 0.516s 0.21368461322364524A 0.516000000001s 0.2136529854231258A 0.528s 0.2136529854231258A 0.528000000001s 0.21366338844965246A 0.54s 0.21366338844965246A 0.540000000001s 0.21367642163954237A 0.552s 0.21367642163954237A 0.552000000001s 0.21367981026469773A 0.5640000000000001s 0.21367981026469773A 0.564000000001s 0.21368297649485843A 0.5760000000000001s 0.21368297649485843A 0.576000000001s 0.21366494946576736A 0.588s 0.21366494946576736A 0.588000000001s 0.21365408854445944A 0.6s 0.21365408854445944A 0.600000000001s 0.21367202960189935A 0.612s 0.21367202960189935A 0.612000000001s 0.21367853277585094A 0.624s 0.21367853277585094A 0.624000000001s 0.21368251315438613A 0.636s 0.21368251315438613A 0.636000000001s 0.21367871979142067A 0.648s 0.21367871979142067A 0.648000000001s 0.213652412079695A 0.66s 0.213652412079695A 0.660000000001s 0.21366706327222115A 0.672s 0.21366706327222115A 0.672000000001s 0.21363808950475843A 0.684s 0.21363808950475843A 0.684000000001s 0.21363492768455342A 0.6960000000000001s 0.21363492768455342A 0.696000000001s 0.21363492681640486A 0.708s 0.21363492681640486A 0.7080000000009999s 0.21363492639480303A 0.72s 0.21363492639480303A 0.720000000001s 0.21363492637442555A 0.732s 0.21363492637442555A 0.732000000001s 0.2136349276634733A 0.744s 0.2136349276634733A 0.744000000001s 0.21363492653322896A 0.756s 0.21363492653322896A 0.756000000001s 0.21363492641026172A 0.768s 0.21363492641026172A 0.768000000001s 0.21363492687332114A 0.78s 0.21363492687332114A 0.780000000001s 0.21363492662071135A 0.792s 0.21363492662071135A 0.792000000001s 0.21363492711644488A 0.804s 0.21363492711644488A 0.804000000001s 0.21363491441744475A 0.8160000000000001s 0.21363491441744475A 0.816000000001s 0.21363494037195951A 0.8280000000000001s 0.21363494037195951A 0.828000000001s 0.21363494066848618A 0.84s 0.21363494066848618A 0.840000000001s 0.21363494035263608A 0.852s 0.21363494035263608A 0.852000000001s 0.21363494034631206A 0.864s 0.21363494034631206A 0.864000000001s 0.21363494034631206A 0.876s 0.21363494034631206A 0.876000000001s 0.2136349402693697A 0.888s 0.2136349402693697A 0.888000000001s 0.21363494041693035A 0.9s 0.21363494041693035A 0.900000000001s 0.21363494050722345A 0.912s 0.21363494050722345A 0.912000000001s 0.21363494039128292A 0.924s 0.21363494039128292A 0.924000000001s 0.2136349198181649A 0.936s 0.2136349198181649A 0.936000000001s 0.21363493890408225A 0.9480000000000001s 0.21363493890408225A 0.948000000001s 0.2136349386469051A 0.96s 0.2136349386469051A 0.9600000000009999s 0.21363493942757125A 0.972s 0.21363493942757125A 0.972000000001s 0.2136349390361842A 0.984s 0.2136349390361842A 0.984000000001s 0.21363493904250822A 0.996s 0.21363493904250822A 0.996000000001s 0.21363493888511023A 1.008s 0.21363493888511023A 1.008000000001s 0.2136349395863746A 1.02s 0.2136349395863746A 1.020000000001s 0.21363493945954273A 1.032s 0.21363493945954273A 1.0320000000010001s 0.21363493841572673A 1.044s 0.21363493841572673A 1.0440000000010001s 0.2136348457722257A 1.056s 0.2136348457722257A 1.0560000000010001s 0.21363484068454502A 1.068s 0.21363484068454502A 1.0680000000010001s 0.2136353090568357A 1.08s 0.2136353090568357A 1.0800000000010002s 0.21363530922231447A 1.092s 0.21363530922231447A 1.0920000000010002s 0.2136353090982932A 1.104s 0.2136353090982932A 1.1040000000010002s 0.21363530885095344A 1.116s 0.21363530885095344A 1.1160000000010002s 0.21363530913131873A 1.1280000000000001s 0.21363530913131873A 1.1280000000010002s 0.21363530969521125A 1.1400000000000001s 0.21363530969521125A 1.1400000000010002s 0.21363530942925074A 1.1520000000000001s 0.21363530942925074A 1.1520000000010002s 0.21363530865350325A 1.164s 0.21363530865350325A 1.164000000001s 0.2136353092303952A 1.176s 0.2136353092303952A 1.176000000001s 0.21363493650516754A 1.188s 0.21363493650516754A 1.188000000001s 0.21363494066848618A 1.2s 0.21363494066848618A 1.200000000001s 0.21363494055886964A 1.212s 0.21363494055886964A 1.212000000001s 0.21363494048157602A 1.224s 0.21363494048157602A 1.224000000001s 0.21363494052654686A 1.236s 0.21363494052654686A 1.236000000001s 0.21363494018610335A 1.248s 0.21363494018610335A 1.248000000001s 0.21363494036563546A 1.26s 0.21363494036563546A 1.260000000001s 0.2136349402820177A 1.272s 0.2136349402820177A 1.272000000001s 0.2136349402050754A 1.284s 0.2136349402050754A 1.2840000000010001s 0.2136349404879A 1.296s 0.2136349404879A 1.2960000000010001s 0.2136349198090302A 1.308s 0.2136349198090302A 1.3080000000010001s 0.21363492612919383A 1.32s 0.21363492612919383A 1.3200000000010002s 0.21363492641553172A 1.332s 0.21363492641553172A 1.3320000000010002s 0.2136349267134638A 1.344s 0.2136349267134638A 1.3440000000010002s 0.2136349267492999A 1.356s 0.2136349267492999A 1.3560000000010002s 0.21363492717863114A 1.368s 0.21363492717863114A 1.3680000000010002s 0.21363492632313066A 1.3800000000000001s 0.21363492632313066A 1.3800000000010002s 0.21363492697134356A 1.3920000000000001s 0.21363492697134356A 1.3920000000010002s 0.2136349270026124A 1.4040000000000001s 0.2136349270026124A 1.4040000000010002s 0.21363492680621618A 1.416s 0.21363492680621618A 1.416000000001s 0.21363492645136795A 1.428s 0.21363492645136795A 1.428000000001s 0.21363488089693283A 1.44s 0.21363488089693283A 1.440000000001s 0.21363484002965671A 1.452s 0.21363484002965671A 1.452000000001s 0.21363485567776203A 1.464s 0.21363485567776203A 1.464000000001s 0.2136353090817805A 1.476s 0.2136353090817805A 1.476000000001s 0.213635309263772A 1.488s 0.213635309263772A 1.488000000001s 0.2136353085059426A 1.5s 0.2136353085059426A 1.500000000001s 0.21363530928028474A 1.512s 0.21363530928028474A 1.512000000001s 0.2136353090733485A 1.524s 0.2136353090733485A 1.524000000001s 0.21363530884252144A 1.536s 0.21363530884252144A 1.5360000000010001s 0.2136353088920597A 1.548s 0.2136353088920597A 1.5480000000010001s 0.2136353090238103A 1.56s 0.2136353090238103A 1.5600000000010001s 0.21363530953711057A 1.572s 0.21363530953711057A 1.5720000000010002s 0.21363493125622407A 1.584s 0.21363493125622407A 1.5840000000010002s 0.2136349406424874A 1.596s 0.2136349406424874A 1.5960000000010002s 0.2136349404042823A 1.608s 0.2136349404042823A 1.6080000000010002s 0.21363494059751648A 1.62s 0.21363494059751648A 1.6200000000010002s 0.2136349405651937A 1.6320000000000001s 0.2136349405651937A 1.6320000000010002s 0.213634940109161A 1.6440000000000001s 0.213634940109161A 1.6440000000010002s 0.21363494044925316A 1.6560000000000001s 0.21363494044925316A 1.6560000000010002s 0.21363494023072285A 1.668s 0.21363494023072285A 1.668000000001s 0.21363494033998803A 1.68s 0.21363494033998803A 1.680000000001s 0.21363494037195951A 1.692s 0.21363494037195951A 1.692000000001s 0.21363491483939795A 1.704s 0.21363491483939795A 1.704000000001s 0.21363492654868765A 1.716s 0.21363492654868765A 1.716000000001s 0.21363492732408382A 1.728s 0.21363492732408382A 1.728000000001s 0.2136349269404261A 1.74s 0.2136349269404261A 1.740000000001s 0.21363492630802325A 1.752s 0.21363492630802325A 1.752000000001s 0.21363492605787285A 1.764s 0.21363492605787285A 1.764000000001s 0.21363492654868765A 1.776s 0.21363492654868765A 1.7760000000010001s 0.21363492689896857A 1.788s 0.21363492689896857A 1.7880000000010001s 0.21363492666708753A 1.8s 0.21363492666708753A 1.8000000000010001s 0.21363492668254624A 1.812s 0.21363492668254624A 1.8120000000010001s 0.21363492638461426A 1.824s 0.21363492638461426A 1.8240000000010002s 0.21363485153341552A 1.836s 0.21363485153341552A 1.8360000000010002s 0.2136348400233327A 1.848s 0.2136348400233327A 1.8480000000010002s 0.2136348996213266A 1.86s 0.2136348996213266A 1.8600000000010002s 0.21363530908986123A 1.872s 0.21363530908986123A 1.8720000000010002s 0.21363593532289732A)
R_0_3_0_1 Node0_3_0 Node0_3_1 9.887809523809524
R_0_3_0_2 Node0_3_0 Node0_4_0 13.020765027322405
R_0_3_0_3 Node0_3_0 Node1_3_0 2.595018540202966
C_0_3_0 Node0_3_0 GND 0.0009924144753600001
I_0_3_1 GND Node0_3_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861245A 0.024s 0.21364960617861245A 0.024000000001s 0.21367364479385648A 0.036000000000000004s 0.21367364479385648A 0.036000000001s 0.21367862573906665A 0.048s 0.21367862573906665A 0.048000000001s 0.21368355630285157A 0.06s 0.21368355630285157A 0.060000000000999996s 0.2136830899760326A 0.07200000000000001s 0.2136830899760326A 0.07200000000100001s 0.213650761016444A 0.084s 0.213650761016444A 0.08400000000100001s 0.2136703347974528A 0.096s 0.2136703347974528A 0.09600000000100001s 0.21367755775122355A 0.108s 0.21367755775122355A 0.108000000001s 0.21368251315438613A 0.12s 0.21368251315438613A 0.120000000001s 0.21368461322364518A 0.132s 0.21368461322364518A 0.132000000001s 0.21365188202072427A 0.14400000000000002s 0.21365188202072427A 0.14400000000100002s 0.2136665141006317A 0.156s 0.2136665141006317A 0.156000000001s 0.21367642163954234A 0.168s 0.21367642163954234A 0.16800000000100002s 0.21368081652299808A 0.18s 0.21368081652299808A 0.180000000001s 0.21368355630285157A 0.192s 0.21368355630285157A 0.192000000001s 0.21366438093562462A 0.20400000000000001s 0.21366438093562462A 0.20400000000100002s 0.21365397945497155A 0.216s 0.21365397945497155A 0.216000000001s 0.2136726557509664A 0.228s 0.2136726557509664A 0.228000000001s 0.21367916633808445A 0.24s 0.21367916633808445A 0.240000000001s 0.21368240258929166A 0.252s 0.21368240258929166A 0.252000000001s 0.21368036273883523A 0.264s 0.21368036273883523A 0.264000000001s 0.2136518246828678A 0.276s 0.2136518246828678A 0.276000000001s 0.2136681831170962A 0.28800000000000003s 0.2136681831170962A 0.288000000001s 0.21367755775122355A 0.3s 0.21367755775122355A 0.30000000000099997s 0.21368240258929166A 0.312s 0.21368240258929166A 0.312000000001s 0.21368461322364518A 0.324s 0.21368461322364518A 0.324000000001s 0.21365238158382518A 0.336s 0.21365238158382518A 0.336000000001s 0.21366438093562462A 0.34800000000000003s 0.21366438093562462A 0.348000000001s 0.21367590370162592A 0.36s 0.21367590370162592A 0.36000000000099996s 0.21368026155438274A 0.372s 0.21368026155438274A 0.372000000001s 0.21368402414041054A 0.384s 0.21368402414041054A 0.384000000001s 0.21366229822230987A 0.396s 0.21366229822230987A 0.396000000001s 0.21365175445102041A 0.40800000000000003s 0.21365175445102041A 0.408000000001s 0.21367314877923804A 0.42s 0.21367314877923804A 0.42000000000099996s 0.21367916633808445A 0.432s 0.21367916633808445A 0.432000000001s 0.21368240258929166A 0.444s 0.21368240258929166A 0.444000000001s 0.21368251315438613A 0.456s 0.21368251315438613A 0.456000000001s 0.21365128071103495A 0.468s 0.21365128071103495A 0.468000000001s 0.21366869877133576A 0.48s 0.21366869877133576A 0.48000000000099996s 0.21367755775122355A 0.492s 0.21367755775122355A 0.49200000000099997s 0.21368240258929166A 0.504s 0.21368240258929166A 0.504000000001s 0.21368461322364518A 0.516s 0.21368461322364518A 0.516000000001s 0.2136529854231258A 0.528s 0.2136529854231258A 0.528000000001s 0.21366338844965244A 0.54s 0.21366338844965244A 0.540000000001s 0.21367642163954234A 0.552s 0.21367642163954234A 0.552000000001s 0.21367981026469768A 0.5640000000000001s 0.21367981026469768A 0.564000000001s 0.2136829764948584A 0.5760000000000001s 0.2136829764948584A 0.576000000001s 0.2136649494657673A 0.588s 0.2136649494657673A 0.588000000001s 0.21365408854445944A 0.6s 0.21365408854445944A 0.600000000001s 0.21367202960189932A 0.612s 0.21367202960189932A 0.612000000001s 0.21367853277585092A 0.624s 0.21367853277585092A 0.624000000001s 0.21368251315438613A 0.636s 0.21368251315438613A 0.636000000001s 0.21367871979142064A 0.648s 0.21367871979142064A 0.648000000001s 0.21365241207969493A 0.66s 0.21365241207969493A 0.660000000001s 0.21366706327222112A 0.672s 0.21366706327222112A 0.672000000001s 0.21363808950475838A 0.684s 0.21363808950475838A 0.684000000001s 0.2136349276845534A 0.6960000000000001s 0.2136349276845534A 0.696000000001s 0.21363492681640484A 0.708s 0.21363492681640484A 0.7080000000009999s 0.213634926394803A 0.72s 0.213634926394803A 0.720000000001s 0.21363492637442555A 0.732s 0.21363492637442555A 0.732000000001s 0.2136349276634733A 0.744s 0.2136349276634733A 0.744000000001s 0.21363492653322894A 0.756s 0.21363492653322894A 0.756000000001s 0.21363492641026172A 0.768s 0.21363492641026172A 0.768000000001s 0.2136349268733211A 0.78s 0.2136349268733211A 0.780000000001s 0.21363492662071132A 0.792s 0.21363492662071132A 0.792000000001s 0.21363492711644486A 0.804s 0.21363492711644486A 0.804000000001s 0.2136349144174447A 0.8160000000000001s 0.2136349144174447A 0.816000000001s 0.21363494037195946A 0.8280000000000001s 0.21363494037195946A 0.828000000001s 0.21363494066848615A 0.84s 0.21363494066848615A 0.840000000001s 0.21363494035263603A 0.852s 0.21363494035263603A 0.852000000001s 0.21363494034631203A 0.864s 0.21363494034631203A 0.864000000001s 0.21363494034631203A 0.876s 0.21363494034631203A 0.876000000001s 0.21363494026936966A 0.888s 0.21363494026936966A 0.888000000001s 0.21363494041693032A 0.9s 0.21363494041693032A 0.900000000001s 0.21363494050722343A 0.912s 0.21363494050722343A 0.912000000001s 0.21363494039128292A 0.924s 0.21363494039128292A 0.924000000001s 0.2136349198181649A 0.936s 0.2136349198181649A 0.936000000001s 0.21363493890408222A 0.9480000000000001s 0.21363493890408222A 0.948000000001s 0.21363493864690508A 0.96s 0.21363493864690508A 0.9600000000009999s 0.21363493942757122A 0.972s 0.21363493942757122A 0.972000000001s 0.21363493903618413A 0.984s 0.21363493903618413A 0.984000000001s 0.2136349390425082A 0.996s 0.2136349390425082A 0.996000000001s 0.2136349388851102A 1.008s 0.2136349388851102A 1.008000000001s 0.21363493958637458A 1.02s 0.21363493958637458A 1.020000000001s 0.2136349394595427A 1.032s 0.2136349394595427A 1.0320000000010001s 0.21363493841572673A 1.044s 0.21363493841572673A 1.0440000000010001s 0.21363484577222566A 1.056s 0.21363484577222566A 1.0560000000010001s 0.21363484068454497A 1.068s 0.21363484068454497A 1.0680000000010001s 0.2136353090568357A 1.08s 0.2136353090568357A 1.0800000000010002s 0.21363530922231444A 1.092s 0.21363530922231444A 1.0920000000010002s 0.21363530909829317A 1.104s 0.21363530909829317A 1.1040000000010002s 0.21363530885095344A 1.116s 0.21363530885095344A 1.1160000000010002s 0.2136353091313187A 1.1280000000000001s 0.2136353091313187A 1.1280000000010002s 0.21363530969521122A 1.1400000000000001s 0.21363530969521122A 1.1400000000010002s 0.21363530942925069A 1.1520000000000001s 0.21363530942925069A 1.1520000000010002s 0.21363530865350322A 1.164s 0.21363530865350322A 1.164000000001s 0.21363530923039517A 1.176s 0.21363530923039517A 1.176000000001s 0.21363493650516752A 1.188s 0.21363493650516752A 1.188000000001s 0.21363494066848615A 1.2s 0.21363494066848615A 1.200000000001s 0.2136349405588696A 1.212s 0.2136349405588696A 1.212000000001s 0.213634940481576A 1.224s 0.213634940481576A 1.224000000001s 0.2136349405265468A 1.236s 0.2136349405265468A 1.236000000001s 0.21363494018610332A 1.248s 0.21363494018610332A 1.248000000001s 0.2136349403656354A 1.26s 0.2136349403656354A 1.260000000001s 0.2136349402820177A 1.272s 0.2136349402820177A 1.272000000001s 0.2136349402050754A 1.284s 0.2136349402050754A 1.2840000000010001s 0.21363494048789997A 1.296s 0.21363494048789997A 1.2960000000010001s 0.21363491980903015A 1.308s 0.21363491980903015A 1.3080000000010001s 0.2136349261291938A 1.32s 0.2136349261291938A 1.3200000000010002s 0.21363492641553172A 1.332s 0.21363492641553172A 1.3320000000010002s 0.21363492671346374A 1.344s 0.21363492671346374A 1.3440000000010002s 0.2136349267492999A 1.356s 0.2136349267492999A 1.3560000000010002s 0.21363492717863114A 1.368s 0.21363492717863114A 1.3680000000010002s 0.21363492632313064A 1.3800000000000001s 0.21363492632313064A 1.3800000000010002s 0.21363492697134356A 1.3920000000000001s 0.21363492697134356A 1.3920000000010002s 0.21363492700261238A 1.4040000000000001s 0.21363492700261238A 1.4040000000010002s 0.21363492680621615A 1.416s 0.21363492680621615A 1.416000000001s 0.2136349264513679A 1.428s 0.2136349264513679A 1.428000000001s 0.21363488089693278A 1.44s 0.21363488089693278A 1.440000000001s 0.21363484002965671A 1.452s 0.21363484002965671A 1.452000000001s 0.21363485567776197A 1.464s 0.21363485567776197A 1.464000000001s 0.21363530908178047A 1.476s 0.21363530908178047A 1.476000000001s 0.21363530926377197A 1.488s 0.21363530926377197A 1.488000000001s 0.21363530850594256A 1.5s 0.21363530850594256A 1.500000000001s 0.2136353092802847A 1.512s 0.2136353092802847A 1.512000000001s 0.21363530907334846A 1.524s 0.21363530907334846A 1.524000000001s 0.2136353088425214A 1.536s 0.2136353088425214A 1.5360000000010001s 0.21363530889205967A 1.548s 0.21363530889205967A 1.5480000000010001s 0.21363530902381028A 1.56s 0.21363530902381028A 1.5600000000010001s 0.21363530953711057A 1.572s 0.21363530953711057A 1.5720000000010002s 0.21363493125622407A 1.584s 0.21363493125622407A 1.5840000000010002s 0.21363494064248736A 1.596s 0.21363494064248736A 1.5960000000010002s 0.2136349404042823A 1.608s 0.2136349404042823A 1.6080000000010002s 0.21363494059751648A 1.62s 0.21363494059751648A 1.6200000000010002s 0.2136349405651937A 1.6320000000000001s 0.2136349405651937A 1.6320000000010002s 0.21363494010916098A 1.6440000000000001s 0.21363494010916098A 1.6440000000010002s 0.21363494044925313A 1.6560000000000001s 0.21363494044925313A 1.6560000000010002s 0.21363494023072283A 1.668s 0.21363494023072283A 1.668000000001s 0.21363494033998798A 1.68s 0.21363494033998798A 1.680000000001s 0.21363494037195946A 1.692s 0.21363494037195946A 1.692000000001s 0.21363491483939792A 1.704s 0.21363491483939792A 1.704000000001s 0.21363492654868763A 1.716s 0.21363492654868763A 1.716000000001s 0.2136349273240838A 1.728s 0.2136349273240838A 1.728000000001s 0.21363492694042607A 1.74s 0.21363492694042607A 1.740000000001s 0.21363492630802322A 1.752s 0.21363492630802322A 1.752000000001s 0.21363492605787282A 1.764s 0.21363492605787282A 1.764000000001s 0.21363492654868763A 1.776s 0.21363492654868763A 1.7760000000010001s 0.21363492689896857A 1.788s 0.21363492689896857A 1.7880000000010001s 0.2136349266670875A 1.8s 0.2136349266670875A 1.8000000000010001s 0.2136349266825462A 1.812s 0.2136349266825462A 1.8120000000010001s 0.21363492638461426A 1.824s 0.21363492638461426A 1.8240000000010002s 0.2136348515334155A 1.836s 0.2136348515334155A 1.8360000000010002s 0.21363484002333266A 1.848s 0.21363484002333266A 1.8480000000010002s 0.21363489962132656A 1.86s 0.21363489962132656A 1.8600000000010002s 0.2136353090898612A 1.872s 0.2136353090898612A 1.8720000000010002s 0.2136359353228973A)
R_0_3_1_1 Node0_3_1 Node0_3_2 9.887809523809524
R_0_3_1_2 Node0_3_1 Node0_4_1 13.020765027322405
R_0_3_1_3 Node0_3_1 Node1_3_1 2.595018540202966
C_0_3_1 Node0_3_1 GND 0.00099241447536
I_0_3_2 GND Node0_3_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14891191361307846A 0.024s 0.14891191361307846A 0.024000000001s 0.14892656801085716A 0.036000000000000004s 0.14892656801085716A 0.036000000001s 0.14892959442118367A 0.048s 0.14892959442118367A 0.048000000001s 0.14893259804974546A 0.06s 0.14893259804974546A 0.060000000000999996s 0.1489323011725311A 0.07200000000000001s 0.1489323011725311A 0.07200000000100001s 0.1489126078360428A 0.084s 0.1489126078360428A 0.08400000000100001s 0.14892455521239742A 0.096s 0.14892455521239742A 0.09600000000100001s 0.14892893947055016A 0.108s 0.14892893947055016A 0.108000000001s 0.1489319543311256A 0.12s 0.1489319543311256A 0.120000000001s 0.1489332479960164A 0.132s 0.1489332479960164A 0.132000000001s 0.1489132867599559A 0.14400000000000002s 0.1489132867599559A 0.14400000000100002s 0.1489222254716125A 0.156s 0.1489222254716125A 0.156000000001s 0.14892825371528498A 0.168s 0.14892825371528498A 0.16800000000100002s 0.14893092910596042A 0.18s 0.14893092910596042A 0.180000000001s 0.14893259804974546A 0.192s 0.14893259804974546A 0.192000000001s 0.1489209168412947A 0.20400000000000001s 0.1489209168412947A 0.20400000000100002s 0.14891457923333182A 0.216s 0.14891457923333182A 0.216000000001s 0.14892594875800982A 0.228s 0.14892594875800982A 0.228000000001s 0.14892992488323106A 0.24s 0.14892992488323106A 0.240000000001s 0.14893190433516074A 0.252s 0.14893190433516074A 0.252000000001s 0.148930637900357A 0.264s 0.148930637900357A 0.264000000001s 0.14891326083259188A 0.276s 0.14891326083259188A 0.276000000001s 0.1489232382097016A 0.28800000000000003s 0.1489232382097016A 0.288000000001s 0.14892893947055016A 0.3s 0.14892893947055016A 0.30000000000099997s 0.14893190433516074A 0.312s 0.14893190433516074A 0.312000000001s 0.1489332479960164A 0.324s 0.1489332479960164A 0.324000000001s 0.1489135986661448A 0.336s 0.1489135986661448A 0.336000000001s 0.1489209168412947A 0.34800000000000003s 0.1489209168412947A 0.348000000001s 0.14892793350026562A 0.36s 0.14892793350026562A 0.36000000000099996s 0.14893059214618512A 0.372s 0.14893059214618512A 0.372000000001s 0.14893289561009496A 0.384s 0.14893289561009496A 0.384000000001s 0.14891963102451533A 0.396s 0.14891963102451533A 0.396000000001s 0.1489132290747483A 0.40800000000000003s 0.1489132290747483A 0.408000000001s 0.14892625770924173A 0.42s 0.14892625770924173A 0.42000000000099996s 0.14892992488323106A 0.432s 0.14892992488323106A 0.432000000001s 0.14893190433516074A 0.444s 0.14893190433516074A 0.444000000001s 0.1489319543311256A 0.456s 0.1489319543311256A 0.456000000001s 0.1489129288454054A 0.468s 0.1489129288454054A 0.468000000001s 0.1489235573920747A 0.48s 0.1489235573920747A 0.48000000000099996s 0.14892893947055016A 0.492s 0.14892893947055016A 0.49200000000099997s 0.14893190433516074A 0.504s 0.14893190433516074A 0.504000000001s 0.1489332479960164A 0.516s 0.1489332479960164A 0.516000000001s 0.14891395772454957A 0.528s 0.14891395772454957A 0.528000000001s 0.1489202960315345A 0.54s 0.1489202960315345A 0.540000000001s 0.14892825371528498A 0.552s 0.14892825371528498A 0.552000000001s 0.14893030206854913A 0.5640000000000001s 0.14893030206854913A 0.564000000001s 0.14893224985795642A 0.5760000000000001s 0.14893224985795642A 0.576000000001s 0.14892125993339997A 0.588s 0.14892125993339997A 0.588000000001s 0.14891462856204832A 0.6s 0.14891462856204832A 0.600000000001s 0.14892557961144562A 0.612s 0.14892557961144562A 0.612000000001s 0.14892955238453828A 0.624s 0.14892955238453828A 0.624000000001s 0.1489319543311256A 0.636s 0.1489319543311256A 0.636000000001s 0.14892963695032188A 0.648s 0.14892963695032188A 0.648000000001s 0.1489136124559438A 0.66s 0.1489136124559438A 0.660000000001s 0.148922559810055A 0.672s 0.148922559810055A 0.672000000001s 0.14890489970888993A 0.684s 0.14890489970888993A 0.684000000001s 0.14890295391360198A 0.6960000000000001s 0.14890295391360198A 0.696000000001s 0.14890295352103752A 0.708s 0.14890295352103752A 0.7080000000009999s 0.14890295333039516A 0.72s 0.14890295333039516A 0.720000000001s 0.14890295332118078A 0.732s 0.14890295332118078A 0.732000000001s 0.14890295390406985A 0.744s 0.14890295390406985A 0.744000000001s 0.14890295339298942A 0.756s 0.14890295339298942A 0.756000000001s 0.14890295333738537A 0.768s 0.14890295333738537A 0.768000000001s 0.14890295354677427A 0.78s 0.14890295354677427A 0.780000000001s 0.1489029534325477A 0.792s 0.1489029534325477A 0.792000000001s 0.14890295365671136A 0.804s 0.14890295365671136A 0.804000000001s 0.14890294791440392A 0.8160000000000001s 0.14890294791440392A 0.816000000001s 0.14890295965066674A 0.8280000000000001s 0.14890295965066674A 0.828000000001s 0.1489029597847519A 0.84s 0.1489029597847519A 0.840000000001s 0.14890295964192896A 0.852s 0.14890295964192896A 0.852000000001s 0.14890295963906933A 0.864s 0.14890295963906933A 0.864000000001s 0.14890295963906933A 0.876s 0.14890295963906933A 0.876000000001s 0.14890295960427707A 0.888s 0.14890295960427707A 0.888000000001s 0.14890295967100192A 0.9s 0.14890295967100192A 0.900000000001s 0.14890295971183118A 0.912s 0.14890295971183118A 0.912000000001s 0.14890295965940453A 0.924s 0.14890295965940453A 0.924000000001s 0.14890295035653286A 0.936s 0.14890295035653286A 0.936000000001s 0.14890295898691353A 0.9480000000000001s 0.14890295898691353A 0.948000000001s 0.14890295887062166A 0.96s 0.14890295887062166A 0.9600000000009999s 0.1489029592236278A 0.972s 0.1489029592236278A 0.972000000001s 0.14890295904664813A 0.984s 0.14890295904664813A 0.984000000001s 0.14890295904950776A 0.996s 0.14890295904950776A 0.996000000001s 0.14890295897833464A 1.008s 0.14890295897833464A 1.008000000001s 0.14890295929543643A 1.02s 0.14890295929543643A 1.020000000001s 0.14890295923808486A 1.032s 0.14890295923808486A 1.0320000000010001s 0.14890295876608609A 1.044s 0.14890295876608609A 1.0440000000010001s 0.14890291687401117A 1.056s 0.14890291687401117A 1.0560000000010001s 0.14890291457343424A 1.068s 0.14890291457343424A 1.0680000000010001s 0.14890321237558185A 1.08s 0.14890321237558185A 1.0800000000010002s 0.148903212450409A 1.092s 0.148903212450409A 1.0920000000010002s 0.14890321239432835A 1.104s 0.14890321239432835A 1.1040000000010002s 0.14890321228248482A 1.116s 0.14890321228248482A 1.1160000000010002s 0.14890321240926202A 1.1280000000000001s 0.14890321240926202A 1.1280000000010002s 0.14890321266424622A 1.1400000000000001s 0.14890321266424622A 1.1400000000010002s 0.14890321254398264A 1.1520000000000001s 0.14890321254398264A 1.1520000000010002s 0.14890321219320063A 1.164s 0.14890321219320063A 1.164000000001s 0.14890321245406296A 1.176s 0.14890321245406296A 1.176000000001s 0.14890295790215838A 1.188s 0.14890295790215838A 1.188000000001s 0.1489029597847519A 1.2s 0.1489029597847519A 1.200000000001s 0.14890295973518486A 1.212s 0.14890295973518486A 1.212000000001s 0.14890295970023376A 1.224s 0.14890295970023376A 1.224000000001s 0.14890295972056894A 1.236s 0.14890295972056894A 1.236000000001s 0.14890295956662525A 1.248s 0.14890295956662525A 1.248000000001s 0.14890295964780711A 1.26s 0.14890295964780711A 1.260000000001s 0.14890295960999636A 1.272s 0.14890295960999636A 1.272000000001s 0.14890295957520414A 1.284s 0.14890295957520414A 1.2840000000010001s 0.1489029597030934A 1.296s 0.1489029597030934A 1.2960000000010001s 0.14890295035240228A 1.308s 0.14890295035240228A 1.3080000000010001s 0.14890295321029046A 1.32s 0.14890295321029046A 1.3200000000010002s 0.1489029533397684A 1.332s 0.1489029533397684A 1.3320000000010002s 0.14890295347448904A 1.344s 0.14890295347448904A 1.3440000000010002s 0.14890295349069363A 1.356s 0.14890295349069363A 1.3560000000010002s 0.1489029536848311A 1.368s 0.1489029536848311A 1.3680000000010002s 0.14890295329798595A 1.3800000000000001s 0.14890295329798595A 1.3800000000010002s 0.14890295359109862A 1.3920000000000001s 0.14890295359109862A 1.3920000000010002s 0.14890295360523795A 1.4040000000000001s 0.14890295360523795A 1.4040000000010002s 0.14890295351643035A 1.416s 0.14890295351643035A 1.416000000001s 0.14890295335597303A 1.428s 0.14890295335597303A 1.428000000001s 0.1489029327569047A 1.44s 0.1489029327569047A 1.440000000001s 0.14890291427730307A 1.452s 0.14890291427730307A 1.452000000001s 0.14890292135315394A 1.464s 0.14890292135315394A 1.464000000001s 0.14890321238686155A 1.476s 0.14890321238686155A 1.476000000001s 0.1489032124691555A 1.488s 0.1489032124691555A 1.488000000001s 0.14890321212647578A 1.5s 0.14890321212647578A 1.500000000001s 0.1489032124766223A 1.512s 0.1489032124766223A 1.512000000001s 0.14890321238304866A 1.524s 0.14890321238304866A 1.524000000001s 0.14890321227867198A 1.536s 0.14890321227867198A 1.5360000000010001s 0.14890321230107245A 1.548s 0.14890321230107245A 1.5480000000010001s 0.14890321236064824A 1.56s 0.14890321236064824A 1.5600000000010001s 0.1489032125927553A 1.572s 0.1489032125927553A 1.5720000000010002s 0.1489029555286607A 1.584s 0.1489029555286607A 1.5840000000010002s 0.1489029597729956A 1.596s 0.1489029597729956A 1.5960000000010002s 0.14890295966528266A 1.608s 0.14890295966528266A 1.6080000000010002s 0.1489029597526604A 1.62s 0.1489029597526604A 1.6200000000010002s 0.14890295973804452A 1.6320000000000001s 0.14890295973804452A 1.6320000000010002s 0.148902959531833A 1.6440000000000001s 0.148902959531833A 1.6440000000010002s 0.14890295968561784A 1.6560000000000001s 0.14890295968561784A 1.6560000000010002s 0.14890295958680153A 1.668s 0.14890295958680153A 1.668000000001s 0.1489029596362097A 1.68s 0.1489029596362097A 1.680000000001s 0.14890295965066674A 1.692s 0.14890295965066674A 1.692000000001s 0.14890294810520516A 1.704s 0.14890294810520516A 1.704000000001s 0.1489029533999796A 1.716s 0.1489029533999796A 1.716000000001s 0.14890295375060272A 1.728s 0.14890295375060272A 1.728000000001s 0.14890295357711816A 1.74s 0.14890295357711816A 1.740000000001s 0.14890295329115458A 1.752s 0.14890295329115458A 1.752000000001s 0.14890295317804014A 1.764s 0.14890295317804014A 1.764000000001s 0.1489029533999796A 1.776s 0.1489029533999796A 1.7760000000010001s 0.1489029535583717A 1.788s 0.1489029535583717A 1.7880000000010001s 0.14890295345351837A 1.8s 0.14890295345351837A 1.8000000000010001s 0.14890295346050855A 1.812s 0.14890295346050855A 1.8120000000010001s 0.14890295332578796A 1.824s 0.14890295332578796A 1.8240000000010002s 0.14890291947913933A 1.836s 0.14890291947913933A 1.8360000000010002s 0.1489029142744434A 1.848s 0.1489029142744434A 1.8480000000010002s 0.1489029412238095A 1.86s 0.1489029412238095A 1.8600000000010002s 0.14890321239051552A 1.872s 0.14890321239051552A 1.8720000000010002s 0.14890358157504935A)
R_0_3_2_1 Node0_3_2 Node0_3_3 9.887809523809524
R_0_3_2_2 Node0_3_2 Node0_4_2 13.020765027322405
R_0_3_2_3 Node0_3_2 Node1_3_2 2.595018540202966
C_0_3_2 Node0_3_2 GND 0.00099241447536
I_0_3_3 GND Node0_3_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.0954750651362911A 0.024s 0.0954750651362911A 0.024000000001s 0.09548197345930416A 0.036000000000000004s 0.09548197345930416A 0.036000000001s 0.09548338652537504A 0.048s 0.09548338652537504A 0.048000000001s 0.0954847995914459A 0.06s 0.0954847995914459A 0.060000000000999996s 0.09548464258410472A 0.07200000000000001s 0.09548464258410472A 0.07200000000100001s 0.0954753791509735A 0.084s 0.0954753791509735A 0.08400000000100001s 0.09548103141525695A 0.096s 0.09548103141525695A 0.09600000000100001s 0.0954830725106926A 0.108s 0.0954830725106926A 0.108000000001s 0.09548448557676346A 0.12s 0.09548448557676346A 0.120000000001s 0.0954851136061283A 0.132s 0.0954851136061283A 0.132000000001s 0.0954756931656559A 0.14400000000000002s 0.0954756931656559A 0.14400000000100002s 0.0954799323638685A 0.156s 0.0954799323638685A 0.156000000001s 0.0954827584960102A 0.168s 0.0954827584960102A 0.16800000000100002s 0.09548401455473986A 0.18s 0.09548401455473986A 0.180000000001s 0.0954847995914459A 0.192s 0.0954847995914459A 0.192000000001s 0.09547930433450366A 0.20400000000000001s 0.09547930433450366A 0.20400000000100002s 0.09547632119502074A 0.216s 0.09547632119502074A 0.216000000001s 0.09548165944462175A 0.228s 0.09548165944462175A 0.228000000001s 0.09548354353271622A 0.24s 0.09548354353271622A 0.240000000001s 0.09548448557676346A 0.252s 0.09548448557676346A 0.252000000001s 0.09548385754739865A 0.264s 0.09548385754739865A 0.264000000001s 0.0954756931656559A 0.276s 0.0954756931656559A 0.276000000001s 0.09548040338589212A 0.28800000000000003s 0.09548040338589212A 0.288000000001s 0.0954830725106926A 0.3s 0.0954830725106926A 0.30000000000099997s 0.09548448557676346A 0.312s 0.09548448557676346A 0.312000000001s 0.0954851136061283A 0.324s 0.0954851136061283A 0.324000000001s 0.09547585017299712A 0.336s 0.09547585017299712A 0.336000000001s 0.09547930433450366A 0.34800000000000003s 0.09547930433450366A 0.348000000001s 0.095482601488669A 0.36s 0.095482601488669A 0.36000000000099996s 0.09548385754739865A 0.372s 0.09548385754739865A 0.372000000001s 0.09548495659878709A 0.384s 0.09548495659878709A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.0954756931656559A 0.40800000000000003s 0.0954756931656559A 0.408000000001s 0.09548181645196296A 0.42s 0.09548181645196296A 0.42000000000099996s 0.09548354353271622A 0.432s 0.09548354353271622A 0.432000000001s 0.09548448557676346A 0.444s 0.09548448557676346A 0.444000000001s 0.09548448557676346A 0.456s 0.09548448557676346A 0.456000000001s 0.09547553615831472A 0.468s 0.09547553615831472A 0.468000000001s 0.09548056039323331A 0.48s 0.09548056039323331A 0.48000000000099996s 0.0954830725106926A 0.492s 0.0954830725106926A 0.49200000000099997s 0.09548448557676346A 0.504s 0.09548448557676346A 0.504000000001s 0.0954851136061283A 0.516s 0.0954851136061283A 0.516000000001s 0.09547600718033832A 0.528s 0.09547600718033832A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.0954827584960102A 0.552s 0.0954827584960102A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410472A 0.5760000000000001s 0.09548464258410472A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502074A 0.6s 0.09547632119502074A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537504A 0.624s 0.09548338652537504A 0.624000000001s 0.09548448557676346A 0.636s 0.09548448557676346A 0.636000000001s 0.09548338652537504A 0.648s 0.09548338652537504A 0.648000000001s 0.09547585017299712A 0.66s 0.09547585017299712A 0.660000000001s 0.09548008937120969A 0.672s 0.09548008937120969A 0.672000000001s 0.09547176798212574A 0.684s 0.09547176798212574A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541972A 1.08s 0.09547098294541972A 1.0800000000010002s 0.09547098294541972A 1.092s 0.09547098294541972A 1.0920000000010002s 0.09547098294541972A 1.104s 0.09547098294541972A 1.1040000000010002s 0.09547098294541972A 1.116s 0.09547098294541972A 1.1160000000010002s 0.09547098294541972A 1.1280000000000001s 0.09547098294541972A 1.1280000000010002s 0.09547098294541972A 1.1400000000000001s 0.09547098294541972A 1.1400000000010002s 0.09547098294541972A 1.1520000000000001s 0.09547098294541972A 1.1520000000010002s 0.09547098294541972A 1.164s 0.09547098294541972A 1.164000000001s 0.09547098294541972A 1.176s 0.09547098294541972A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541972A 1.476s 0.09547098294541972A 1.476000000001s 0.09547098294541972A 1.488s 0.09547098294541972A 1.488000000001s 0.09547098294541972A 1.5s 0.09547098294541972A 1.500000000001s 0.09547098294541972A 1.512s 0.09547098294541972A 1.512000000001s 0.09547098294541972A 1.524s 0.09547098294541972A 1.524000000001s 0.09547098294541972A 1.536s 0.09547098294541972A 1.5360000000010001s 0.09547098294541972A 1.548s 0.09547098294541972A 1.5480000000010001s 0.09547098294541972A 1.56s 0.09547098294541972A 1.5600000000010001s 0.09547098294541972A 1.572s 0.09547098294541972A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541972A 1.872s 0.09547098294541972A 1.8720000000010002s 0.09547113995276091A)
R_0_3_3_1 Node0_3_3 Node0_3_4 9.887809523809524
R_0_3_3_2 Node0_3_3 Node0_4_3 13.020765027322405
R_0_3_3_3 Node0_3_3 Node1_3_3 2.595018540202966
C_0_3_3 Node0_3_3 GND 0.00099241447536
I_0_3_4 GND Node0_3_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629112A 0.024s 0.09547506513629112A 0.024000000001s 0.09548197345930418A 0.036000000000000004s 0.09548197345930418A 0.036000000001s 0.09548338652537504A 0.048s 0.09548338652537504A 0.048000000001s 0.09548479959144592A 0.06s 0.09548479959144592A 0.060000000000999996s 0.09548464258410472A 0.07200000000000001s 0.09548464258410472A 0.07200000000100001s 0.0954753791509735A 0.084s 0.0954753791509735A 0.08400000000100001s 0.09548103141525695A 0.096s 0.09548103141525695A 0.09600000000100001s 0.09548307251069262A 0.108s 0.09548307251069262A 0.108000000001s 0.09548448557676348A 0.12s 0.09548448557676348A 0.120000000001s 0.09548511360612831A 0.132s 0.09548511360612831A 0.132000000001s 0.09547569316565592A 0.14400000000000002s 0.09547569316565592A 0.14400000000100002s 0.09547993236386851A 0.156s 0.09547993236386851A 0.156000000001s 0.0954827584960102A 0.168s 0.0954827584960102A 0.16800000000100002s 0.09548401455473987A 0.18s 0.09548401455473987A 0.180000000001s 0.09548479959144592A 0.192s 0.09548479959144592A 0.192000000001s 0.09547930433450368A 0.20400000000000001s 0.09547930433450368A 0.20400000000100002s 0.09547632119502074A 0.216s 0.09547632119502074A 0.216000000001s 0.09548165944462175A 0.228s 0.09548165944462175A 0.228000000001s 0.09548354353271624A 0.24s 0.09548354353271624A 0.240000000001s 0.09548448557676348A 0.252s 0.09548448557676348A 0.252000000001s 0.09548385754739865A 0.264s 0.09548385754739865A 0.264000000001s 0.09547569316565592A 0.276s 0.09547569316565592A 0.276000000001s 0.09548040338589212A 0.28800000000000003s 0.09548040338589212A 0.288000000001s 0.09548307251069262A 0.3s 0.09548307251069262A 0.30000000000099997s 0.09548448557676348A 0.312s 0.09548448557676348A 0.312000000001s 0.09548511360612831A 0.324s 0.09548511360612831A 0.324000000001s 0.09547585017299712A 0.336s 0.09547585017299712A 0.336000000001s 0.09547930433450368A 0.34800000000000003s 0.09547930433450368A 0.348000000001s 0.095482601488669A 0.36s 0.095482601488669A 0.36000000000099996s 0.09548385754739865A 0.372s 0.09548385754739865A 0.372000000001s 0.0954849565987871A 0.384s 0.0954849565987871A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.09547569316565592A 0.40800000000000003s 0.09547569316565592A 0.408000000001s 0.09548181645196296A 0.42s 0.09548181645196296A 0.42000000000099996s 0.09548354353271624A 0.432s 0.09548354353271624A 0.432000000001s 0.09548448557676348A 0.444s 0.09548448557676348A 0.444000000001s 0.09548448557676348A 0.456s 0.09548448557676348A 0.456000000001s 0.09547553615831472A 0.468s 0.09547553615831472A 0.468000000001s 0.09548056039323333A 0.48s 0.09548056039323333A 0.48000000000099996s 0.09548307251069262A 0.492s 0.09548307251069262A 0.49200000000099997s 0.09548448557676348A 0.504s 0.09548448557676348A 0.504000000001s 0.09548511360612831A 0.516s 0.09548511360612831A 0.516000000001s 0.0954760071803383A 0.528s 0.0954760071803383A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.0954827584960102A 0.552s 0.0954827584960102A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410472A 0.5760000000000001s 0.09548464258410472A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502074A 0.6s 0.09547632119502074A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537504A 0.624s 0.09548338652537504A 0.624000000001s 0.09548448557676348A 0.636s 0.09548448557676348A 0.636000000001s 0.09548338652537504A 0.648s 0.09548338652537504A 0.648000000001s 0.09547585017299712A 0.66s 0.09547585017299712A 0.660000000001s 0.09548008937120969A 0.672s 0.09548008937120969A 0.672000000001s 0.09547176798212575A 0.684s 0.09547176798212575A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541974A 1.08s 0.09547098294541974A 1.0800000000010002s 0.09547098294541974A 1.092s 0.09547098294541974A 1.0920000000010002s 0.09547098294541974A 1.104s 0.09547098294541974A 1.1040000000010002s 0.09547098294541974A 1.116s 0.09547098294541974A 1.1160000000010002s 0.09547098294541974A 1.1280000000000001s 0.09547098294541974A 1.1280000000010002s 0.09547098294541974A 1.1400000000000001s 0.09547098294541974A 1.1400000000010002s 0.09547098294541974A 1.1520000000000001s 0.09547098294541974A 1.1520000000010002s 0.09547098294541974A 1.164s 0.09547098294541974A 1.164000000001s 0.09547098294541974A 1.176s 0.09547098294541974A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541974A 1.476s 0.09547098294541974A 1.476000000001s 0.09547098294541974A 1.488s 0.09547098294541974A 1.488000000001s 0.09547098294541974A 1.5s 0.09547098294541974A 1.500000000001s 0.09547098294541974A 1.512s 0.09547098294541974A 1.512000000001s 0.09547098294541974A 1.524s 0.09547098294541974A 1.524000000001s 0.09547098294541974A 1.536s 0.09547098294541974A 1.5360000000010001s 0.09547098294541974A 1.548s 0.09547098294541974A 1.5480000000010001s 0.09547098294541974A 1.56s 0.09547098294541974A 1.5600000000010001s 0.09547098294541974A 1.572s 0.09547098294541974A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541974A 1.872s 0.09547098294541974A 1.8720000000010002s 0.09547113995276092A)
R_0_3_4_1 Node0_3_4 Node0_3_5 9.88780952380952
R_0_3_4_2 Node0_3_4 Node0_4_4 13.020765027322405
R_0_3_4_3 Node0_3_4 Node1_3_4 2.595018540202966
C_0_3_4 Node0_3_4 GND 0.0009924144753600001
I_0_3_5 GND Node0_3_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.12566446291622857A 0.024s 0.12566446291622857A 0.024000000001s 0.12567574742045368A 0.036000000000000004s 0.12567574742045368A 0.036000000001s 0.12567807195291666A 0.048s 0.12567807195291666A 0.048000000001s 0.12568038361471504A 0.06s 0.12568038361471504A 0.060000000000999996s 0.12568014758723403A 0.07200000000000001s 0.12568014758723403A 0.07200000000100001s 0.12566499173136028A 0.084s 0.12566499173136028A 0.08400000000100001s 0.12567420044868696A 0.096s 0.12567420044868696A 0.09600000000100001s 0.12567756532487218A 0.108s 0.12567756532487218A 0.108000000001s 0.12567988333224922A 0.12s 0.12567988333224922A 0.120000000001s 0.12568088741552147A 0.132s 0.12568088741552147A 0.132000000001s 0.1256655119032214A 0.14400000000000002s 0.1256655119032214A 0.14400000000100002s 0.12567240611356092A 0.156s 0.12567240611356092A 0.156000000001s 0.12567704129360677A 0.168s 0.12567704129360677A 0.16800000000100002s 0.12567909921056558A 0.18s 0.12567909921056558A 0.180000000001s 0.12568038361471504A 0.192s 0.12568038361471504A 0.192000000001s 0.1256713935755006A 0.20400000000000001s 0.1256713935755006A 0.20400000000100002s 0.12566651531334172A 0.216s 0.12566651531334172A 0.216000000001s 0.1256752609600406A 0.228s 0.1256752609600406A 0.228000000001s 0.12567832695430642A 0.24s 0.12567832695430642A 0.240000000001s 0.12567985508679477A 0.252s 0.12567985508679477A 0.252000000001s 0.1256788663872877A 0.264s 0.1256788663872877A 0.264000000001s 0.12566549725543566A 0.276s 0.12566549725543566A 0.276000000001s 0.1256731831806125A 0.28800000000000003s 0.1256731831806125A 0.288000000001s 0.12567756532487218A 0.3s 0.12567756532487218A 0.30000000000099997s 0.12567985508679477A 0.312s 0.12567985508679477A 0.312000000001s 0.12568088741552147A 0.324s 0.12568088741552147A 0.324000000001s 0.1256657564213919A 0.336s 0.1256657564213919A 0.336000000001s 0.1256713935755006A 0.34800000000000003s 0.1256713935755006A 0.348000000001s 0.1256767920813235A 0.36s 0.1256767920813235A 0.36000000000099996s 0.1256788405382541A 0.372s 0.1256788405382541A 0.372000000001s 0.12568062002813646A 0.384s 0.12568062002813646A 0.384000000001s 0.12567039392605567A 0.396s 0.12567039392605567A 0.396000000001s 0.12566547931369323A 0.40800000000000003s 0.12566547931369323A 0.408000000001s 0.1256755038087944A 0.42s 0.1256755038087944A 0.42000000000099996s 0.12567832695430642A 0.432s 0.12567832695430642A 0.432000000001s 0.12567985508679477A 0.444s 0.12567985508679477A 0.444000000001s 0.12567988333224922A 0.456s 0.12567988333224922A 0.456000000001s 0.12566524139241148A 0.468s 0.12566524139241148A 0.468000000001s 0.12567343180949742A 0.48s 0.12567343180949742A 0.48000000000099996s 0.12567756532487218A 0.492s 0.12567756532487218A 0.49200000000099997s 0.12567985508679477A 0.504s 0.12567985508679477A 0.504000000001s 0.12568088741552147A 0.516s 0.12568088741552147A 0.516000000001s 0.12566602757842765A 0.528s 0.12566602757842765A 0.528000000001s 0.12567090623550237A 0.54s 0.12567090623550237A 0.540000000001s 0.12567704129360677A 0.552s 0.12567704129360677A 0.552000000001s 0.12567860835222666A 0.5640000000000001s 0.12567860835222666A 0.564000000001s 0.12568011859682476A 0.5760000000000001s 0.12568011859682476A 0.576000000001s 0.12567165571230068A 0.588s 0.12567165571230068A 0.588000000001s 0.1256665431818311A 0.6s 0.1256665431818311A 0.600000000001s 0.12567498410365194A 0.612s 0.12567498410365194A 0.612000000001s 0.12567804820411702A 0.624s 0.12567804820411702A 0.624000000001s 0.12567988333224922A 0.636s 0.12567988333224922A 0.636000000001s 0.12567809597995247A 0.648s 0.12567809597995247A 0.648000000001s 0.12566576421200346A 0.66s 0.12566576421200346A 0.660000000001s 0.12567266330493823A 0.672s 0.12567266330493823A 0.672000000001s 0.12565906596673293A 0.684s 0.12565906596673293A 0.684000000001s 0.1256575568487219A 0.6960000000000001s 0.1256575568487219A 0.696000000001s 0.12565755662694078A 0.708s 0.12565755662694078A 0.7080000000009999s 0.1256575565192365A 0.72s 0.1256575565192365A 0.720000000001s 0.12565755651403077A 0.732s 0.12565755651403077A 0.732000000001s 0.12565755684333668A 0.744s 0.12565755684333668A 0.744000000001s 0.12565755655459937A 0.756s 0.12565755655459937A 0.756000000001s 0.12565755652318564A 0.768s 0.12565755652318564A 0.768000000001s 0.12565755664148084A 0.78s 0.12565755664148084A 0.780000000001s 0.12565755657694805A 0.792s 0.12565755657694805A 0.792000000001s 0.12565755670359036A 0.804s 0.12565755670359036A 0.804000000001s 0.12565755345944685A 0.8160000000000001s 0.12565755345944685A 0.816000000001s 0.1256575600899035A 0.8280000000000001s 0.1256575600899035A 0.828000000001s 0.12565756016565555A 0.84s 0.12565756016565555A 0.840000000001s 0.12565756008496706A 0.852s 0.12565756008496706A 0.852000000001s 0.12565756008335147A 0.864s 0.12565756008335147A 0.864000000001s 0.12565756008335147A 0.876s 0.12565756008335147A 0.876000000001s 0.12565756006369544A 0.888s 0.12565756006369544A 0.888000000001s 0.12565756010139195A 0.9s 0.12565756010139195A 0.900000000001s 0.12565756012445864A 0.912s 0.12565756012445864A 0.912000000001s 0.12565756009483994A 0.924s 0.12565756009483994A 0.924000000001s 0.12565755483913904A 0.936s 0.12565755483913904A 0.936000000001s 0.12565755971491302A 0.9480000000000001s 0.12565755971491302A 0.948000000001s 0.12565755964921338A 0.96s 0.12565755964921338A 0.9600000000009999s 0.12565755984864585A 0.972s 0.12565755984864585A 0.972000000001s 0.12565755974866036A 0.984s 0.12565755974866036A 0.984000000001s 0.12565755975027593A 0.996s 0.12565755975027593A 0.996000000001s 0.12565755971006634A 1.008s 0.12565755971006634A 1.008000000001s 0.12565755988921448A 1.02s 0.12565755988921448A 1.020000000001s 0.12565755985681343A 1.032s 0.12565755985681343A 1.0320000000010001s 0.1256575595901555A 1.044s 0.1256575595901555A 1.0440000000010001s 0.1256575359230316A 1.056s 0.1256575359230316A 1.0560000000010001s 0.12565753462330992A 1.068s 0.12565753462330992A 1.0680000000010001s 0.1256577711733363A 1.08s 0.1256577711733363A 1.0800000000010002s 0.12565777121561023A 1.092s 0.12565777121561023A 1.0920000000010002s 0.1256577711839272A 1.104s 0.1256577711839272A 1.1040000000010002s 0.1256577711207407A 1.116s 0.1256577711207407A 1.1160000000010002s 0.12565777119236407A 1.1280000000000001s 0.12565777119236407A 1.1280000000010002s 0.12565777133641856A 1.1400000000000001s 0.12565777133641856A 1.1400000000010002s 0.1256577712684751A 1.1520000000000001s 0.1256577712684751A 1.1520000000010002s 0.12565777107029918A 1.164s 0.12565777107029918A 1.164000000001s 0.12565777121767457A 1.176s 0.12565777121767457A 1.176000000001s 0.1256575591020755A 1.188s 0.1256575591020755A 1.188000000001s 0.12565756016565555A 1.2s 0.12565756016565555A 1.200000000001s 0.1256575601376524A 1.212s 0.1256575601376524A 1.212000000001s 0.1256575601179066A 1.224s 0.1256575601179066A 1.224000000001s 0.12565756012939508A 1.236s 0.12565756012939508A 1.236000000001s 0.12565756004242384A 1.248s 0.12565756004242384A 1.248000000001s 0.12565756008828793A 1.26s 0.12565756008828793A 1.260000000001s 0.12565756006692658A 1.272s 0.12565756006692658A 1.272000000001s 0.12565756004727055A 1.284s 0.12565756004727055A 1.2840000000010001s 0.1256575601195222A 1.296s 0.1256575601195222A 1.2960000000010001s 0.12565755483680546A 1.308s 0.12565755483680546A 1.3080000000010001s 0.12565755645138277A 1.32s 0.12565755645138277A 1.3200000000010002s 0.12565755652453195A 1.332s 0.12565755652453195A 1.3320000000010002s 0.12565755660064298A 1.344s 0.12565755660064298A 1.3440000000010002s 0.12565755660979783A 1.356s 0.12565755660979783A 1.3560000000010002s 0.12565755671947673A 1.368s 0.12565755671947673A 1.3680000000010002s 0.12565755650092672A 1.3800000000000001s 0.12565755650092672A 1.3800000000010002s 0.1256575566665221A 1.3920000000000001s 0.1256575566665221A 1.3920000000010002s 0.12565755667451017A 1.4040000000000001s 0.12565755667451017A 1.4040000000010002s 0.12565755662433795A 1.416s 0.12565755662433795A 1.416000000001s 0.12565755653368682A 1.428s 0.12565755653368682A 1.428000000001s 0.1256575448961467A 1.44s 0.1256575448961467A 1.440000000001s 0.12565753445600922A 1.452s 0.12565753445600922A 1.452000000001s 0.12565753845354433A 1.464s 0.12565753845354433A 1.464000000001s 0.1256577711797088A 1.476s 0.1256577711797088A 1.476000000001s 0.12565777122620114A 1.488s 0.12565777122620114A 1.488000000001s 0.12565777103260267A 1.5s 0.12565777103260267A 1.500000000001s 0.12565777123041957A 1.512s 0.12565777123041957A 1.512000000001s 0.12565777117755472A 1.524s 0.12565777117755472A 1.524000000001s 0.12565777111858661A 1.536s 0.12565777111858661A 1.5360000000010001s 0.12565777113124188A 1.548s 0.12565777113124188A 1.5480000000010001s 0.12565777116489948A 1.56s 0.12565777116489948A 1.5600000000010001s 0.12565777129602948A 1.572s 0.12565777129602948A 1.5720000000010002s 0.1256575577611569A 1.584s 0.1256575577611569A 1.5840000000010002s 0.12565756015901378A 1.596s 0.12565756015901378A 1.5960000000010002s 0.12565756009816081A 1.608s 0.12565756009816081A 1.6080000000010002s 0.1256575601475253A 1.62s 0.1256575601475253A 1.6200000000010002s 0.125657560139268A 1.6320000000000001s 0.125657560139268A 1.6320000000010002s 0.12565756002276782A 1.6440000000000001s 0.12565756002276782A 1.6440000000010002s 0.1256575601096493A 1.6560000000000001s 0.1256575601096493A 1.6560000000010002s 0.12565756005382256A 1.668s 0.12565756005382256A 1.668000000001s 0.12565756008173593A 1.68s 0.12565756008173593A 1.680000000001s 0.1256575600899035A 1.692s 0.1256575600899035A 1.692000000001s 0.12565755356724093A 1.704s 0.12565755356724093A 1.704000000001s 0.12565755655854852A 1.716s 0.12565755655854852A 1.716000000001s 0.1256575567566347A 1.728s 0.1256575567566347A 1.728000000001s 0.1256575566586238A 1.74s 0.1256575566586238A 1.740000000001s 0.1256575564970673A 1.752s 0.1256575564970673A 1.752000000001s 0.1256575564331628A 1.764s 0.1256575564331628A 1.764000000001s 0.12565755655854852A 1.776s 0.12565755655854852A 1.7760000000010001s 0.12565755664803288A 1.788s 0.12565755664803288A 1.7880000000010001s 0.1256575565887955A 1.8s 0.1256575565887955A 1.8000000000010001s 0.12565755659274466A 1.812s 0.12565755659274466A 1.8120000000010001s 0.1256575565166336A 1.824s 0.1256575565166336A 1.8240000000010002s 0.12565753739481098A 1.836s 0.12565753739481098A 1.8360000000010002s 0.12565753445439365A 1.848s 0.12565753445439365A 1.8480000000010002s 0.12565754967956422A 1.86s 0.12565754967956422A 1.8600000000010002s 0.12565777118177315A 1.872s 0.12565777118177315A 1.8720000000010002s 0.12565804805961292A)
R_0_3_5_1 Node0_3_5 Node0_3_6 9.88780952380952
R_0_3_5_2 Node0_3_5 Node0_4_5 13.020765027322389
R_0_3_5_3 Node0_3_5 Node1_3_5 2.595018540202963
C_0_3_5 Node0_3_5 GND 0.0009924144753600012
I_0_3_6 GND Node0_3_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861245A 0.024s 0.21364960617861245A 0.024000000001s 0.21367364479385648A 0.036000000000000004s 0.21367364479385648A 0.036000000001s 0.21367862573906665A 0.048s 0.21367862573906665A 0.048000000001s 0.21368355630285157A 0.06s 0.21368355630285157A 0.060000000000999996s 0.2136830899760326A 0.07200000000000001s 0.2136830899760326A 0.07200000000100001s 0.213650761016444A 0.084s 0.213650761016444A 0.08400000000100001s 0.2136703347974528A 0.096s 0.2136703347974528A 0.09600000000100001s 0.21367755775122355A 0.108s 0.21367755775122355A 0.108000000001s 0.21368251315438613A 0.12s 0.21368251315438613A 0.120000000001s 0.21368461322364518A 0.132s 0.21368461322364518A 0.132000000001s 0.21365188202072427A 0.14400000000000002s 0.21365188202072427A 0.14400000000100002s 0.2136665141006317A 0.156s 0.2136665141006317A 0.156000000001s 0.21367642163954234A 0.168s 0.21367642163954234A 0.16800000000100002s 0.21368081652299808A 0.18s 0.21368081652299808A 0.180000000001s 0.21368355630285157A 0.192s 0.21368355630285157A 0.192000000001s 0.21366438093562462A 0.20400000000000001s 0.21366438093562462A 0.20400000000100002s 0.21365397945497155A 0.216s 0.21365397945497155A 0.216000000001s 0.2136726557509664A 0.228s 0.2136726557509664A 0.228000000001s 0.21367916633808445A 0.24s 0.21367916633808445A 0.240000000001s 0.21368240258929166A 0.252s 0.21368240258929166A 0.252000000001s 0.21368036273883523A 0.264s 0.21368036273883523A 0.264000000001s 0.2136518246828678A 0.276s 0.2136518246828678A 0.276000000001s 0.2136681831170962A 0.28800000000000003s 0.2136681831170962A 0.288000000001s 0.21367755775122355A 0.3s 0.21367755775122355A 0.30000000000099997s 0.21368240258929166A 0.312s 0.21368240258929166A 0.312000000001s 0.21368461322364518A 0.324s 0.21368461322364518A 0.324000000001s 0.21365238158382518A 0.336s 0.21365238158382518A 0.336000000001s 0.21366438093562462A 0.34800000000000003s 0.21366438093562462A 0.348000000001s 0.21367590370162592A 0.36s 0.21367590370162592A 0.36000000000099996s 0.21368026155438274A 0.372s 0.21368026155438274A 0.372000000001s 0.21368402414041054A 0.384s 0.21368402414041054A 0.384000000001s 0.21366229822230987A 0.396s 0.21366229822230987A 0.396000000001s 0.21365175445102041A 0.40800000000000003s 0.21365175445102041A 0.408000000001s 0.21367314877923804A 0.42s 0.21367314877923804A 0.42000000000099996s 0.21367916633808445A 0.432s 0.21367916633808445A 0.432000000001s 0.21368240258929166A 0.444s 0.21368240258929166A 0.444000000001s 0.21368251315438613A 0.456s 0.21368251315438613A 0.456000000001s 0.21365128071103495A 0.468s 0.21365128071103495A 0.468000000001s 0.21366869877133576A 0.48s 0.21366869877133576A 0.48000000000099996s 0.21367755775122355A 0.492s 0.21367755775122355A 0.49200000000099997s 0.21368240258929166A 0.504s 0.21368240258929166A 0.504000000001s 0.21368461322364518A 0.516s 0.21368461322364518A 0.516000000001s 0.2136529854231258A 0.528s 0.2136529854231258A 0.528000000001s 0.21366338844965244A 0.54s 0.21366338844965244A 0.540000000001s 0.21367642163954234A 0.552s 0.21367642163954234A 0.552000000001s 0.21367981026469768A 0.5640000000000001s 0.21367981026469768A 0.564000000001s 0.2136829764948584A 0.5760000000000001s 0.2136829764948584A 0.576000000001s 0.2136649494657673A 0.588s 0.2136649494657673A 0.588000000001s 0.21365408854445944A 0.6s 0.21365408854445944A 0.600000000001s 0.21367202960189932A 0.612s 0.21367202960189932A 0.612000000001s 0.21367853277585092A 0.624s 0.21367853277585092A 0.624000000001s 0.21368251315438613A 0.636s 0.21368251315438613A 0.636000000001s 0.21367871979142064A 0.648s 0.21367871979142064A 0.648000000001s 0.21365241207969493A 0.66s 0.21365241207969493A 0.660000000001s 0.21366706327222112A 0.672s 0.21366706327222112A 0.672000000001s 0.21363808950475838A 0.684s 0.21363808950475838A 0.684000000001s 0.2136349276845534A 0.6960000000000001s 0.2136349276845534A 0.696000000001s 0.21363492681640484A 0.708s 0.21363492681640484A 0.7080000000009999s 0.213634926394803A 0.72s 0.213634926394803A 0.720000000001s 0.21363492637442555A 0.732s 0.21363492637442555A 0.732000000001s 0.2136349276634733A 0.744s 0.2136349276634733A 0.744000000001s 0.21363492653322894A 0.756s 0.21363492653322894A 0.756000000001s 0.21363492641026172A 0.768s 0.21363492641026172A 0.768000000001s 0.2136349268733211A 0.78s 0.2136349268733211A 0.780000000001s 0.21363492662071132A 0.792s 0.21363492662071132A 0.792000000001s 0.21363492711644486A 0.804s 0.21363492711644486A 0.804000000001s 0.2136349144174447A 0.8160000000000001s 0.2136349144174447A 0.816000000001s 0.21363494037195946A 0.8280000000000001s 0.21363494037195946A 0.828000000001s 0.21363494066848615A 0.84s 0.21363494066848615A 0.840000000001s 0.21363494035263603A 0.852s 0.21363494035263603A 0.852000000001s 0.21363494034631203A 0.864s 0.21363494034631203A 0.864000000001s 0.21363494034631203A 0.876s 0.21363494034631203A 0.876000000001s 0.21363494026936966A 0.888s 0.21363494026936966A 0.888000000001s 0.21363494041693032A 0.9s 0.21363494041693032A 0.900000000001s 0.21363494050722343A 0.912s 0.21363494050722343A 0.912000000001s 0.21363494039128292A 0.924s 0.21363494039128292A 0.924000000001s 0.2136349198181649A 0.936s 0.2136349198181649A 0.936000000001s 0.21363493890408222A 0.9480000000000001s 0.21363493890408222A 0.948000000001s 0.21363493864690508A 0.96s 0.21363493864690508A 0.9600000000009999s 0.21363493942757122A 0.972s 0.21363493942757122A 0.972000000001s 0.21363493903618413A 0.984s 0.21363493903618413A 0.984000000001s 0.2136349390425082A 0.996s 0.2136349390425082A 0.996000000001s 0.2136349388851102A 1.008s 0.2136349388851102A 1.008000000001s 0.21363493958637458A 1.02s 0.21363493958637458A 1.020000000001s 0.2136349394595427A 1.032s 0.2136349394595427A 1.0320000000010001s 0.21363493841572673A 1.044s 0.21363493841572673A 1.0440000000010001s 0.21363484577222566A 1.056s 0.21363484577222566A 1.0560000000010001s 0.21363484068454497A 1.068s 0.21363484068454497A 1.0680000000010001s 0.2136353090568357A 1.08s 0.2136353090568357A 1.0800000000010002s 0.21363530922231444A 1.092s 0.21363530922231444A 1.0920000000010002s 0.21363530909829317A 1.104s 0.21363530909829317A 1.1040000000010002s 0.21363530885095344A 1.116s 0.21363530885095344A 1.1160000000010002s 0.2136353091313187A 1.1280000000000001s 0.2136353091313187A 1.1280000000010002s 0.21363530969521122A 1.1400000000000001s 0.21363530969521122A 1.1400000000010002s 0.21363530942925069A 1.1520000000000001s 0.21363530942925069A 1.1520000000010002s 0.21363530865350322A 1.164s 0.21363530865350322A 1.164000000001s 0.21363530923039517A 1.176s 0.21363530923039517A 1.176000000001s 0.21363493650516752A 1.188s 0.21363493650516752A 1.188000000001s 0.21363494066848615A 1.2s 0.21363494066848615A 1.200000000001s 0.2136349405588696A 1.212s 0.2136349405588696A 1.212000000001s 0.213634940481576A 1.224s 0.213634940481576A 1.224000000001s 0.2136349405265468A 1.236s 0.2136349405265468A 1.236000000001s 0.21363494018610332A 1.248s 0.21363494018610332A 1.248000000001s 0.2136349403656354A 1.26s 0.2136349403656354A 1.260000000001s 0.2136349402820177A 1.272s 0.2136349402820177A 1.272000000001s 0.2136349402050754A 1.284s 0.2136349402050754A 1.2840000000010001s 0.21363494048789997A 1.296s 0.21363494048789997A 1.2960000000010001s 0.21363491980903015A 1.308s 0.21363491980903015A 1.3080000000010001s 0.2136349261291938A 1.32s 0.2136349261291938A 1.3200000000010002s 0.21363492641553172A 1.332s 0.21363492641553172A 1.3320000000010002s 0.21363492671346374A 1.344s 0.21363492671346374A 1.3440000000010002s 0.2136349267492999A 1.356s 0.2136349267492999A 1.3560000000010002s 0.21363492717863114A 1.368s 0.21363492717863114A 1.3680000000010002s 0.21363492632313064A 1.3800000000000001s 0.21363492632313064A 1.3800000000010002s 0.21363492697134356A 1.3920000000000001s 0.21363492697134356A 1.3920000000010002s 0.21363492700261238A 1.4040000000000001s 0.21363492700261238A 1.4040000000010002s 0.21363492680621615A 1.416s 0.21363492680621615A 1.416000000001s 0.2136349264513679A 1.428s 0.2136349264513679A 1.428000000001s 0.21363488089693278A 1.44s 0.21363488089693278A 1.440000000001s 0.21363484002965671A 1.452s 0.21363484002965671A 1.452000000001s 0.21363485567776197A 1.464s 0.21363485567776197A 1.464000000001s 0.21363530908178047A 1.476s 0.21363530908178047A 1.476000000001s 0.21363530926377197A 1.488s 0.21363530926377197A 1.488000000001s 0.21363530850594256A 1.5s 0.21363530850594256A 1.500000000001s 0.2136353092802847A 1.512s 0.2136353092802847A 1.512000000001s 0.21363530907334846A 1.524s 0.21363530907334846A 1.524000000001s 0.2136353088425214A 1.536s 0.2136353088425214A 1.5360000000010001s 0.21363530889205967A 1.548s 0.21363530889205967A 1.5480000000010001s 0.21363530902381028A 1.56s 0.21363530902381028A 1.5600000000010001s 0.21363530953711057A 1.572s 0.21363530953711057A 1.5720000000010002s 0.21363493125622407A 1.584s 0.21363493125622407A 1.5840000000010002s 0.21363494064248736A 1.596s 0.21363494064248736A 1.5960000000010002s 0.2136349404042823A 1.608s 0.2136349404042823A 1.6080000000010002s 0.21363494059751648A 1.62s 0.21363494059751648A 1.6200000000010002s 0.2136349405651937A 1.6320000000000001s 0.2136349405651937A 1.6320000000010002s 0.21363494010916098A 1.6440000000000001s 0.21363494010916098A 1.6440000000010002s 0.21363494044925313A 1.6560000000000001s 0.21363494044925313A 1.6560000000010002s 0.21363494023072283A 1.668s 0.21363494023072283A 1.668000000001s 0.21363494033998798A 1.68s 0.21363494033998798A 1.680000000001s 0.21363494037195946A 1.692s 0.21363494037195946A 1.692000000001s 0.21363491483939792A 1.704s 0.21363491483939792A 1.704000000001s 0.21363492654868763A 1.716s 0.21363492654868763A 1.716000000001s 0.2136349273240838A 1.728s 0.2136349273240838A 1.728000000001s 0.21363492694042607A 1.74s 0.21363492694042607A 1.740000000001s 0.21363492630802322A 1.752s 0.21363492630802322A 1.752000000001s 0.21363492605787282A 1.764s 0.21363492605787282A 1.764000000001s 0.21363492654868763A 1.776s 0.21363492654868763A 1.7760000000010001s 0.21363492689896857A 1.788s 0.21363492689896857A 1.7880000000010001s 0.2136349266670875A 1.8s 0.2136349266670875A 1.8000000000010001s 0.2136349266825462A 1.812s 0.2136349266825462A 1.8120000000010001s 0.21363492638461426A 1.824s 0.21363492638461426A 1.8240000000010002s 0.2136348515334155A 1.836s 0.2136348515334155A 1.8360000000010002s 0.21363484002333266A 1.848s 0.21363484002333266A 1.8480000000010002s 0.21363489962132656A 1.86s 0.21363489962132656A 1.8600000000010002s 0.2136353090898612A 1.872s 0.2136353090898612A 1.8720000000010002s 0.2136359353228973A)
R_0_3_6_1 Node0_3_6 Node0_3_7 9.887809523809524
R_0_3_6_2 Node0_3_6 Node0_4_6 13.020765027322405
R_0_3_6_3 Node0_3_6 Node1_3_6 2.595018540202966
C_0_3_6 Node0_3_6 GND 0.00099241447536
I_0_3_7 GND Node0_3_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861245A 0.024s 0.21364960617861245A 0.024000000001s 0.21367364479385648A 0.036000000000000004s 0.21367364479385648A 0.036000000001s 0.21367862573906665A 0.048s 0.21367862573906665A 0.048000000001s 0.21368355630285157A 0.06s 0.21368355630285157A 0.060000000000999996s 0.2136830899760326A 0.07200000000000001s 0.2136830899760326A 0.07200000000100001s 0.213650761016444A 0.084s 0.213650761016444A 0.08400000000100001s 0.2136703347974528A 0.096s 0.2136703347974528A 0.09600000000100001s 0.21367755775122355A 0.108s 0.21367755775122355A 0.108000000001s 0.21368251315438613A 0.12s 0.21368251315438613A 0.120000000001s 0.21368461322364518A 0.132s 0.21368461322364518A 0.132000000001s 0.21365188202072427A 0.14400000000000002s 0.21365188202072427A 0.14400000000100002s 0.2136665141006317A 0.156s 0.2136665141006317A 0.156000000001s 0.21367642163954234A 0.168s 0.21367642163954234A 0.16800000000100002s 0.21368081652299808A 0.18s 0.21368081652299808A 0.180000000001s 0.21368355630285157A 0.192s 0.21368355630285157A 0.192000000001s 0.21366438093562462A 0.20400000000000001s 0.21366438093562462A 0.20400000000100002s 0.21365397945497155A 0.216s 0.21365397945497155A 0.216000000001s 0.2136726557509664A 0.228s 0.2136726557509664A 0.228000000001s 0.21367916633808445A 0.24s 0.21367916633808445A 0.240000000001s 0.21368240258929166A 0.252s 0.21368240258929166A 0.252000000001s 0.21368036273883523A 0.264s 0.21368036273883523A 0.264000000001s 0.2136518246828678A 0.276s 0.2136518246828678A 0.276000000001s 0.2136681831170962A 0.28800000000000003s 0.2136681831170962A 0.288000000001s 0.21367755775122355A 0.3s 0.21367755775122355A 0.30000000000099997s 0.21368240258929166A 0.312s 0.21368240258929166A 0.312000000001s 0.21368461322364518A 0.324s 0.21368461322364518A 0.324000000001s 0.21365238158382518A 0.336s 0.21365238158382518A 0.336000000001s 0.21366438093562462A 0.34800000000000003s 0.21366438093562462A 0.348000000001s 0.21367590370162592A 0.36s 0.21367590370162592A 0.36000000000099996s 0.21368026155438274A 0.372s 0.21368026155438274A 0.372000000001s 0.21368402414041054A 0.384s 0.21368402414041054A 0.384000000001s 0.21366229822230987A 0.396s 0.21366229822230987A 0.396000000001s 0.21365175445102041A 0.40800000000000003s 0.21365175445102041A 0.408000000001s 0.21367314877923804A 0.42s 0.21367314877923804A 0.42000000000099996s 0.21367916633808445A 0.432s 0.21367916633808445A 0.432000000001s 0.21368240258929166A 0.444s 0.21368240258929166A 0.444000000001s 0.21368251315438613A 0.456s 0.21368251315438613A 0.456000000001s 0.21365128071103495A 0.468s 0.21365128071103495A 0.468000000001s 0.21366869877133576A 0.48s 0.21366869877133576A 0.48000000000099996s 0.21367755775122355A 0.492s 0.21367755775122355A 0.49200000000099997s 0.21368240258929166A 0.504s 0.21368240258929166A 0.504000000001s 0.21368461322364518A 0.516s 0.21368461322364518A 0.516000000001s 0.2136529854231258A 0.528s 0.2136529854231258A 0.528000000001s 0.21366338844965244A 0.54s 0.21366338844965244A 0.540000000001s 0.21367642163954234A 0.552s 0.21367642163954234A 0.552000000001s 0.21367981026469768A 0.5640000000000001s 0.21367981026469768A 0.564000000001s 0.2136829764948584A 0.5760000000000001s 0.2136829764948584A 0.576000000001s 0.2136649494657673A 0.588s 0.2136649494657673A 0.588000000001s 0.21365408854445944A 0.6s 0.21365408854445944A 0.600000000001s 0.21367202960189932A 0.612s 0.21367202960189932A 0.612000000001s 0.21367853277585092A 0.624s 0.21367853277585092A 0.624000000001s 0.21368251315438613A 0.636s 0.21368251315438613A 0.636000000001s 0.21367871979142064A 0.648s 0.21367871979142064A 0.648000000001s 0.21365241207969493A 0.66s 0.21365241207969493A 0.660000000001s 0.21366706327222112A 0.672s 0.21366706327222112A 0.672000000001s 0.21363808950475838A 0.684s 0.21363808950475838A 0.684000000001s 0.2136349276845534A 0.6960000000000001s 0.2136349276845534A 0.696000000001s 0.21363492681640484A 0.708s 0.21363492681640484A 0.7080000000009999s 0.213634926394803A 0.72s 0.213634926394803A 0.720000000001s 0.21363492637442555A 0.732s 0.21363492637442555A 0.732000000001s 0.2136349276634733A 0.744s 0.2136349276634733A 0.744000000001s 0.21363492653322894A 0.756s 0.21363492653322894A 0.756000000001s 0.21363492641026172A 0.768s 0.21363492641026172A 0.768000000001s 0.2136349268733211A 0.78s 0.2136349268733211A 0.780000000001s 0.21363492662071132A 0.792s 0.21363492662071132A 0.792000000001s 0.21363492711644486A 0.804s 0.21363492711644486A 0.804000000001s 0.2136349144174447A 0.8160000000000001s 0.2136349144174447A 0.816000000001s 0.21363494037195946A 0.8280000000000001s 0.21363494037195946A 0.828000000001s 0.21363494066848615A 0.84s 0.21363494066848615A 0.840000000001s 0.21363494035263603A 0.852s 0.21363494035263603A 0.852000000001s 0.21363494034631203A 0.864s 0.21363494034631203A 0.864000000001s 0.21363494034631203A 0.876s 0.21363494034631203A 0.876000000001s 0.21363494026936966A 0.888s 0.21363494026936966A 0.888000000001s 0.21363494041693032A 0.9s 0.21363494041693032A 0.900000000001s 0.21363494050722343A 0.912s 0.21363494050722343A 0.912000000001s 0.21363494039128292A 0.924s 0.21363494039128292A 0.924000000001s 0.2136349198181649A 0.936s 0.2136349198181649A 0.936000000001s 0.21363493890408222A 0.9480000000000001s 0.21363493890408222A 0.948000000001s 0.21363493864690508A 0.96s 0.21363493864690508A 0.9600000000009999s 0.21363493942757122A 0.972s 0.21363493942757122A 0.972000000001s 0.21363493903618413A 0.984s 0.21363493903618413A 0.984000000001s 0.2136349390425082A 0.996s 0.2136349390425082A 0.996000000001s 0.2136349388851102A 1.008s 0.2136349388851102A 1.008000000001s 0.21363493958637458A 1.02s 0.21363493958637458A 1.020000000001s 0.2136349394595427A 1.032s 0.2136349394595427A 1.0320000000010001s 0.21363493841572673A 1.044s 0.21363493841572673A 1.0440000000010001s 0.21363484577222566A 1.056s 0.21363484577222566A 1.0560000000010001s 0.21363484068454497A 1.068s 0.21363484068454497A 1.0680000000010001s 0.2136353090568357A 1.08s 0.2136353090568357A 1.0800000000010002s 0.21363530922231444A 1.092s 0.21363530922231444A 1.0920000000010002s 0.21363530909829317A 1.104s 0.21363530909829317A 1.1040000000010002s 0.21363530885095344A 1.116s 0.21363530885095344A 1.1160000000010002s 0.2136353091313187A 1.1280000000000001s 0.2136353091313187A 1.1280000000010002s 0.21363530969521122A 1.1400000000000001s 0.21363530969521122A 1.1400000000010002s 0.21363530942925069A 1.1520000000000001s 0.21363530942925069A 1.1520000000010002s 0.21363530865350322A 1.164s 0.21363530865350322A 1.164000000001s 0.21363530923039517A 1.176s 0.21363530923039517A 1.176000000001s 0.21363493650516752A 1.188s 0.21363493650516752A 1.188000000001s 0.21363494066848615A 1.2s 0.21363494066848615A 1.200000000001s 0.2136349405588696A 1.212s 0.2136349405588696A 1.212000000001s 0.213634940481576A 1.224s 0.213634940481576A 1.224000000001s 0.2136349405265468A 1.236s 0.2136349405265468A 1.236000000001s 0.21363494018610332A 1.248s 0.21363494018610332A 1.248000000001s 0.2136349403656354A 1.26s 0.2136349403656354A 1.260000000001s 0.2136349402820177A 1.272s 0.2136349402820177A 1.272000000001s 0.2136349402050754A 1.284s 0.2136349402050754A 1.2840000000010001s 0.21363494048789997A 1.296s 0.21363494048789997A 1.2960000000010001s 0.21363491980903015A 1.308s 0.21363491980903015A 1.3080000000010001s 0.2136349261291938A 1.32s 0.2136349261291938A 1.3200000000010002s 0.21363492641553172A 1.332s 0.21363492641553172A 1.3320000000010002s 0.21363492671346374A 1.344s 0.21363492671346374A 1.3440000000010002s 0.2136349267492999A 1.356s 0.2136349267492999A 1.3560000000010002s 0.21363492717863114A 1.368s 0.21363492717863114A 1.3680000000010002s 0.21363492632313064A 1.3800000000000001s 0.21363492632313064A 1.3800000000010002s 0.21363492697134356A 1.3920000000000001s 0.21363492697134356A 1.3920000000010002s 0.21363492700261238A 1.4040000000000001s 0.21363492700261238A 1.4040000000010002s 0.21363492680621615A 1.416s 0.21363492680621615A 1.416000000001s 0.2136349264513679A 1.428s 0.2136349264513679A 1.428000000001s 0.21363488089693278A 1.44s 0.21363488089693278A 1.440000000001s 0.21363484002965671A 1.452s 0.21363484002965671A 1.452000000001s 0.21363485567776197A 1.464s 0.21363485567776197A 1.464000000001s 0.21363530908178047A 1.476s 0.21363530908178047A 1.476000000001s 0.21363530926377197A 1.488s 0.21363530926377197A 1.488000000001s 0.21363530850594256A 1.5s 0.21363530850594256A 1.500000000001s 0.2136353092802847A 1.512s 0.2136353092802847A 1.512000000001s 0.21363530907334846A 1.524s 0.21363530907334846A 1.524000000001s 0.2136353088425214A 1.536s 0.2136353088425214A 1.5360000000010001s 0.21363530889205967A 1.548s 0.21363530889205967A 1.5480000000010001s 0.21363530902381028A 1.56s 0.21363530902381028A 1.5600000000010001s 0.21363530953711057A 1.572s 0.21363530953711057A 1.5720000000010002s 0.21363493125622407A 1.584s 0.21363493125622407A 1.5840000000010002s 0.21363494064248736A 1.596s 0.21363494064248736A 1.5960000000010002s 0.2136349404042823A 1.608s 0.2136349404042823A 1.6080000000010002s 0.21363494059751648A 1.62s 0.21363494059751648A 1.6200000000010002s 0.2136349405651937A 1.6320000000000001s 0.2136349405651937A 1.6320000000010002s 0.21363494010916098A 1.6440000000000001s 0.21363494010916098A 1.6440000000010002s 0.21363494044925313A 1.6560000000000001s 0.21363494044925313A 1.6560000000010002s 0.21363494023072283A 1.668s 0.21363494023072283A 1.668000000001s 0.21363494033998798A 1.68s 0.21363494033998798A 1.680000000001s 0.21363494037195946A 1.692s 0.21363494037195946A 1.692000000001s 0.21363491483939792A 1.704s 0.21363491483939792A 1.704000000001s 0.21363492654868763A 1.716s 0.21363492654868763A 1.716000000001s 0.2136349273240838A 1.728s 0.2136349273240838A 1.728000000001s 0.21363492694042607A 1.74s 0.21363492694042607A 1.740000000001s 0.21363492630802322A 1.752s 0.21363492630802322A 1.752000000001s 0.21363492605787282A 1.764s 0.21363492605787282A 1.764000000001s 0.21363492654868763A 1.776s 0.21363492654868763A 1.7760000000010001s 0.21363492689896857A 1.788s 0.21363492689896857A 1.7880000000010001s 0.2136349266670875A 1.8s 0.2136349266670875A 1.8000000000010001s 0.2136349266825462A 1.812s 0.2136349266825462A 1.8120000000010001s 0.21363492638461426A 1.824s 0.21363492638461426A 1.8240000000010002s 0.2136348515334155A 1.836s 0.2136348515334155A 1.8360000000010002s 0.21363484002333266A 1.848s 0.21363484002333266A 1.8480000000010002s 0.21363489962132656A 1.86s 0.21363489962132656A 1.8600000000010002s 0.2136353090898612A 1.872s 0.2136353090898612A 1.8720000000010002s 0.2136359353228973A)
R_0_3_7_1 Node0_3_7 Node0_3_8 9.887809523809532
R_0_3_7_2 Node0_3_7 Node0_4_7 13.020765027322405
R_0_3_7_3 Node0_3_7 Node1_3_7 2.595018540202966
C_0_3_7 Node0_3_7 GND 0.00099241447536
I_0_3_8 GND Node0_3_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.042029430723661214A 0.024s 0.042029430723661214A 0.024000000001s 0.042034159631578076A 0.036000000000000004s 0.042034159631578076A 0.036000000001s 0.04203513948965221A 0.048s 0.04203513948965221A 0.048000000001s 0.042036109436626286A 0.06s 0.042036109436626286A 0.060000000000999996s 0.04203601770020289A 0.07200000000000001s 0.04203601770020289A 0.07200000000100001s 0.04202965790487398A 0.084s 0.04202965790487398A 0.08400000000100001s 0.04203350848474456A 0.096s 0.04203350848474456A 0.09600000000100001s 0.04203492939368307A 0.108s 0.04203492939368307A 0.108000000001s 0.04203590422709211A 0.12s 0.04203590422709211A 0.120000000001s 0.04203631735547094A 0.132s 0.04203631735547094A 0.132000000001s 0.042029878430306165A 0.14400000000000002s 0.042029878430306165A 0.14400000000100002s 0.04203275687225516A 0.156s 0.04203275687225516A 0.156000000001s 0.04203470589630317A 0.168s 0.04203470589630317A 0.16800000000100002s 0.04203557046354036A 0.18s 0.04203557046354036A 0.180000000001s 0.042036109436626286A 0.192s 0.042036109436626286A 0.192000000001s 0.04203233723323738A 0.20400000000000001s 0.04203233723323738A 0.20400000000100002s 0.04203029104032202A 0.216s 0.04203029104032202A 0.216000000001s 0.04203396506576362A 0.228s 0.04203396506576362A 0.228000000001s 0.04203524583699997A 0.24s 0.04203524583699997A 0.240000000001s 0.042035882476581715A 0.252s 0.042035882476581715A 0.252000000001s 0.042035481194524715A 0.264s 0.042035481194524715A 0.264000000001s 0.042029867150727845A 0.276s 0.042029867150727845A 0.276000000001s 0.042033085203362935A 0.28800000000000003s 0.042033085203362935A 0.288000000001s 0.04203492939368307A 0.3s 0.04203492939368307A 0.30000000000099997s 0.042035882476581715A 0.312s 0.042035882476581715A 0.312000000001s 0.04203631735547094A 0.324s 0.04203631735547094A 0.324000000001s 0.04202997670501454A 0.336s 0.04202997670501454A 0.336000000001s 0.04203233723323738A 0.34800000000000003s 0.04203233723323738A 0.348000000001s 0.04203460400687698A 0.36s 0.04203460400687698A 0.36000000000099996s 0.04203546128938652A 0.372s 0.04203546128938652A 0.372000000001s 0.04203620147024445A 0.384s 0.04203620147024445A 0.384000000001s 0.04203192751914268A 0.396s 0.04203192751914268A 0.396000000001s 0.042029853334626714A 0.40800000000000003s 0.042029853334626714A 0.408000000001s 0.04203406205493183A 0.42s 0.04203406205493183A 0.42000000000099996s 0.04203524583699997A 0.432s 0.04203524583699997A 0.432000000001s 0.042035882476581715A 0.444s 0.042035882476581715A 0.444000000001s 0.04203590422709211A 0.456s 0.04203590422709211A 0.456000000001s 0.04202976013987548A 0.468s 0.04202976013987548A 0.468000000001s 0.042033186643541214A 0.48s 0.042033186643541214A 0.48000000000099996s 0.04203492939368307A 0.492s 0.04203492939368307A 0.49200000000099997s 0.042035882476581715A 0.504s 0.042035882476581715A 0.504000000001s 0.04203631735547094A 0.516s 0.04203631735547094A 0.516000000001s 0.042030095493073676A 0.528s 0.042030095493073676A 0.528000000001s 0.04203214199009532A 0.54s 0.04203214199009532A 0.540000000001s 0.04203470589630317A 0.552s 0.04203470589630317A 0.552000000001s 0.042035372511087826A 0.5640000000000001s 0.042035372511087826A 0.564000000001s 0.04203599537603747A 0.5760000000000001s 0.04203599537603747A 0.576000000001s 0.04203244907523267A 0.588s 0.04203244907523267A 0.588000000001s 0.042030312500549144A 0.6s 0.042030312500549144A 0.600000000001s 0.04203384188889798A 0.612s 0.04203384188889798A 0.612000000001s 0.04203512120180648A 0.624s 0.04203512120180648A 0.624000000001s 0.04203590422709211A 0.636s 0.04203590422709211A 0.636000000001s 0.04203515799175463A 0.648s 0.04203515799175463A 0.648000000001s 0.04202998270420204A 0.66s 0.04202998270420204A 0.660000000001s 0.04203286490601047A 0.672s 0.04203286490601047A 0.672000000001s 0.04202716514847681A 0.684s 0.04202716514847681A 0.684000000001s 0.042026543151059435A 0.6960000000000001s 0.042026543151059435A 0.696000000001s 0.04202654298027611A 0.708s 0.04202654298027611A 0.7080000000009999s 0.042026542897338044A 0.72s 0.042026542897338044A 0.720000000001s 0.04202654289332937A 0.732s 0.04202654289332937A 0.732000000001s 0.04202654314691253A 0.744s 0.04202654314691253A 0.744000000001s 0.04202654292456938A 0.756s 0.04202654292456938A 0.756000000001s 0.042026542900379105A 0.768s 0.042026542900379105A 0.768000000001s 0.04202654299147276A 0.78s 0.04202654299147276A 0.780000000001s 0.04202654294177902A 0.792s 0.04202654294177902A 0.792000000001s 0.042026543039300375A 0.804s 0.042026543039300375A 0.804000000001s 0.042026540541136415A 0.8160000000000001s 0.042026540541136415A 0.816000000001s 0.042026545646942595A 0.8280000000000001s 0.042026545646942595A 0.828000000001s 0.04202654570527571A 0.84s 0.04202654570527571A 0.840000000001s 0.04202654564314127A 0.852s 0.04202654564314127A 0.852000000001s 0.0420265456418972A 0.864s 0.0420265456418972A 0.864000000001s 0.0420265456418972A 0.876s 0.0420265456418972A 0.876000000001s 0.042026545626760996A 0.888s 0.042026545626760996A 0.888000000001s 0.042026545655789324A 0.9s 0.042026545655789324A 0.900000000001s 0.04202654567355191A 0.912s 0.04202654567355191A 0.912000000001s 0.04202654565074393A 0.924s 0.04202654565074393A 0.924000000001s 0.04202654160357318A 0.936s 0.04202654160357318A 0.936000000001s 0.042026545358179866A 0.9480000000000001s 0.042026545358179866A 0.948000000001s 0.042026545307587634A 0.96s 0.042026545307587634A 0.9600000000009999s 0.04202654546116131A 0.972s 0.04202654546116131A 0.972000000001s 0.04202654538416713A 0.984s 0.04202654538416713A 0.984000000001s 0.0420265453854112A 0.996s 0.0420265453854112A 0.996000000001s 0.04202654535444766A 1.008s 0.04202654535444766A 1.008000000001s 0.04202654549240131A 1.02s 0.04202654549240131A 1.020000000001s 0.04202654546745078A 1.032s 0.04202654546745078A 1.0320000000010001s 0.04202654526210992A 1.044s 0.04202654526210992A 1.0440000000010001s 0.0420265270371589A 1.056s 0.0420265270371589A 1.0560000000010001s 0.042026526036303684A 1.068s 0.042026526036303684A 1.0680000000010001s 0.042026618175114966A 1.08s 0.042026618175114966A 1.0800000000010002s 0.04202661820766816A 1.092s 0.04202661820766816A 1.0920000000010002s 0.04202661818327054A 1.104s 0.04202661818327054A 1.1040000000010002s 0.042026618134613544A 1.116s 0.042026618134613544A 1.1160000000010002s 0.04202661818976736A 1.1280000000000001s 0.04202661818976736A 1.1280000000010002s 0.042026618300697045A 1.1400000000000001s 0.042026618300697045A 1.1400000000010002s 0.04202661824837694A 1.1520000000000001s 0.04202661824837694A 1.1520000000010002s 0.04202661809577088A 1.164s 0.04202661809577088A 1.164000000001s 0.042026618209257814A 1.176s 0.042026618209257814A 1.176000000001s 0.04202654488626222A 1.188s 0.04202654488626222A 1.188000000001s 0.04202654570527571A 1.2s 0.04202654570527571A 1.200000000001s 0.04202654568371181A 1.212s 0.04202654568371181A 1.212000000001s 0.042026545668506506A 1.224s 0.042026545668506506A 1.224000000001s 0.04202654567735323A 1.236s 0.04202654567735323A 1.236000000001s 0.04202654561038073A 1.248s 0.04202654561038073A 1.248000000001s 0.04202654564569853A 1.26s 0.04202654564569853A 1.260000000001s 0.04202654562924914A 1.272s 0.04202654562924914A 1.272000000001s 0.04202654561411294A 1.284s 0.04202654561411294A 1.2840000000010001s 0.042026545669750566A 1.296s 0.042026545669750566A 1.2960000000010001s 0.04202654160177618A 1.308s 0.04202654160177618A 1.3080000000010001s 0.04202654284508705A 1.32s 0.04202654284508705A 1.3200000000010002s 0.042026542901415824A 1.332s 0.042026542901415824A 1.3320000000010002s 0.042026542960025406A 1.344s 0.042026542960025406A 1.3440000000010002s 0.04202654296707514A 1.356s 0.04202654296707514A 1.3560000000010002s 0.04202654305153374A 1.368s 0.04202654305153374A 1.3680000000010002s 0.042026542883238566A 1.3800000000000001s 0.042026542883238566A 1.3800000000010002s 0.04202654301075586A 1.3920000000000001s 0.04202654301075586A 1.3920000000010002s 0.0420265430169071A 1.4040000000000001s 0.0420265430169071A 1.4040000000010002s 0.04202654297827178A 1.416s 0.04202654297827178A 1.416000000001s 0.04202654290846557A 1.428s 0.04202654290846557A 1.428000000001s 0.04202653394693735A 1.44s 0.04202653394693735A 1.440000000001s 0.0420265259074732A 1.452s 0.0420265259074732A 1.452000000001s 0.04202652898578899A 1.464s 0.04202652898578899A 1.464000000001s 0.042026618180022145A 1.476s 0.042026618180022145A 1.476000000001s 0.04202661821582375A 1.488s 0.04202661821582375A 1.488000000001s 0.04202661806674255A 1.5s 0.04202661806674255A 1.500000000001s 0.04202661821907216A 1.512s 0.04202661821907216A 1.512000000001s 0.04202661817836338A 1.524s 0.04202661817836338A 1.524000000001s 0.04202661813295479A 1.536s 0.04202661813295479A 1.5360000000010001s 0.042026618142700006A 1.548s 0.042026618142700006A 1.5480000000010001s 0.04202661816861817A 1.56s 0.04202661816861817A 1.5600000000010001s 0.04202661826959527A 1.572s 0.04202661826959527A 1.5720000000010002s 0.04202654385368317A 1.584s 0.04202654385368317A 1.5840000000010002s 0.0420265457001612A 1.596s 0.0420265457001612A 1.5960000000010002s 0.04202654565330119A 1.608s 0.04202654565330119A 1.6080000000010002s 0.04202654569131447A 1.62s 0.04202654569131447A 1.6200000000010002s 0.04202654568495589A 1.6320000000000001s 0.04202654568495589A 1.6320000000010002s 0.04202654559524453A 1.6440000000000001s 0.04202654559524453A 1.6440000000010002s 0.042026545662147904A 1.6560000000000001s 0.042026545662147904A 1.6560000000010002s 0.042026545619158334A 1.668s 0.042026545619158334A 1.668000000001s 0.04202654564065313A 1.68s 0.04202654564065313A 1.680000000001s 0.042026545646942595A 1.692s 0.042026545646942595A 1.692000000001s 0.0420265406241436A 1.704s 0.0420265406241436A 1.704000000001s 0.04202654292761043A 1.716s 0.04202654292761043A 1.716000000001s 0.04202654308014738A 1.728s 0.04202654308014738A 1.728000000001s 0.042026543004673726A 1.74s 0.042026543004673726A 1.740000000001s 0.04202654288026661A 1.752s 0.04202654288026661A 1.752000000001s 0.042026542831056696A 1.764s 0.042026542831056696A 1.764000000001s 0.04202654292761043A 1.776s 0.04202654292761043A 1.7760000000010001s 0.04202654299651815A 1.788s 0.04202654299651815A 1.7880000000010001s 0.04202654295090221A 1.8s 0.04202654295090221A 1.8000000000010001s 0.04202654295394327A 1.812s 0.04202654295394327A 1.8120000000010001s 0.042026542895333696A 1.824s 0.042026542895333696A 1.8240000000010002s 0.04202652817050772A 1.836s 0.04202652817050772A 1.8360000000010002s 0.04202652590622913A 1.848s 0.04202652590622913A 1.8480000000010002s 0.042026537630424646A 1.86s 0.042026537630424646A 1.8600000000010002s 0.04202661818161179A 1.872s 0.04202661818161179A 1.8720000000010002s 0.04202674137499594A)
R_0_3_8_1 Node0_3_8 Node0_3_9 9.887809523809532
R_0_3_8_2 Node0_3_8 Node0_4_8 13.020765027322419
R_0_3_8_3 Node0_3_8 Node1_3_8 2.5950185402029695
C_0_3_8 Node0_3_8 GND 0.0009924144753599986
R_0_3_9_2 Node0_3_9 Node0_4_9 13.020765027322405
R_0_3_9_3 Node0_3_9 Node1_3_9 2.595018540202966
C_0_3_9 Node0_3_9 GND 0.0009924144753600001
I_0_4_0 GND Node0_4_0 PWL(0s 0A 0.012s 0A 0.012000000001s 1.741689535968294A 0.024s 1.741689535968294A 0.024000000001s 7.505876178549929A 0.036000000000000004s 7.505876178549929A 0.036000000001s 8.483211308364845A 0.048s 8.483211308364845A 0.048000000001s 9.389404664335023A 0.06s 9.389404664335023A 0.060000000000999996s 10.220542162452729A 0.07200000000000001s 10.220542162452729A 0.07200000000100001s 4.728651903037433A 0.084s 4.728651903037433A 0.08400000000100001s 5.7849723607186965A 0.096s 5.7849723607186965A 0.09600000000100001s 8.049998267306206A 0.108s 8.049998267306206A 0.108000000001s 9.275013369563517A 0.12s 9.275013369563517A 0.120000000001s 10.17450207688795A 0.132s 10.17450207688795A 0.132000000001s 6.373968009641A 0.14400000000000002s 6.373968009641A 0.14400000000100002s 3.465464004713756A 0.156s 3.465464004713756A 0.156000000001s 7.447766359515683A 0.168s 7.447766359515683A 0.16800000000100002s 8.780437691250038A 0.18s 8.780437691250038A 0.180000000001s 9.432536795811348A 0.192s 9.432536795811348A 0.192000000001s 10.5498684279569A 0.20400000000000001s 10.5498684279569A 0.20400000000100002s 2.7955423993042405A 0.216s 2.7955423993042405A 0.216000000001s 6.66279645335943A 0.228s 6.66279645335943A 0.228000000001s 8.109302053805935A 0.24s 8.109302053805935A 0.240000000001s 9.447257589950445A 0.252s 9.447257589950445A 0.252000000001s 9.676579295315811A 0.264s 9.676579295315811A 0.264000000001s 5.986123313480459A 0.276s 5.986123313480459A 0.276000000001s 4.012188847771891A 0.28800000000000003s 4.012188847771891A 0.288000000001s 7.385138802570828A 0.3s 7.385138802570828A 0.30000000000099997s 9.150291075855739A 0.312s 9.150291075855739A 0.312000000001s 9.439056117222213A 0.324s 9.439056117222213A 0.324000000001s 7.86528184541036A 0.336s 7.86528184541036A 0.336000000001s 1.9005830926031444A 0.34800000000000003s 1.9005830926031444A 0.348000000001s 7.624103643654467A 0.36s 7.624103643654467A 0.36000000000099996s 8.235546086407236A 0.372s 8.235546086407236A 0.372000000001s 9.366052180274735A 0.384s 9.366052180274735A 0.384000000001s 10.404840885572945A 0.396s 10.404840885572945A 0.396000000001s 3.345826772407921A 0.40800000000000003s 3.345826772407921A 0.408000000001s 7.179183832266077A 0.42s 7.179183832266077A 0.42000000000099996s 8.29176326918198A 0.432s 8.29176326918198A 0.432000000001s 9.278475599086935A 0.444s 9.278475599086935A 0.444000000001s 10.055937558087196A 0.456s 10.055937558087196A 0.456000000001s 5.633242394943901A 0.468s 5.633242394943901A 0.468000000001s 4.451521932456726A 0.48s 4.451521932456726A 0.48000000000099996s 7.694732744854951A 0.492s 7.694732744854951A 0.49200000000099997s 9.269433326106434A 0.504s 9.269433326106434A 0.504000000001s 9.500051821734747A 0.516s 9.500051821734747A 0.516000000001s 7.683982272881707A 0.528s 7.683982272881707A 0.528000000001s 2.087423239170632A 0.54s 2.087423239170632A 0.540000000001s 7.611721527426548A 0.552s 7.611721527426548A 0.552000000001s 8.140668057328583A 0.5640000000000001s 8.140668057328583A 0.564000000001s 9.433107711645205A 0.5760000000000001s 9.433107711645205A 0.576000000001s 10.53191154949803A 0.588s 10.53191154949803A 0.588000000001s 3.871152511502808A 0.6s 3.871152511502808A 0.600000000001s 5.123204770146788A 0.612s 5.123204770146788A 0.612000000001s 7.819716794510176A 0.624s 7.819716794510176A 0.624000000001s 9.22134522293399A 0.636s 9.22134522293399A 0.636000000001s 9.888173294500719A 0.648s 9.888173294500719A 0.648000000001s 6.813627556860705A 0.66s 6.813627556860705A 0.660000000001s 2.646212315091897A 0.672s 2.646212315091897A 0.672000000001s 7.247047443037224A 0.684s 7.247047443037224A 0.684000000001s 6.910118206445153A 0.6960000000000001s 6.910118206445153A 0.696000000001s 6.926704660042006A 0.708s 6.926704660042006A 0.7080000000009999s 6.987849347123737A 0.72s 6.987849347123737A 0.720000000001s 6.851710233578369A 0.732s 6.851710233578369A 0.732000000001s 6.968478765322916A 0.744s 6.968478765322916A 0.744000000001s 6.857261743388168A 0.756s 6.857261743388168A 0.756000000001s 6.927918488522382A 0.768s 6.927918488522382A 0.768000000001s 6.95288603677678A 0.78s 6.95288603677678A 0.780000000001s 6.881902616959099A 0.792s 6.881902616959099A 0.792000000001s 6.998414506618701A 0.804s 6.998414506618701A 0.804000000001s 5.143603657435585A 0.8160000000000001s 5.143603657435585A 0.816000000001s 7.755543222086249A 0.8280000000000001s 7.755543222086249A 0.828000000001s 7.746706480137929A 0.84s 7.746706480137929A 0.840000000001s 7.701016630435434A 0.852s 7.701016630435434A 0.852000000001s 7.707495965474809A 0.864s 7.707495965474809A 0.864000000001s 7.71470672959737A 0.876s 7.71470672959737A 0.876000000001s 7.713016808676694A 0.888s 7.713016808676694A 0.888000000001s 7.757547637925107A 0.9s 7.757547637925107A 0.900000000001s 7.727379396399618A 0.912s 7.727379396399618A 0.912000000001s 7.701100582762136A 0.924s 7.701100582762136A 0.924000000001s 5.708091392974897A 0.936s 5.708091392974897A 0.936000000001s 7.72791660358834A 0.9480000000000001s 7.72791660358834A 0.948000000001s 7.739782153573932A 0.96s 7.739782153573932A 0.9600000000009999s 7.732087685236232A 0.972s 7.732087685236232A 0.972000000001s 7.735249163861505A 0.984s 7.735249163861505A 0.984000000001s 7.738303853557509A 0.996s 7.738303853557509A 0.996000000001s 7.729059964472478A 1.008s 7.729059964472478A 1.008000000001s 7.7691732928733295A 1.02s 7.7691732928733295A 1.020000000001s 7.760564700958718A 1.032s 7.760564700958718A 1.0320000000010001s 7.699930034488649A 1.044s 7.699930034488649A 1.0440000000010001s 2.201472456243245A 1.056s 2.201472456243245A 1.0560000000010001s 2.0379007266170586A 1.068s 2.0379007266170586A 1.0680000000010001s 8.729104830615626A 1.08s 8.729104830615626A 1.0800000000010002s 8.752726096862508A 1.092s 8.752726096862508A 1.0920000000010002s 8.686021417595208A 1.104s 8.686021417595208A 1.1040000000010002s 8.711933537835243A 1.116s 8.711933537835243A 1.1160000000010002s 8.678653841006115A 1.1280000000000001s 8.678653841006115A 1.1280000000010002s 8.70846669915965A 1.1400000000000001s 8.70846669915965A 1.1400000000010002s 8.732958589866131A 1.1520000000000001s 8.732958589866131A 1.1520000000010002s 8.674370097982864A 1.164s 8.674370097982864A 1.164000000001s 8.736034158815448A 1.176s 8.736034158815448A 1.176000000001s 8.217789435209285A 1.188s 8.217789435209285A 1.188000000001s 7.720882226990299A 1.2s 7.720882226990299A 1.200000000001s 7.7382499158621885A 1.212s 7.7382499158621885A 1.212000000001s 7.758695566194861A 1.224s 7.758695566194861A 1.224000000001s 7.733781086434834A 1.236s 7.733781086434834A 1.236000000001s 7.685516119174222A 1.248s 7.685516119174222A 1.248000000001s 7.687500090718939A 1.26s 7.687500090718939A 1.260000000001s 7.717670289684299A 1.272s 7.717670289684299A 1.272000000001s 7.730554359627132A 1.284s 7.730554359627132A 1.2840000000010001s 7.751091139679161A 1.296s 7.751091139679161A 1.2960000000010001s 5.680446505617656A 1.308s 5.680446505617656A 1.3080000000010001s 6.8618839052398215A 1.32s 6.8618839052398215A 1.3200000000010002s 6.909082504123275A 1.332s 6.909082504123275A 1.3320000000010002s 6.979286211423403A 1.344s 6.979286211423403A 1.3440000000010002s 6.870269784473268A 1.356s 6.870269784473268A 1.3560000000010002s 6.981215592324843A 1.368s 6.981215592324843A 1.3680000000010002s 6.842826947987797A 1.3800000000000001s 6.842826947987797A 1.3800000000010002s 6.9571469428865464A 1.3920000000000001s 6.9571469428865464A 1.3920000000010002s 6.891391620781466A 1.4040000000000001s 6.891391620781466A 1.4040000000010002s 6.916584491570159A 1.416s 6.916584491570159A 1.416000000001s 6.963914238510188A 1.428s 6.963914238510188A 1.428000000001s 3.5306437516296563A 1.44s 3.5306437516296563A 1.440000000001s 1.9460742965068536A 1.452s 1.9460742965068536A 1.452000000001s 2.932476341910933A 1.464s 2.932476341910933A 1.464000000001s 8.75552675463627A 1.476s 8.75552675463627A 1.476000000001s 8.731952684510615A 1.488s 8.731952684510615A 1.488000000001s 8.635978879653672A 1.5s 8.635978879653672A 1.500000000001s 8.766298749809383A 1.512s 8.766298749809383A 1.512000000001s 8.66881989335172A 1.524s 8.66881989335172A 1.524000000001s 8.677229913988022A 1.536s 8.677229913988022A 1.5360000000010001s 8.716189441583492A 1.548s 8.716189441583492A 1.5480000000010001s 8.714027125867668A 1.56s 8.714027125867668A 1.5600000000010001s 8.723988524614743A 1.572s 8.723988524614743A 1.5720000000010002s 7.8415353977779345A 1.584s 7.8415353977779345A 1.5840000000010002s 7.728705886479002A 1.596s 7.728705886479002A 1.5960000000010002s 7.731627905329761A 1.608s 7.731627905329761A 1.6080000000010002s 7.758492862729279A 1.62s 7.758492862729279A 1.6200000000010002s 7.733111207898027A 1.6320000000000001s 7.733111207898027A 1.6320000000010002s 7.669332027334326A 1.6440000000000001s 7.669332027334326A 1.6440000000010002s 7.699240799831573A 1.6560000000000001s 7.699240799831573A 1.6560000000010002s 7.723226584260858A 1.668s 7.723226584260858A 1.668000000001s 7.735957539177136A 1.68s 7.735957539177136A 1.680000000001s 7.7371328715570025A 1.692s 7.7371328715570025A 1.692000000001s 5.421039514532263A 1.704s 5.421039514532263A 1.704000000001s 6.934980052474837A 1.716s 6.934980052474837A 1.716000000001s 6.923005321182484A 1.728s 6.923005321182484A 1.728000000001s 6.9067227048803375A 1.74s 6.9067227048803375A 1.740000000001s 6.9820222736644935A 1.752s 6.9820222736644935A 1.752000000001s 6.850785888053879A 1.764s 6.850785888053879A 1.764000000001s 6.931948634536119A 1.776s 6.931948634536119A 1.7760000000010001s 6.905307912663989A 1.788s 6.905307912663989A 1.7880000000010001s 6.889521833021336A 1.8s 6.889521833021336A 1.8000000000010001s 6.999504581550902A 1.812s 6.999504581550902A 1.8120000000010001s 6.866557178206206A 1.824s 6.866557178206206A 1.8240000000010002s 2.1530002204435554A 1.836s 2.1530002204435554A 1.8360000000010002s 1.945675414276032A 1.848s 1.945675414276032A 1.8480000000010002s 5.537615123665265A 1.86s 5.537615123665265A 1.8600000000010002s 8.75685628956971A 1.872s 8.75685628956971A 1.8720000000010002s 8.712348535711278A)
R_0_4_0_1 Node0_4_0 Node0_4_1 9.88780952380952
R_0_4_0_2 Node0_4_0 Node0_5_0 13.020765027322405
R_0_4_0_3 Node0_4_0 Node1_4_0 2.5950185402029646
C_0_4_0 Node0_4_0 GND 0.0009924144753600006
I_0_4_1 GND Node0_4_1 PWL(0s 0A 0.012s 0A 0.012000000001s 1.741689535968294A 0.024s 1.741689535968294A 0.024000000001s 7.505876178549929A 0.036000000000000004s 7.505876178549929A 0.036000000001s 8.483211308364845A 0.048s 8.483211308364845A 0.048000000001s 9.389404664335023A 0.06s 9.389404664335023A 0.060000000000999996s 10.220542162452729A 0.07200000000000001s 10.220542162452729A 0.07200000000100001s 4.728651903037433A 0.084s 4.728651903037433A 0.08400000000100001s 5.7849723607186965A 0.096s 5.7849723607186965A 0.09600000000100001s 8.049998267306206A 0.108s 8.049998267306206A 0.108000000001s 9.275013369563517A 0.12s 9.275013369563517A 0.120000000001s 10.17450207688795A 0.132s 10.17450207688795A 0.132000000001s 6.373968009641A 0.14400000000000002s 6.373968009641A 0.14400000000100002s 3.465464004713756A 0.156s 3.465464004713756A 0.156000000001s 7.447766359515683A 0.168s 7.447766359515683A 0.16800000000100002s 8.780437691250038A 0.18s 8.780437691250038A 0.180000000001s 9.432536795811348A 0.192s 9.432536795811348A 0.192000000001s 10.5498684279569A 0.20400000000000001s 10.5498684279569A 0.20400000000100002s 2.7955423993042405A 0.216s 2.7955423993042405A 0.216000000001s 6.66279645335943A 0.228s 6.66279645335943A 0.228000000001s 8.109302053805935A 0.24s 8.109302053805935A 0.240000000001s 9.447257589950445A 0.252s 9.447257589950445A 0.252000000001s 9.676579295315811A 0.264s 9.676579295315811A 0.264000000001s 5.986123313480459A 0.276s 5.986123313480459A 0.276000000001s 4.012188847771891A 0.28800000000000003s 4.012188847771891A 0.288000000001s 7.385138802570828A 0.3s 7.385138802570828A 0.30000000000099997s 9.150291075855739A 0.312s 9.150291075855739A 0.312000000001s 9.439056117222213A 0.324s 9.439056117222213A 0.324000000001s 7.86528184541036A 0.336s 7.86528184541036A 0.336000000001s 1.9005830926031444A 0.34800000000000003s 1.9005830926031444A 0.348000000001s 7.624103643654467A 0.36s 7.624103643654467A 0.36000000000099996s 8.235546086407236A 0.372s 8.235546086407236A 0.372000000001s 9.366052180274735A 0.384s 9.366052180274735A 0.384000000001s 10.404840885572945A 0.396s 10.404840885572945A 0.396000000001s 3.345826772407921A 0.40800000000000003s 3.345826772407921A 0.408000000001s 7.179183832266077A 0.42s 7.179183832266077A 0.42000000000099996s 8.29176326918198A 0.432s 8.29176326918198A 0.432000000001s 9.278475599086935A 0.444s 9.278475599086935A 0.444000000001s 10.055937558087196A 0.456s 10.055937558087196A 0.456000000001s 5.633242394943901A 0.468s 5.633242394943901A 0.468000000001s 4.451521932456726A 0.48s 4.451521932456726A 0.48000000000099996s 7.694732744854951A 0.492s 7.694732744854951A 0.49200000000099997s 9.269433326106434A 0.504s 9.269433326106434A 0.504000000001s 9.500051821734747A 0.516s 9.500051821734747A 0.516000000001s 7.683982272881707A 0.528s 7.683982272881707A 0.528000000001s 2.087423239170632A 0.54s 2.087423239170632A 0.540000000001s 7.611721527426548A 0.552s 7.611721527426548A 0.552000000001s 8.140668057328583A 0.5640000000000001s 8.140668057328583A 0.564000000001s 9.433107711645205A 0.5760000000000001s 9.433107711645205A 0.576000000001s 10.53191154949803A 0.588s 10.53191154949803A 0.588000000001s 3.871152511502808A 0.6s 3.871152511502808A 0.600000000001s 5.123204770146788A 0.612s 5.123204770146788A 0.612000000001s 7.819716794510176A 0.624s 7.819716794510176A 0.624000000001s 9.22134522293399A 0.636s 9.22134522293399A 0.636000000001s 9.888173294500719A 0.648s 9.888173294500719A 0.648000000001s 6.813627556860705A 0.66s 6.813627556860705A 0.660000000001s 2.646212315091897A 0.672s 2.646212315091897A 0.672000000001s 7.247047443037224A 0.684s 7.247047443037224A 0.684000000001s 6.910118206445153A 0.6960000000000001s 6.910118206445153A 0.696000000001s 6.926704660042006A 0.708s 6.926704660042006A 0.7080000000009999s 6.987849347123737A 0.72s 6.987849347123737A 0.720000000001s 6.851710233578369A 0.732s 6.851710233578369A 0.732000000001s 6.968478765322916A 0.744s 6.968478765322916A 0.744000000001s 6.857261743388168A 0.756s 6.857261743388168A 0.756000000001s 6.927918488522382A 0.768s 6.927918488522382A 0.768000000001s 6.95288603677678A 0.78s 6.95288603677678A 0.780000000001s 6.881902616959099A 0.792s 6.881902616959099A 0.792000000001s 6.998414506618701A 0.804s 6.998414506618701A 0.804000000001s 5.143603657435585A 0.8160000000000001s 5.143603657435585A 0.816000000001s 7.755543222086249A 0.8280000000000001s 7.755543222086249A 0.828000000001s 7.746706480137929A 0.84s 7.746706480137929A 0.840000000001s 7.701016630435434A 0.852s 7.701016630435434A 0.852000000001s 7.707495965474809A 0.864s 7.707495965474809A 0.864000000001s 7.71470672959737A 0.876s 7.71470672959737A 0.876000000001s 7.713016808676694A 0.888s 7.713016808676694A 0.888000000001s 7.757547637925107A 0.9s 7.757547637925107A 0.900000000001s 7.727379396399618A 0.912s 7.727379396399618A 0.912000000001s 7.701100582762136A 0.924s 7.701100582762136A 0.924000000001s 5.708091392974897A 0.936s 5.708091392974897A 0.936000000001s 7.72791660358834A 0.9480000000000001s 7.72791660358834A 0.948000000001s 7.739782153573932A 0.96s 7.739782153573932A 0.9600000000009999s 7.732087685236232A 0.972s 7.732087685236232A 0.972000000001s 7.735249163861505A 0.984s 7.735249163861505A 0.984000000001s 7.738303853557509A 0.996s 7.738303853557509A 0.996000000001s 7.729059964472478A 1.008s 7.729059964472478A 1.008000000001s 7.7691732928733295A 1.02s 7.7691732928733295A 1.020000000001s 7.760564700958718A 1.032s 7.760564700958718A 1.0320000000010001s 7.699930034488649A 1.044s 7.699930034488649A 1.0440000000010001s 2.201472456243245A 1.056s 2.201472456243245A 1.0560000000010001s 2.0379007266170586A 1.068s 2.0379007266170586A 1.0680000000010001s 8.729104830615626A 1.08s 8.729104830615626A 1.0800000000010002s 8.752726096862508A 1.092s 8.752726096862508A 1.0920000000010002s 8.686021417595208A 1.104s 8.686021417595208A 1.1040000000010002s 8.711933537835243A 1.116s 8.711933537835243A 1.1160000000010002s 8.678653841006115A 1.1280000000000001s 8.678653841006115A 1.1280000000010002s 8.70846669915965A 1.1400000000000001s 8.70846669915965A 1.1400000000010002s 8.732958589866131A 1.1520000000000001s 8.732958589866131A 1.1520000000010002s 8.674370097982864A 1.164s 8.674370097982864A 1.164000000001s 8.736034158815448A 1.176s 8.736034158815448A 1.176000000001s 8.217789435209285A 1.188s 8.217789435209285A 1.188000000001s 7.720882226990299A 1.2s 7.720882226990299A 1.200000000001s 7.7382499158621885A 1.212s 7.7382499158621885A 1.212000000001s 7.758695566194861A 1.224s 7.758695566194861A 1.224000000001s 7.733781086434834A 1.236s 7.733781086434834A 1.236000000001s 7.685516119174222A 1.248s 7.685516119174222A 1.248000000001s 7.687500090718939A 1.26s 7.687500090718939A 1.260000000001s 7.717670289684299A 1.272s 7.717670289684299A 1.272000000001s 7.730554359627132A 1.284s 7.730554359627132A 1.2840000000010001s 7.751091139679161A 1.296s 7.751091139679161A 1.2960000000010001s 5.680446505617656A 1.308s 5.680446505617656A 1.3080000000010001s 6.8618839052398215A 1.32s 6.8618839052398215A 1.3200000000010002s 6.909082504123275A 1.332s 6.909082504123275A 1.3320000000010002s 6.979286211423403A 1.344s 6.979286211423403A 1.3440000000010002s 6.870269784473268A 1.356s 6.870269784473268A 1.3560000000010002s 6.981215592324843A 1.368s 6.981215592324843A 1.3680000000010002s 6.842826947987797A 1.3800000000000001s 6.842826947987797A 1.3800000000010002s 6.9571469428865464A 1.3920000000000001s 6.9571469428865464A 1.3920000000010002s 6.891391620781466A 1.4040000000000001s 6.891391620781466A 1.4040000000010002s 6.916584491570159A 1.416s 6.916584491570159A 1.416000000001s 6.963914238510188A 1.428s 6.963914238510188A 1.428000000001s 3.5306437516296563A 1.44s 3.5306437516296563A 1.440000000001s 1.9460742965068536A 1.452s 1.9460742965068536A 1.452000000001s 2.932476341910933A 1.464s 2.932476341910933A 1.464000000001s 8.75552675463627A 1.476s 8.75552675463627A 1.476000000001s 8.731952684510615A 1.488s 8.731952684510615A 1.488000000001s 8.635978879653672A 1.5s 8.635978879653672A 1.500000000001s 8.766298749809383A 1.512s 8.766298749809383A 1.512000000001s 8.66881989335172A 1.524s 8.66881989335172A 1.524000000001s 8.677229913988022A 1.536s 8.677229913988022A 1.5360000000010001s 8.716189441583492A 1.548s 8.716189441583492A 1.5480000000010001s 8.714027125867668A 1.56s 8.714027125867668A 1.5600000000010001s 8.723988524614743A 1.572s 8.723988524614743A 1.5720000000010002s 7.8415353977779345A 1.584s 7.8415353977779345A 1.5840000000010002s 7.728705886479002A 1.596s 7.728705886479002A 1.5960000000010002s 7.731627905329761A 1.608s 7.731627905329761A 1.6080000000010002s 7.758492862729279A 1.62s 7.758492862729279A 1.6200000000010002s 7.733111207898027A 1.6320000000000001s 7.733111207898027A 1.6320000000010002s 7.669332027334325A 1.6440000000000001s 7.669332027334325A 1.6440000000010002s 7.699240799831573A 1.6560000000000001s 7.699240799831573A 1.6560000000010002s 7.723226584260858A 1.668s 7.723226584260858A 1.668000000001s 7.735957539177136A 1.68s 7.735957539177136A 1.680000000001s 7.737132871557002A 1.692s 7.737132871557002A 1.692000000001s 5.421039514532263A 1.704s 5.421039514532263A 1.704000000001s 6.934980052474837A 1.716s 6.934980052474837A 1.716000000001s 6.923005321182484A 1.728s 6.923005321182484A 1.728000000001s 6.9067227048803375A 1.74s 6.9067227048803375A 1.740000000001s 6.9820222736644935A 1.752s 6.9820222736644935A 1.752000000001s 6.850785888053879A 1.764s 6.850785888053879A 1.764000000001s 6.931948634536119A 1.776s 6.931948634536119A 1.7760000000010001s 6.905307912663989A 1.788s 6.905307912663989A 1.7880000000010001s 6.889521833021336A 1.8s 6.889521833021336A 1.8000000000010001s 6.999504581550902A 1.812s 6.999504581550902A 1.8120000000010001s 6.866557178206206A 1.824s 6.866557178206206A 1.8240000000010002s 2.1530002204435554A 1.836s 2.1530002204435554A 1.8360000000010002s 1.945675414276032A 1.848s 1.945675414276032A 1.8480000000010002s 5.537615123665265A 1.86s 5.537615123665265A 1.8600000000010002s 8.75685628956971A 1.872s 8.75685628956971A 1.8720000000010002s 8.712348535711278A)
R_0_4_1_1 Node0_4_1 Node0_4_2 9.88780952380952
R_0_4_1_2 Node0_4_1 Node0_5_1 13.020765027322405
R_0_4_1_3 Node0_4_1 Node1_4_1 2.595018540202965
C_0_4_1 Node0_4_1 GND 0.0009924144753600006
I_0_4_2 GND Node0_4_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.8398698600070463A 0.024s 0.8398698600070463A 0.024000000001s 3.446356948712031A 0.036000000000000004s 3.446356948712031A 0.036000000001s 3.8882947828762817A 0.048s 3.8882947828762817A 0.048000000001s 4.2980633176653855A 0.06s 4.2980633176653855A 0.060000000000999996s 4.6738917997924565A 0.07200000000000001s 4.6738917997924565A 0.07200000000100001s 2.1905319767007243A 0.084s 2.1905319767007243A 0.08400000000100001s 2.6681881762232322A 0.096s 2.6681881762232322A 0.09600000000100001s 3.6924018286272418A 0.108s 3.6924018286272418A 0.108000000001s 4.246337027379515A 0.12s 4.246337027379515A 0.120000000001s 4.653073385254055A 0.132s 4.653073385254055A 0.132000000001s 2.93452071605273A 0.14400000000000002s 2.93452071605273A 0.14400000000100002s 1.619338850325361A 0.156s 1.619338850325361A 0.156000000001s 3.4200809442029927A 0.168s 3.4200809442029927A 0.16800000000100002s 4.0226966743718755A 0.18s 4.0226966743718755A 0.180000000001s 4.31756705471274A 0.192s 4.31756705471274A 0.192000000001s 4.822805533732061A 0.20400000000000001s 4.822805533732061A 0.20400000000100002s 1.3164078401214574A 0.216s 1.3164078401214574A 0.216000000001s 3.0651281031410718A 0.228s 3.0651281031410718A 0.228000000001s 3.7192184163475175A 0.24s 3.7192184163475175A 0.240000000001s 4.324223416652838A 0.252s 4.324223416652838A 0.252000000001s 4.427919089653059A 0.264s 4.427919089653059A 0.264000000001s 2.7591428548107366A 0.276s 2.7591428548107366A 0.276000000001s 1.8665603147134404A 0.28800000000000003s 1.8665603147134404A 0.288000000001s 3.39176182476466A 0.3s 3.39176182476466A 0.30000000000099997s 4.189939378175588A 0.312s 4.189939378175588A 0.312000000001s 4.3205151712521985A 0.324s 4.3205151712521985A 0.324000000001s 3.608871730533061A 0.336s 3.608871730533061A 0.336000000001s 0.9117215911062522A 0.34800000000000003s 0.9117215911062522A 0.348000000001s 3.4998180727412356A 0.36s 3.4998180727412356A 0.36000000000099996s 3.7763043462804666A 0.372s 3.7763043462804666A 0.372000000001s 4.287503742168101A 0.384s 4.287503742168101A 0.384000000001s 4.75722579552323A 0.396s 4.75722579552323A 0.396000000001s 1.565238271347609A 0.40800000000000003s 1.565238271347609A 0.408000000001s 3.298631225242224A 0.42s 3.298631225242224A 0.42000000000099996s 3.8017247855954284A 0.432s 3.8017247855954284A 0.432000000001s 4.247902598379858A 0.444s 4.247902598379858A 0.444000000001s 4.599459850332162A 0.456s 4.599459850332162A 0.456000000001s 2.5995750310463315A 0.468s 2.5995750310463315A 0.468000000001s 2.065220579727954A 0.48s 2.065220579727954A 0.48000000000099996s 3.5317558068630817A 0.492s 3.5317558068630817A 0.49200000000099997s 4.243813811007528A 0.504s 4.243813811007528A 0.504000000001s 4.348096562227129A 0.516s 4.348096562227129A 0.516000000001s 3.5268907256873767A 0.528s 3.5268907256873767A 0.528000000001s 0.9962078788029062A 0.54s 0.9962078788029062A 0.540000000001s 3.4942191417145994A 0.552s 3.4942191417145994A 0.552000000001s 3.7334017635141024A 0.5640000000000001s 3.7334017635141024A 0.564000000001s 4.317825128730584A 0.5760000000000001s 4.317825128730584A 0.576000000001s 4.814685774428861A 0.588s 4.814685774428861A 0.588000000001s 1.8027834509653449A 0.6s 1.8027834509653449A 0.600000000001s 2.3689465319616607A 0.612s 2.3689465319616607A 0.612000000001s 3.588271990409212A 0.624s 3.588271990409212A 0.624000000001s 4.222069053971901A 0.636s 4.222069053971901A 0.636000000001s 4.523598631798377A 0.648s 4.523598631798377A 0.648000000001s 3.133328602787247A 0.66s 3.133328602787247A 0.660000000001s 1.2488849619307003A 0.672s 1.2488849619307003A 0.672000000001s 3.3293126811559466A 0.684s 3.3293126811559466A 0.684000000001s 3.1769575512766597A 0.6960000000000001s 3.1769575512766597A 0.696000000001s 3.1844577099386244A 0.708s 3.1844577099386244A 0.7080000000009999s 3.2121064687146528A 0.72s 3.2121064687146528A 0.720000000001s 3.150546295786351A 0.732s 3.150546295786351A 0.732000000001s 3.2033473668347736A 0.744s 3.2033473668347736A 0.744000000001s 3.1530566096484325A 0.756s 3.1530566096484325A 0.756000000001s 3.1850065859318A 0.768s 3.1850065859318A 0.768000000001s 3.1962965565222445A 0.78s 3.1962965565222445A 0.780000000001s 3.164198862588293A 0.792s 3.164198862588293A 0.792000000001s 3.2168838837321845A 0.804s 3.2168838837321845A 0.804000000001s 2.3781647702354474A 0.8160000000000001s 2.3781647702354474A 0.816000000001s 3.559246731846608A 0.8280000000000001s 3.559246731846608A 0.828000000001s 3.5552508826869174A 0.84s 3.5552508826869174A 0.840000000001s 3.534590581796855A 0.852s 3.534590581796855A 0.852000000001s 3.5375204450455335A 0.864s 3.5375204450455335A 0.864000000001s 3.5407810501337407A 0.876s 3.5407810501337407A 0.876000000001s 3.5400168919032167A 0.888s 3.5400168919032167A 0.888000000001s 3.5601531002109006A 0.9s 3.5601531002109006A 0.900000000001s 3.5465114500128996A 0.912s 3.5465114500128996A 0.912000000001s 3.5346285438462237A 0.924s 3.5346285438462237A 0.924000000001s 2.6334181042019944A 0.936s 2.6334181042019944A 0.936000000001s 3.5467543674711877A 0.9480000000000001s 3.5467543674711877A 0.948000000001s 3.552119800593088A 0.96s 3.552119800593088A 0.9600000000009999s 3.548640471331095A 0.972s 3.548640471331095A 0.972000000001s 3.550070047048261A 0.984s 3.550070047048261A 0.984000000001s 3.5514513343288314A 0.996s 3.5514513343288314A 0.996000000001s 3.5472713790185235A 1.008s 3.5472713790185235A 1.008000000001s 3.565410056205247A 1.02s 3.565410056205247A 1.020000000001s 3.5615173732493233A 1.032s 3.5615173732493233A 1.0320000000010001s 3.534099238547694A 1.044s 3.534099238547694A 1.0440000000010001s 1.0477748418274362A 1.056s 1.0477748418274362A 1.0560000000010001s 0.9738100296604041A 1.068s 0.9738100296604041A 1.0680000000010001s 3.999477545211591A 1.08s 3.999477545211591A 1.0800000000010002s 4.010158746205741A 1.092s 4.010158746205741A 1.0920000000010002s 3.979995837957823A 1.104s 3.979995837957823A 1.1040000000010002s 3.9917129305800243A 1.116s 3.9917129305800243A 1.1160000000010002s 3.976664324500187A 1.1280000000000001s 3.976664324500187A 1.1280000000010002s 3.9901452753865527A 1.1400000000000001s 3.9901452753865527A 1.1400000000010002s 4.001220160391806A 1.1520000000000001s 4.001220160391806A 1.1520000000010002s 3.974727276766996A 1.164s 3.974727276766996A 1.164000000001s 4.002610888974078A 1.176s 4.002610888974078A 1.176000000001s 3.768267901988309A 1.188s 3.768267901988309A 1.188000000001s 3.543573522315516A 1.2s 3.543573522315516A 1.200000000001s 3.551426944469335A 1.212s 3.551426944469335A 1.212000000001s 3.5606721770651197A 1.224s 3.5606721770651197A 1.224000000001s 3.549406203293851A 1.236s 3.549406203293851A 1.236000000001s 3.5275814708303774A 1.248s 3.5275814708303774A 1.248000000001s 3.5284785945753243A 1.26s 3.5284785945753243A 1.260000000001s 3.5421211298998245A 1.272s 3.5421211298998245A 1.272000000001s 3.547947123275614A 1.284s 3.547947123275614A 1.2840000000010001s 3.557233563435753A 1.296s 3.557233563435753A 1.2960000000010001s 2.6209174789079412A 1.308s 2.6209174789079412A 1.3080000000010001s 3.1551466855676913A 1.32s 3.1551466855676913A 1.3200000000010002s 3.1764892214016025A 1.332s 3.1764892214016025A 1.3320000000010002s 3.208234340412999A 1.344s 3.208234340412999A 1.3440000000010002s 3.158938661013416A 1.356s 3.158938661013416A 1.3560000000010002s 3.209106779044661A 1.368s 3.209106779044661A 1.3680000000010002s 3.1465294002529096A 1.3800000000000001s 3.1465294002529096A 1.3800000000010002s 3.198223277727617A 1.3920000000000001s 3.198223277727617A 1.3920000000010002s 3.16848965530032A 1.4040000000000001s 3.16848965530032A 1.4040000000010002s 3.179881513539469A 1.416s 3.179881513539469A 1.416000000001s 3.201283352661259A 1.428s 3.201283352661259A 1.428000000001s 1.6488072172002533A 1.44s 1.6488072172002533A 1.440000000001s 0.9322874226023741A 1.452s 0.9322874226023741A 1.452000000001s 1.3783244130788086A 1.464s 1.3783244130788086A 1.464000000001s 4.01142516386027A 1.476s 4.01142516386027A 1.476000000001s 4.000765304281592A 1.488s 4.000765304281592A 1.488000000001s 3.9573673132875378A 1.5s 3.9573673132875378A 1.500000000001s 4.016296107032812A 1.512s 4.016296107032812A 1.512000000001s 3.972217553088159A 1.524s 3.972217553088159A 1.524000000001s 3.976020444933262A 1.536s 3.976020444933262A 1.5360000000010001s 3.9936373897885913A 1.548s 3.9936373897885913A 1.5480000000010001s 3.992659621343321A 1.56s 3.992659621343321A 1.5600000000010001s 3.997164024328678A 1.572s 3.997164024328678A 1.5720000000010002s 3.59813117194763A 1.584s 3.59813117194763A 1.5840000000010002s 3.547111269980489A 1.596s 3.547111269980489A 1.5960000000010002s 3.548432565389781A 1.608s 3.548432565389781A 1.6080000000010002s 3.5605805174379235A 1.62s 3.5605805174379235A 1.6200000000010002s 3.549103293736907A 1.6320000000000001s 3.549103293736907A 1.6320000000010002s 3.520263254438293A 1.6440000000000001s 3.520263254438293A 1.6440000000010002s 3.5337875764281685A 1.6560000000000001s 3.5337875764281685A 1.6560000000010002s 3.5446336073654545A 1.668s 3.5446336073654545A 1.668000000001s 3.550390364301641A 1.68s 3.550390364301641A 1.680000000001s 3.550921832905104A 1.692s 3.550921832905104A 1.692000000001s 2.5036173231029344A 1.704s 2.5036173231029344A 1.704000000001s 3.188199724822869A 1.716s 3.188199724822869A 1.716000000001s 3.182784921465261A 1.728s 3.182784921465261A 1.728000000001s 3.1754221537111484A 1.74s 3.1754221537111484A 1.740000000001s 3.2094715488854044A 1.752s 3.2094715488854044A 1.752000000001s 3.150128319872955A 1.764s 3.150128319872955A 1.764000000001s 3.1868289607003066A 1.776s 3.1868289607003066A 1.7760000000010001s 3.174782404771789A 1.788s 3.174782404771789A 1.7880000000010001s 3.1676441638404795A 1.8s 3.1676441638404795A 1.8000000000010001s 3.217376800129122A 1.812s 3.217376800129122A 1.8120000000010001s 3.1572598732068617A 1.824s 3.1572598732068617A 1.8240000000010002s 1.0258563854753908A 1.836s 1.0258563854753908A 1.8360000000010002s 0.9321070537247758A 1.848s 0.9321070537247758A 1.8480000000010002s 2.5563311572873935A 1.86s 2.5563311572873935A 1.8600000000010002s 4.012026360667605A 1.872s 4.012026360667605A 1.8720000000010002s 3.991900672734275A)
R_0_4_2_1 Node0_4_2 Node0_4_3 9.88780952380952
R_0_4_2_2 Node0_4_2 Node0_5_2 13.020765027322405
R_0_4_2_3 Node0_4_2 Node1_4_2 2.5950185402029646
C_0_4_2 Node0_4_2 GND 0.0009924144753600006
I_0_4_3 GND Node0_4_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629116A 0.024s 0.09547506513629116A 0.024000000001s 0.0954819734593042A 0.036000000000000004s 0.0954819734593042A 0.036000000001s 0.0954833865253751A 0.048s 0.0954833865253751A 0.048000000001s 0.09548479959144596A 0.06s 0.09548479959144596A 0.060000000000999996s 0.09548464258410477A 0.07200000000000001s 0.09548464258410477A 0.07200000000100001s 0.09547537915097354A 0.084s 0.09547537915097354A 0.08400000000100001s 0.095481031415257A 0.096s 0.095481031415257A 0.09600000000100001s 0.09548307251069267A 0.108s 0.09548307251069267A 0.108000000001s 0.09548448557676352A 0.12s 0.09548448557676352A 0.120000000001s 0.09548511360612835A 0.132s 0.09548511360612835A 0.132000000001s 0.09547569316565598A 0.14400000000000002s 0.09547569316565598A 0.14400000000100002s 0.09547993236386854A 0.156s 0.09547993236386854A 0.156000000001s 0.09548275849601026A 0.168s 0.09548275849601026A 0.16800000000100002s 0.09548401455473991A 0.18s 0.09548401455473991A 0.180000000001s 0.09548479959144596A 0.192s 0.09548479959144596A 0.192000000001s 0.09547930433450372A 0.20400000000000001s 0.09547930433450372A 0.20400000000100002s 0.09547632119502078A 0.216s 0.09547632119502078A 0.216000000001s 0.09548165944462182A 0.228s 0.09548165944462182A 0.228000000001s 0.09548354353271629A 0.24s 0.09548354353271629A 0.240000000001s 0.09548448557676352A 0.252s 0.09548448557676352A 0.252000000001s 0.09548385754739869A 0.264s 0.09548385754739869A 0.264000000001s 0.09547569316565598A 0.276s 0.09547569316565598A 0.276000000001s 0.09548040338589217A 0.28800000000000003s 0.09548040338589217A 0.288000000001s 0.09548307251069267A 0.3s 0.09548307251069267A 0.30000000000099997s 0.09548448557676352A 0.312s 0.09548448557676352A 0.312000000001s 0.09548511360612835A 0.324s 0.09548511360612835A 0.324000000001s 0.09547585017299717A 0.336s 0.09547585017299717A 0.336000000001s 0.09547930433450372A 0.34800000000000003s 0.09547930433450372A 0.348000000001s 0.09548260148866905A 0.36s 0.09548260148866905A 0.36000000000099996s 0.09548385754739869A 0.372s 0.09548385754739869A 0.372000000001s 0.09548495659878714A 0.384s 0.09548495659878714A 0.384000000001s 0.0954786763051389A 0.396s 0.0954786763051389A 0.396000000001s 0.09547569316565598A 0.40800000000000003s 0.09547569316565598A 0.408000000001s 0.09548181645196302A 0.42s 0.09548181645196302A 0.42000000000099996s 0.09548354353271629A 0.432s 0.09548354353271629A 0.432000000001s 0.09548448557676352A 0.444s 0.09548448557676352A 0.444000000001s 0.09548448557676352A 0.456s 0.09548448557676352A 0.456000000001s 0.09547553615831478A 0.468s 0.09547553615831478A 0.468000000001s 0.09548056039323335A 0.48s 0.09548056039323335A 0.48000000000099996s 0.09548307251069267A 0.492s 0.09548307251069267A 0.49200000000099997s 0.09548448557676352A 0.504s 0.09548448557676352A 0.504000000001s 0.09548511360612835A 0.516s 0.09548511360612835A 0.516000000001s 0.09547600718033836A 0.528s 0.09547600718033836A 0.528000000001s 0.0954789903198213A 0.54s 0.0954789903198213A 0.540000000001s 0.09548275849601026A 0.552s 0.09548275849601026A 0.552000000001s 0.0954837005400575A 0.5640000000000001s 0.0954837005400575A 0.564000000001s 0.09548464258410477A 0.5760000000000001s 0.09548464258410477A 0.576000000001s 0.09547946134184493A 0.588s 0.09547946134184493A 0.588000000001s 0.09547632119502078A 0.6s 0.09547632119502078A 0.600000000001s 0.09548150243728062A 0.612s 0.09548150243728062A 0.612000000001s 0.0954833865253751A 0.624s 0.0954833865253751A 0.624000000001s 0.09548448557676352A 0.636s 0.09548448557676352A 0.636000000001s 0.0954833865253751A 0.648s 0.0954833865253751A 0.648000000001s 0.09547585017299717A 0.66s 0.09547585017299717A 0.660000000001s 0.09548008937120975A 0.672s 0.09548008937120975A 0.672000000001s 0.09547176798212578A 0.684s 0.09547176798212578A 0.684000000001s 0.09547082593807857A 0.6960000000000001s 0.09547082593807857A 0.696000000001s 0.09547082593807857A 0.708s 0.09547082593807857A 0.7080000000009999s 0.09547082593807857A 0.72s 0.09547082593807857A 0.720000000001s 0.09547082593807857A 0.732s 0.09547082593807857A 0.732000000001s 0.09547082593807857A 0.744s 0.09547082593807857A 0.744000000001s 0.09547082593807857A 0.756s 0.09547082593807857A 0.756000000001s 0.09547082593807857A 0.768s 0.09547082593807857A 0.768000000001s 0.09547082593807857A 0.78s 0.09547082593807857A 0.780000000001s 0.09547082593807857A 0.792s 0.09547082593807857A 0.792000000001s 0.09547082593807857A 0.804s 0.09547082593807857A 0.804000000001s 0.09547082593807857A 0.8160000000000001s 0.09547082593807857A 0.816000000001s 0.09547082593807857A 0.8280000000000001s 0.09547082593807857A 0.828000000001s 0.09547082593807857A 0.84s 0.09547082593807857A 0.840000000001s 0.09547082593807857A 0.852s 0.09547082593807857A 0.852000000001s 0.09547082593807857A 0.864s 0.09547082593807857A 0.864000000001s 0.09547082593807857A 0.876s 0.09547082593807857A 0.876000000001s 0.09547082593807857A 0.888s 0.09547082593807857A 0.888000000001s 0.09547082593807857A 0.9s 0.09547082593807857A 0.900000000001s 0.09547082593807857A 0.912s 0.09547082593807857A 0.912000000001s 0.09547082593807857A 0.924s 0.09547082593807857A 0.924000000001s 0.09547082593807857A 0.936s 0.09547082593807857A 0.936000000001s 0.09547082593807857A 0.9480000000000001s 0.09547082593807857A 0.948000000001s 0.09547082593807857A 0.96s 0.09547082593807857A 0.9600000000009999s 0.09547082593807857A 0.972s 0.09547082593807857A 0.972000000001s 0.09547082593807857A 0.984s 0.09547082593807857A 0.984000000001s 0.09547082593807857A 0.996s 0.09547082593807857A 0.996000000001s 0.09547082593807857A 1.008s 0.09547082593807857A 1.008000000001s 0.09547082593807857A 1.02s 0.09547082593807857A 1.020000000001s 0.09547082593807857A 1.032s 0.09547082593807857A 1.0320000000010001s 0.09547082593807857A 1.044s 0.09547082593807857A 1.0440000000010001s 0.09547082593807857A 1.056s 0.09547082593807857A 1.0560000000010001s 0.09547082593807857A 1.068s 0.09547082593807857A 1.0680000000010001s 0.09547098294541978A 1.08s 0.09547098294541978A 1.0800000000010002s 0.09547098294541978A 1.092s 0.09547098294541978A 1.0920000000010002s 0.09547098294541978A 1.104s 0.09547098294541978A 1.1040000000010002s 0.09547098294541978A 1.116s 0.09547098294541978A 1.1160000000010002s 0.09547098294541978A 1.1280000000000001s 0.09547098294541978A 1.1280000000010002s 0.09547098294541978A 1.1400000000000001s 0.09547098294541978A 1.1400000000010002s 0.09547098294541978A 1.1520000000000001s 0.09547098294541978A 1.1520000000010002s 0.09547098294541978A 1.164s 0.09547098294541978A 1.164000000001s 0.09547098294541978A 1.176s 0.09547098294541978A 1.176000000001s 0.09547082593807857A 1.188s 0.09547082593807857A 1.188000000001s 0.09547082593807857A 1.2s 0.09547082593807857A 1.200000000001s 0.09547082593807857A 1.212s 0.09547082593807857A 1.212000000001s 0.09547082593807857A 1.224s 0.09547082593807857A 1.224000000001s 0.09547082593807857A 1.236s 0.09547082593807857A 1.236000000001s 0.09547082593807857A 1.248s 0.09547082593807857A 1.248000000001s 0.09547082593807857A 1.26s 0.09547082593807857A 1.260000000001s 0.09547082593807857A 1.272s 0.09547082593807857A 1.272000000001s 0.09547082593807857A 1.284s 0.09547082593807857A 1.2840000000010001s 0.09547082593807857A 1.296s 0.09547082593807857A 1.2960000000010001s 0.09547082593807857A 1.308s 0.09547082593807857A 1.3080000000010001s 0.09547082593807857A 1.32s 0.09547082593807857A 1.3200000000010002s 0.09547082593807857A 1.332s 0.09547082593807857A 1.3320000000010002s 0.09547082593807857A 1.344s 0.09547082593807857A 1.3440000000010002s 0.09547082593807857A 1.356s 0.09547082593807857A 1.3560000000010002s 0.09547082593807857A 1.368s 0.09547082593807857A 1.3680000000010002s 0.09547082593807857A 1.3800000000000001s 0.09547082593807857A 1.3800000000010002s 0.09547082593807857A 1.3920000000000001s 0.09547082593807857A 1.3920000000010002s 0.09547082593807857A 1.4040000000000001s 0.09547082593807857A 1.4040000000010002s 0.09547082593807857A 1.416s 0.09547082593807857A 1.416000000001s 0.09547082593807857A 1.428s 0.09547082593807857A 1.428000000001s 0.09547082593807857A 1.44s 0.09547082593807857A 1.440000000001s 0.09547082593807857A 1.452s 0.09547082593807857A 1.452000000001s 0.09547082593807857A 1.464s 0.09547082593807857A 1.464000000001s 0.09547098294541978A 1.476s 0.09547098294541978A 1.476000000001s 0.09547098294541978A 1.488s 0.09547098294541978A 1.488000000001s 0.09547098294541978A 1.5s 0.09547098294541978A 1.500000000001s 0.09547098294541978A 1.512s 0.09547098294541978A 1.512000000001s 0.09547098294541978A 1.524s 0.09547098294541978A 1.524000000001s 0.09547098294541978A 1.536s 0.09547098294541978A 1.5360000000010001s 0.09547098294541978A 1.548s 0.09547098294541978A 1.5480000000010001s 0.09547098294541978A 1.56s 0.09547098294541978A 1.5600000000010001s 0.09547098294541978A 1.572s 0.09547098294541978A 1.5720000000010002s 0.09547082593807857A 1.584s 0.09547082593807857A 1.5840000000010002s 0.09547082593807857A 1.596s 0.09547082593807857A 1.5960000000010002s 0.09547082593807857A 1.608s 0.09547082593807857A 1.6080000000010002s 0.09547082593807857A 1.62s 0.09547082593807857A 1.6200000000010002s 0.09547082593807857A 1.6320000000000001s 0.09547082593807857A 1.6320000000010002s 0.09547082593807857A 1.6440000000000001s 0.09547082593807857A 1.6440000000010002s 0.09547082593807857A 1.6560000000000001s 0.09547082593807857A 1.6560000000010002s 0.09547082593807857A 1.668s 0.09547082593807857A 1.668000000001s 0.09547082593807857A 1.68s 0.09547082593807857A 1.680000000001s 0.09547082593807857A 1.692s 0.09547082593807857A 1.692000000001s 0.09547082593807857A 1.704s 0.09547082593807857A 1.704000000001s 0.09547082593807857A 1.716s 0.09547082593807857A 1.716000000001s 0.09547082593807857A 1.728s 0.09547082593807857A 1.728000000001s 0.09547082593807857A 1.74s 0.09547082593807857A 1.740000000001s 0.09547082593807857A 1.752s 0.09547082593807857A 1.752000000001s 0.09547082593807857A 1.764s 0.09547082593807857A 1.764000000001s 0.09547082593807857A 1.776s 0.09547082593807857A 1.7760000000010001s 0.09547082593807857A 1.788s 0.09547082593807857A 1.7880000000010001s 0.09547082593807857A 1.8s 0.09547082593807857A 1.8000000000010001s 0.09547082593807857A 1.812s 0.09547082593807857A 1.8120000000010001s 0.09547082593807857A 1.824s 0.09547082593807857A 1.8240000000010002s 0.09547082593807857A 1.836s 0.09547082593807857A 1.8360000000010002s 0.09547082593807857A 1.848s 0.09547082593807857A 1.8480000000010002s 0.09547082593807857A 1.86s 0.09547082593807857A 1.8600000000010002s 0.09547098294541978A 1.872s 0.09547098294541978A 1.8720000000010002s 0.09547113995276098A)
R_0_4_3_1 Node0_4_3 Node0_4_4 9.88780952380952
R_0_4_3_2 Node0_4_3 Node0_5_3 13.020765027322405
R_0_4_3_3 Node0_4_3 Node1_4_3 2.595018540202965
C_0_4_3 Node0_4_3 GND 0.0009924144753600006
I_0_4_4 GND Node0_4_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629114A 0.024s 0.09547506513629114A 0.024000000001s 0.0954819734593042A 0.036000000000000004s 0.0954819734593042A 0.036000000001s 0.0954833865253751A 0.048s 0.0954833865253751A 0.048000000001s 0.09548479959144594A 0.06s 0.09548479959144594A 0.060000000000999996s 0.09548464258410476A 0.07200000000000001s 0.09548464258410476A 0.07200000000100001s 0.09547537915097354A 0.084s 0.09547537915097354A 0.08400000000100001s 0.09548103141525699A 0.096s 0.09548103141525699A 0.09600000000100001s 0.09548307251069266A 0.108s 0.09548307251069266A 0.108000000001s 0.0954844855767635A 0.12s 0.0954844855767635A 0.120000000001s 0.09548511360612835A 0.132s 0.09548511360612835A 0.132000000001s 0.09547569316565596A 0.14400000000000002s 0.09547569316565596A 0.14400000000100002s 0.09547993236386854A 0.156s 0.09547993236386854A 0.156000000001s 0.09548275849601025A 0.168s 0.09548275849601025A 0.16800000000100002s 0.0954840145547399A 0.18s 0.0954840145547399A 0.180000000001s 0.09548479959144594A 0.192s 0.09548479959144594A 0.192000000001s 0.09547930433450372A 0.20400000000000001s 0.09547930433450372A 0.20400000000100002s 0.09547632119502078A 0.216s 0.09547632119502078A 0.216000000001s 0.09548165944462181A 0.228s 0.09548165944462181A 0.228000000001s 0.09548354353271629A 0.24s 0.09548354353271629A 0.240000000001s 0.0954844855767635A 0.252s 0.0954844855767635A 0.252000000001s 0.09548385754739869A 0.264s 0.09548385754739869A 0.264000000001s 0.09547569316565596A 0.276s 0.09547569316565596A 0.276000000001s 0.09548040338589216A 0.28800000000000003s 0.09548040338589216A 0.288000000001s 0.09548307251069266A 0.3s 0.09548307251069266A 0.30000000000099997s 0.0954844855767635A 0.312s 0.0954844855767635A 0.312000000001s 0.09548511360612835A 0.324s 0.09548511360612835A 0.324000000001s 0.09547585017299717A 0.336s 0.09547585017299717A 0.336000000001s 0.09547930433450372A 0.34800000000000003s 0.09547930433450372A 0.348000000001s 0.09548260148866905A 0.36s 0.09548260148866905A 0.36000000000099996s 0.09548385754739869A 0.372s 0.09548385754739869A 0.372000000001s 0.09548495659878713A 0.384s 0.09548495659878713A 0.384000000001s 0.09547867630513888A 0.396s 0.09547867630513888A 0.396000000001s 0.09547569316565596A 0.40800000000000003s 0.09547569316565596A 0.408000000001s 0.095481816451963A 0.42s 0.095481816451963A 0.42000000000099996s 0.09548354353271629A 0.432s 0.09548354353271629A 0.432000000001s 0.0954844855767635A 0.444s 0.0954844855767635A 0.444000000001s 0.0954844855767635A 0.456s 0.0954844855767635A 0.456000000001s 0.09547553615831478A 0.468s 0.09547553615831478A 0.468000000001s 0.09548056039323335A 0.48s 0.09548056039323335A 0.48000000000099996s 0.09548307251069266A 0.492s 0.09548307251069266A 0.49200000000099997s 0.0954844855767635A 0.504s 0.0954844855767635A 0.504000000001s 0.09548511360612835A 0.516s 0.09548511360612835A 0.516000000001s 0.09547600718033836A 0.528s 0.09547600718033836A 0.528000000001s 0.09547899031982127A 0.54s 0.09547899031982127A 0.540000000001s 0.09548275849601025A 0.552s 0.09548275849601025A 0.552000000001s 0.09548370054005749A 0.5640000000000001s 0.09548370054005749A 0.564000000001s 0.09548464258410476A 0.5760000000000001s 0.09548464258410476A 0.576000000001s 0.09547946134184492A 0.588s 0.09547946134184492A 0.588000000001s 0.09547632119502078A 0.6s 0.09547632119502078A 0.600000000001s 0.09548150243728061A 0.612s 0.09548150243728061A 0.612000000001s 0.0954833865253751A 0.624s 0.0954833865253751A 0.624000000001s 0.0954844855767635A 0.636s 0.0954844855767635A 0.636000000001s 0.0954833865253751A 0.648s 0.0954833865253751A 0.648000000001s 0.09547585017299717A 0.66s 0.09547585017299717A 0.660000000001s 0.09548008937120975A 0.672s 0.09548008937120975A 0.672000000001s 0.09547176798212578A 0.684s 0.09547176798212578A 0.684000000001s 0.09547082593807857A 0.6960000000000001s 0.09547082593807857A 0.696000000001s 0.09547082593807857A 0.708s 0.09547082593807857A 0.7080000000009999s 0.09547082593807857A 0.72s 0.09547082593807857A 0.720000000001s 0.09547082593807857A 0.732s 0.09547082593807857A 0.732000000001s 0.09547082593807857A 0.744s 0.09547082593807857A 0.744000000001s 0.09547082593807857A 0.756s 0.09547082593807857A 0.756000000001s 0.09547082593807857A 0.768s 0.09547082593807857A 0.768000000001s 0.09547082593807857A 0.78s 0.09547082593807857A 0.780000000001s 0.09547082593807857A 0.792s 0.09547082593807857A 0.792000000001s 0.09547082593807857A 0.804s 0.09547082593807857A 0.804000000001s 0.09547082593807857A 0.8160000000000001s 0.09547082593807857A 0.816000000001s 0.09547082593807857A 0.8280000000000001s 0.09547082593807857A 0.828000000001s 0.09547082593807857A 0.84s 0.09547082593807857A 0.840000000001s 0.09547082593807857A 0.852s 0.09547082593807857A 0.852000000001s 0.09547082593807857A 0.864s 0.09547082593807857A 0.864000000001s 0.09547082593807857A 0.876s 0.09547082593807857A 0.876000000001s 0.09547082593807857A 0.888s 0.09547082593807857A 0.888000000001s 0.09547082593807857A 0.9s 0.09547082593807857A 0.900000000001s 0.09547082593807857A 0.912s 0.09547082593807857A 0.912000000001s 0.09547082593807857A 0.924s 0.09547082593807857A 0.924000000001s 0.09547082593807857A 0.936s 0.09547082593807857A 0.936000000001s 0.09547082593807857A 0.9480000000000001s 0.09547082593807857A 0.948000000001s 0.09547082593807857A 0.96s 0.09547082593807857A 0.9600000000009999s 0.09547082593807857A 0.972s 0.09547082593807857A 0.972000000001s 0.09547082593807857A 0.984s 0.09547082593807857A 0.984000000001s 0.09547082593807857A 0.996s 0.09547082593807857A 0.996000000001s 0.09547082593807857A 1.008s 0.09547082593807857A 1.008000000001s 0.09547082593807857A 1.02s 0.09547082593807857A 1.020000000001s 0.09547082593807857A 1.032s 0.09547082593807857A 1.0320000000010001s 0.09547082593807857A 1.044s 0.09547082593807857A 1.0440000000010001s 0.09547082593807857A 1.056s 0.09547082593807857A 1.0560000000010001s 0.09547082593807857A 1.068s 0.09547082593807857A 1.0680000000010001s 0.09547098294541978A 1.08s 0.09547098294541978A 1.0800000000010002s 0.09547098294541978A 1.092s 0.09547098294541978A 1.0920000000010002s 0.09547098294541978A 1.104s 0.09547098294541978A 1.1040000000010002s 0.09547098294541978A 1.116s 0.09547098294541978A 1.1160000000010002s 0.09547098294541978A 1.1280000000000001s 0.09547098294541978A 1.1280000000010002s 0.09547098294541978A 1.1400000000000001s 0.09547098294541978A 1.1400000000010002s 0.09547098294541978A 1.1520000000000001s 0.09547098294541978A 1.1520000000010002s 0.09547098294541978A 1.164s 0.09547098294541978A 1.164000000001s 0.09547098294541978A 1.176s 0.09547098294541978A 1.176000000001s 0.09547082593807857A 1.188s 0.09547082593807857A 1.188000000001s 0.09547082593807857A 1.2s 0.09547082593807857A 1.200000000001s 0.09547082593807857A 1.212s 0.09547082593807857A 1.212000000001s 0.09547082593807857A 1.224s 0.09547082593807857A 1.224000000001s 0.09547082593807857A 1.236s 0.09547082593807857A 1.236000000001s 0.09547082593807857A 1.248s 0.09547082593807857A 1.248000000001s 0.09547082593807857A 1.26s 0.09547082593807857A 1.260000000001s 0.09547082593807857A 1.272s 0.09547082593807857A 1.272000000001s 0.09547082593807857A 1.284s 0.09547082593807857A 1.2840000000010001s 0.09547082593807857A 1.296s 0.09547082593807857A 1.2960000000010001s 0.09547082593807857A 1.308s 0.09547082593807857A 1.3080000000010001s 0.09547082593807857A 1.32s 0.09547082593807857A 1.3200000000010002s 0.09547082593807857A 1.332s 0.09547082593807857A 1.3320000000010002s 0.09547082593807857A 1.344s 0.09547082593807857A 1.3440000000010002s 0.09547082593807857A 1.356s 0.09547082593807857A 1.3560000000010002s 0.09547082593807857A 1.368s 0.09547082593807857A 1.3680000000010002s 0.09547082593807857A 1.3800000000000001s 0.09547082593807857A 1.3800000000010002s 0.09547082593807857A 1.3920000000000001s 0.09547082593807857A 1.3920000000010002s 0.09547082593807857A 1.4040000000000001s 0.09547082593807857A 1.4040000000010002s 0.09547082593807857A 1.416s 0.09547082593807857A 1.416000000001s 0.09547082593807857A 1.428s 0.09547082593807857A 1.428000000001s 0.09547082593807857A 1.44s 0.09547082593807857A 1.440000000001s 0.09547082593807857A 1.452s 0.09547082593807857A 1.452000000001s 0.09547082593807857A 1.464s 0.09547082593807857A 1.464000000001s 0.09547098294541978A 1.476s 0.09547098294541978A 1.476000000001s 0.09547098294541978A 1.488s 0.09547098294541978A 1.488000000001s 0.09547098294541978A 1.5s 0.09547098294541978A 1.500000000001s 0.09547098294541978A 1.512s 0.09547098294541978A 1.512000000001s 0.09547098294541978A 1.524s 0.09547098294541978A 1.524000000001s 0.09547098294541978A 1.536s 0.09547098294541978A 1.5360000000010001s 0.09547098294541978A 1.548s 0.09547098294541978A 1.5480000000010001s 0.09547098294541978A 1.56s 0.09547098294541978A 1.5600000000010001s 0.09547098294541978A 1.572s 0.09547098294541978A 1.5720000000010002s 0.09547082593807857A 1.584s 0.09547082593807857A 1.5840000000010002s 0.09547082593807857A 1.596s 0.09547082593807857A 1.5960000000010002s 0.09547082593807857A 1.608s 0.09547082593807857A 1.6080000000010002s 0.09547082593807857A 1.62s 0.09547082593807857A 1.6200000000010002s 0.09547082593807857A 1.6320000000000001s 0.09547082593807857A 1.6320000000010002s 0.09547082593807857A 1.6440000000000001s 0.09547082593807857A 1.6440000000010002s 0.09547082593807857A 1.6560000000000001s 0.09547082593807857A 1.6560000000010002s 0.09547082593807857A 1.668s 0.09547082593807857A 1.668000000001s 0.09547082593807857A 1.68s 0.09547082593807857A 1.680000000001s 0.09547082593807857A 1.692s 0.09547082593807857A 1.692000000001s 0.09547082593807857A 1.704s 0.09547082593807857A 1.704000000001s 0.09547082593807857A 1.716s 0.09547082593807857A 1.716000000001s 0.09547082593807857A 1.728s 0.09547082593807857A 1.728000000001s 0.09547082593807857A 1.74s 0.09547082593807857A 1.740000000001s 0.09547082593807857A 1.752s 0.09547082593807857A 1.752000000001s 0.09547082593807857A 1.764s 0.09547082593807857A 1.764000000001s 0.09547082593807857A 1.776s 0.09547082593807857A 1.7760000000010001s 0.09547082593807857A 1.788s 0.09547082593807857A 1.7880000000010001s 0.09547082593807857A 1.8s 0.09547082593807857A 1.8000000000010001s 0.09547082593807857A 1.812s 0.09547082593807857A 1.8120000000010001s 0.09547082593807857A 1.824s 0.09547082593807857A 1.8240000000010002s 0.09547082593807857A 1.836s 0.09547082593807857A 1.8360000000010002s 0.09547082593807857A 1.848s 0.09547082593807857A 1.8480000000010002s 0.09547082593807857A 1.86s 0.09547082593807857A 1.8600000000010002s 0.09547098294541978A 1.872s 0.09547098294541978A 1.8720000000010002s 0.09547113995276096A)
R_0_4_4_1 Node0_4_4 Node0_4_5 9.887809523809514
R_0_4_4_2 Node0_4_4 Node0_5_4 13.020765027322406
R_0_4_4_3 Node0_4_4 Node1_4_4 2.5950185402029646
C_0_4_4 Node0_4_4 GND 0.0009924144753600006
I_0_4_5 GND Node0_4_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.12566446291622863A 0.024s 0.12566446291622863A 0.024000000001s 0.1256757474204537A 0.036000000000000004s 0.1256757474204537A 0.036000000001s 0.12567807195291675A 0.048s 0.12567807195291675A 0.048000000001s 0.1256803836147151A 0.06s 0.1256803836147151A 0.060000000000999996s 0.1256801475872341A 0.07200000000000001s 0.1256801475872341A 0.07200000000100001s 0.12566499173136036A 0.084s 0.12566499173136036A 0.08400000000100001s 0.12567420044868705A 0.096s 0.12567420044868705A 0.09600000000100001s 0.12567756532487223A 0.108s 0.12567756532487223A 0.108000000001s 0.1256798833322493A 0.12s 0.1256798833322493A 0.120000000001s 0.12568088741552155A 0.132s 0.12568088741552155A 0.132000000001s 0.12566551190322145A 0.14400000000000002s 0.12566551190322145A 0.14400000000100002s 0.125672406113561A 0.156s 0.125672406113561A 0.156000000001s 0.1256770412936068A 0.168s 0.1256770412936068A 0.16800000000100002s 0.12567909921056566A 0.18s 0.12567909921056566A 0.180000000001s 0.1256803836147151A 0.192s 0.1256803836147151A 0.192000000001s 0.12567139357550067A 0.20400000000000001s 0.12567139357550067A 0.20400000000100002s 0.12566651531334178A 0.216s 0.12566651531334178A 0.216000000001s 0.12567526096004067A 0.228s 0.12567526096004067A 0.228000000001s 0.12567832695430647A 0.24s 0.12567832695430647A 0.240000000001s 0.12567985508679483A 0.252s 0.12567985508679483A 0.252000000001s 0.12567886638728779A 0.264s 0.12567886638728779A 0.264000000001s 0.12566549725543572A 0.276s 0.12566549725543572A 0.276000000001s 0.12567318318061255A 0.28800000000000003s 0.12567318318061255A 0.288000000001s 0.12567756532487223A 0.3s 0.12567756532487223A 0.30000000000099997s 0.12567985508679483A 0.312s 0.12567985508679483A 0.312000000001s 0.12568088741552155A 0.324s 0.12568088741552155A 0.324000000001s 0.125665756421392A 0.336s 0.125665756421392A 0.336000000001s 0.12567139357550067A 0.34800000000000003s 0.12567139357550067A 0.348000000001s 0.12567679208132357A 0.36s 0.12567679208132357A 0.36000000000099996s 0.12567884053825415A 0.372s 0.12567884053825415A 0.372000000001s 0.1256806200281365A 0.384s 0.1256806200281365A 0.384000000001s 0.12567039392605575A 0.396s 0.12567039392605575A 0.396000000001s 0.1256654793136933A 0.40800000000000003s 0.1256654793136933A 0.408000000001s 0.12567550380879444A 0.42s 0.12567550380879444A 0.42000000000099996s 0.12567832695430647A 0.432s 0.12567832695430647A 0.432000000001s 0.12567985508679483A 0.444s 0.12567985508679483A 0.444000000001s 0.1256798833322493A 0.456s 0.1256798833322493A 0.456000000001s 0.12566524139241153A 0.468s 0.12566524139241153A 0.468000000001s 0.12567343180949747A 0.48s 0.12567343180949747A 0.48000000000099996s 0.12567756532487223A 0.492s 0.12567756532487223A 0.49200000000099997s 0.12567985508679483A 0.504s 0.12567985508679483A 0.504000000001s 0.12568088741552155A 0.516s 0.12568088741552155A 0.516000000001s 0.12566602757842774A 0.528s 0.12566602757842774A 0.528000000001s 0.12567090623550242A 0.54s 0.12567090623550242A 0.540000000001s 0.1256770412936068A 0.552s 0.1256770412936068A 0.552000000001s 0.12567860835222674A 0.5640000000000001s 0.12567860835222674A 0.564000000001s 0.12568011859682485A 0.5760000000000001s 0.12568011859682485A 0.576000000001s 0.12567165571230074A 0.588s 0.12567165571230074A 0.588000000001s 0.12566654318183115A 0.6s 0.12566654318183115A 0.600000000001s 0.12567498410365202A 0.612s 0.12567498410365202A 0.612000000001s 0.1256780482041171A 0.624s 0.1256780482041171A 0.624000000001s 0.1256798833322493A 0.636s 0.1256798833322493A 0.636000000001s 0.12567809597995253A 0.648s 0.12567809597995253A 0.648000000001s 0.12566576421200354A 0.66s 0.12566576421200354A 0.660000000001s 0.1256726633049383A 0.672s 0.1256726633049383A 0.672000000001s 0.12565906596673299A 0.684s 0.12565906596673299A 0.684000000001s 0.12565755684872196A 0.6960000000000001s 0.12565755684872196A 0.696000000001s 0.12565755662694084A 0.708s 0.12565755662694084A 0.7080000000009999s 0.12565755651923655A 0.72s 0.12565755651923655A 0.720000000001s 0.12565755651403082A 0.732s 0.12565755651403082A 0.732000000001s 0.12565755684333674A 0.744s 0.12565755684333674A 0.744000000001s 0.12565755655459945A 0.756s 0.12565755655459945A 0.756000000001s 0.1256575565231857A 0.768s 0.1256575565231857A 0.768000000001s 0.12565755664148093A 0.78s 0.12565755664148093A 0.780000000001s 0.1256575565769481A 0.792s 0.1256575565769481A 0.792000000001s 0.1256575567035904A 0.804s 0.1256575567035904A 0.804000000001s 0.12565755345944693A 0.8160000000000001s 0.12565755345944693A 0.816000000001s 0.12565756008990359A 0.8280000000000001s 0.12565756008990359A 0.828000000001s 0.1256575601656556A 0.84s 0.1256575601656556A 0.840000000001s 0.12565756008496712A 0.852s 0.12565756008496712A 0.852000000001s 0.12565756008335155A 0.864s 0.12565756008335155A 0.864000000001s 0.12565756008335155A 0.876s 0.12565756008335155A 0.876000000001s 0.1256575600636955A 0.888s 0.1256575600636955A 0.888000000001s 0.12565756010139204A 0.9s 0.12565756010139204A 0.900000000001s 0.1256575601244587A 0.912s 0.1256575601244587A 0.912000000001s 0.12565756009484003A 0.924s 0.12565756009484003A 0.924000000001s 0.1256575548391391A 0.936s 0.1256575548391391A 0.936000000001s 0.12565755971491308A 0.9480000000000001s 0.12565755971491308A 0.948000000001s 0.12565755964921344A 0.96s 0.12565755964921344A 0.9600000000009999s 0.12565755984864593A 0.972s 0.12565755984864593A 0.972000000001s 0.1256575597486604A 0.984s 0.1256575597486604A 0.984000000001s 0.12565755975027598A 0.996s 0.12565755975027598A 0.996000000001s 0.12565755971006637A 1.008s 0.12565755971006637A 1.008000000001s 0.1256575598892145A 1.02s 0.1256575598892145A 1.020000000001s 0.1256575598568135A 1.032s 0.1256575598568135A 1.0320000000010001s 0.1256575595901556A 1.044s 0.1256575595901556A 1.0440000000010001s 0.12565753592303167A 1.056s 0.12565753592303167A 1.0560000000010001s 0.12565753462330997A 1.068s 0.12565753462330997A 1.0680000000010001s 0.12565777117333637A 1.08s 0.12565777117333637A 1.0800000000010002s 0.1256577712156103A 1.092s 0.1256577712156103A 1.0920000000010002s 0.1256577711839273A 1.104s 0.1256577711839273A 1.1040000000010002s 0.12565777112074078A 1.116s 0.12565777112074078A 1.1160000000010002s 0.12565777119236413A 1.1280000000000001s 0.12565777119236413A 1.1280000000010002s 0.12565777133641864A 1.1400000000000001s 0.12565777133641864A 1.1400000000010002s 0.1256577712684752A 1.1520000000000001s 0.1256577712684752A 1.1520000000010002s 0.12565777107029924A 1.164s 0.12565777107029924A 1.164000000001s 0.12565777121767466A 1.176s 0.12565777121767466A 1.176000000001s 0.12565755910207554A 1.188s 0.12565755910207554A 1.188000000001s 0.1256575601656556A 1.2s 0.1256575601656556A 1.200000000001s 0.12565756013765247A 1.212s 0.12565756013765247A 1.212000000001s 0.12565756011790669A 1.224s 0.12565756011790669A 1.224000000001s 0.12565756012939516A 1.236s 0.12565756012939516A 1.236000000001s 0.1256575600424239A 1.248s 0.1256575600424239A 1.248000000001s 0.125657560088288A 1.26s 0.125657560088288A 1.260000000001s 0.12565756006692663A 1.272s 0.12565756006692663A 1.272000000001s 0.1256575600472706A 1.284s 0.1256575600472706A 1.2840000000010001s 0.12565756011952225A 1.296s 0.12565756011952225A 1.2960000000010001s 0.12565755483680552A 1.308s 0.12565755483680552A 1.3080000000010001s 0.12565755645138282A 1.32s 0.12565755645138282A 1.3200000000010002s 0.12565755652453198A 1.332s 0.12565755652453198A 1.3320000000010002s 0.12565755660064304A 1.344s 0.12565755660064304A 1.3440000000010002s 0.1256575566097979A 1.356s 0.1256575566097979A 1.3560000000010002s 0.1256575567194768A 1.368s 0.1256575567194768A 1.3680000000010002s 0.1256575565009268A 1.3800000000000001s 0.1256575565009268A 1.3800000000010002s 0.12565755666652217A 1.3920000000000001s 0.12565755666652217A 1.3920000000010002s 0.12565755667451026A 1.4040000000000001s 0.12565755667451026A 1.4040000000010002s 0.125657556624338A 1.416s 0.125657556624338A 1.416000000001s 0.12565755653368688A 1.428s 0.12565755653368688A 1.428000000001s 0.12565754489614675A 1.44s 0.12565754489614675A 1.440000000001s 0.12565753445600927A 1.452s 0.12565753445600927A 1.452000000001s 0.12565753845354438A 1.464s 0.12565753845354438A 1.464000000001s 0.1256577711797089A 1.476s 0.1256577711797089A 1.476000000001s 0.12565777122620125A 1.488s 0.12565777122620125A 1.488000000001s 0.12565777103260276A 1.5s 0.12565777103260276A 1.500000000001s 0.12565777123041966A 1.512s 0.12565777123041966A 1.512000000001s 0.1256577711775548A 1.524s 0.1256577711775548A 1.524000000001s 0.12565777111858667A 1.536s 0.12565777111858667A 1.5360000000010001s 0.12565777113124194A 1.548s 0.12565777113124194A 1.5480000000010001s 0.12565777116489954A 1.56s 0.12565777116489954A 1.5600000000010001s 0.12565777129602954A 1.572s 0.12565777129602954A 1.5720000000010002s 0.12565755776115695A 1.584s 0.12565755776115695A 1.5840000000010002s 0.12565756015901383A 1.596s 0.12565756015901383A 1.5960000000010002s 0.1256575600981609A 1.608s 0.1256575600981609A 1.6080000000010002s 0.12565756014752538A 1.62s 0.12565756014752538A 1.6200000000010002s 0.12565756013926804A 1.6320000000000001s 0.12565756013926804A 1.6320000000010002s 0.12565756002276787A 1.6440000000000001s 0.12565756002276787A 1.6440000000010002s 0.12565756010964935A 1.6560000000000001s 0.12565756010964935A 1.6560000000010002s 0.12565756005382261A 1.668s 0.12565756005382261A 1.668000000001s 0.125657560081736A 1.68s 0.125657560081736A 1.680000000001s 0.12565756008990359A 1.692s 0.12565756008990359A 1.692000000001s 0.12565755356724098A 1.704s 0.12565755356724098A 1.704000000001s 0.1256575565585486A 1.716s 0.1256575565585486A 1.716000000001s 0.12565755675663476A 1.728s 0.12565755675663476A 1.728000000001s 0.12565755665862385A 1.74s 0.12565755665862385A 1.740000000001s 0.1256575564970674A 1.752s 0.1256575564970674A 1.752000000001s 0.12565755643316284A 1.764s 0.12565755643316284A 1.764000000001s 0.1256575565585486A 1.776s 0.1256575565585486A 1.7760000000010001s 0.12565755664803294A 1.788s 0.12565755664803294A 1.7880000000010001s 0.12565755658879554A 1.8s 0.12565755658879554A 1.8000000000010001s 0.12565755659274472A 1.812s 0.12565755659274472A 1.8120000000010001s 0.12565755651663368A 1.824s 0.12565755651663368A 1.8240000000010002s 0.12565753739481106A 1.836s 0.12565753739481106A 1.8360000000010002s 0.1256575344543937A 1.848s 0.1256575344543937A 1.8480000000010002s 0.12565754967956427A 1.86s 0.12565754967956427A 1.8600000000010002s 0.1256577711817732A 1.872s 0.1256577711817732A 1.8720000000010002s 0.12565804805961298A)
R_0_4_5_1 Node0_4_5 Node0_4_6 9.887809523809514
R_0_4_5_2 Node0_4_5 Node0_5_5 13.020765027322389
R_0_4_5_3 Node0_4_5 Node1_4_5 2.595018540202962
C_0_4_5 Node0_4_5 GND 0.0009924144753600016
I_0_4_6 GND Node0_4_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861256A 0.024s 0.21364960617861256A 0.024000000001s 0.2136736447938566A 0.036000000000000004s 0.2136736447938566A 0.036000000001s 0.21367862573906676A 0.048s 0.21367862573906676A 0.048000000001s 0.21368355630285168A 0.06s 0.21368355630285168A 0.060000000000999996s 0.21368308997603275A 0.07200000000000001s 0.21368308997603275A 0.07200000000100001s 0.2136507610164441A 0.084s 0.2136507610164441A 0.08400000000100001s 0.21367033479745293A 0.096s 0.21367033479745293A 0.09600000000100001s 0.21367755775122366A 0.108s 0.21367755775122366A 0.108000000001s 0.21368251315438624A 0.12s 0.21368251315438624A 0.120000000001s 0.2136846132236453A 0.132s 0.2136846132236453A 0.132000000001s 0.21365188202072438A 0.14400000000000002s 0.21365188202072438A 0.14400000000100002s 0.2136665141006318A 0.156s 0.2136665141006318A 0.156000000001s 0.21367642163954248A 0.168s 0.21367642163954248A 0.16800000000100002s 0.2136808165229982A 0.18s 0.2136808165229982A 0.180000000001s 0.21368355630285168A 0.192s 0.21368355630285168A 0.192000000001s 0.21366438093562473A 0.20400000000000001s 0.21366438093562473A 0.20400000000100002s 0.21365397945497167A 0.216s 0.21365397945497167A 0.216000000001s 0.2136726557509665A 0.228s 0.2136726557509665A 0.228000000001s 0.21367916633808456A 0.24s 0.21367916633808456A 0.240000000001s 0.21368240258929178A 0.252s 0.21368240258929178A 0.252000000001s 0.21368036273883537A 0.264s 0.21368036273883537A 0.264000000001s 0.21365182468286792A 0.276s 0.21365182468286792A 0.276000000001s 0.2136681831170963A 0.28800000000000003s 0.2136681831170963A 0.288000000001s 0.21367755775122366A 0.3s 0.21367755775122366A 0.30000000000099997s 0.21368240258929178A 0.312s 0.21368240258929178A 0.312000000001s 0.2136846132236453A 0.324s 0.2136846132236453A 0.324000000001s 0.2136523815838253A 0.336s 0.2136523815838253A 0.336000000001s 0.21366438093562473A 0.34800000000000003s 0.21366438093562473A 0.348000000001s 0.21367590370162604A 0.36s 0.21367590370162604A 0.36000000000099996s 0.21368026155438286A 0.372s 0.21368026155438286A 0.372000000001s 0.21368402414041066A 0.384s 0.21368402414041066A 0.384000000001s 0.21366229822230998A 0.396s 0.21366229822230998A 0.396000000001s 0.21365175445102053A 0.40800000000000003s 0.21365175445102053A 0.408000000001s 0.21367314877923818A 0.42s 0.21367314877923818A 0.42000000000099996s 0.21367916633808456A 0.432s 0.21367916633808456A 0.432000000001s 0.21368240258929178A 0.444s 0.21368240258929178A 0.444000000001s 0.21368251315438624A 0.456s 0.21368251315438624A 0.456000000001s 0.21365128071103506A 0.468s 0.21365128071103506A 0.468000000001s 0.2136686987713359A 0.48s 0.2136686987713359A 0.48000000000099996s 0.21367755775122366A 0.492s 0.21367755775122366A 0.49200000000099997s 0.21368240258929178A 0.504s 0.21368240258929178A 0.504000000001s 0.2136846132236453A 0.516s 0.2136846132236453A 0.516000000001s 0.21365298542312594A 0.528s 0.21365298542312594A 0.528000000001s 0.21366338844965257A 0.54s 0.21366338844965257A 0.540000000001s 0.21367642163954248A 0.552s 0.21367642163954248A 0.552000000001s 0.21367981026469782A 0.5640000000000001s 0.21367981026469782A 0.564000000001s 0.2136829764948585A 0.5760000000000001s 0.2136829764948585A 0.576000000001s 0.21366494946576745A 0.588s 0.21366494946576745A 0.588000000001s 0.21365408854445955A 0.6s 0.21365408854445955A 0.600000000001s 0.21367202960189946A 0.612s 0.21367202960189946A 0.612000000001s 0.21367853277585103A 0.624s 0.21367853277585103A 0.624000000001s 0.21368251315438624A 0.636s 0.21368251315438624A 0.636000000001s 0.21367871979142078A 0.648s 0.21367871979142078A 0.648000000001s 0.21365241207969507A 0.66s 0.21365241207969507A 0.660000000001s 0.21366706327222126A 0.672s 0.21366706327222126A 0.672000000001s 0.21363808950475852A 0.684s 0.21363808950475852A 0.684000000001s 0.2136349276845535A 0.6960000000000001s 0.2136349276845535A 0.696000000001s 0.21363492681640495A 0.708s 0.21363492681640495A 0.7080000000009999s 0.2136349263948031A 0.72s 0.2136349263948031A 0.720000000001s 0.21363492637442566A 0.732s 0.21363492637442566A 0.732000000001s 0.21363492766347342A 0.744s 0.21363492766347342A 0.744000000001s 0.21363492653322902A 0.756s 0.21363492653322902A 0.756000000001s 0.21363492641026183A 0.768s 0.21363492641026183A 0.768000000001s 0.21363492687332122A 0.78s 0.21363492687332122A 0.780000000001s 0.21363492662071143A 0.792s 0.21363492662071143A 0.792000000001s 0.213634927116445A 0.804s 0.213634927116445A 0.804000000001s 0.2136349144174448A 0.8160000000000001s 0.2136349144174448A 0.816000000001s 0.2136349403719596A 0.8280000000000001s 0.2136349403719596A 0.828000000001s 0.21363494066848626A 0.84s 0.21363494066848626A 0.840000000001s 0.21363494035263617A 0.852s 0.21363494035263617A 0.852000000001s 0.21363494034631214A 0.864s 0.21363494034631214A 0.864000000001s 0.21363494034631214A 0.876s 0.21363494034631214A 0.876000000001s 0.21363494026936974A 0.888s 0.21363494026936974A 0.888000000001s 0.21363494041693046A 0.9s 0.21363494041693046A 0.900000000001s 0.21363494050722356A 0.912s 0.21363494050722356A 0.912000000001s 0.21363494039128306A 0.924s 0.21363494039128306A 0.924000000001s 0.21363491981816501A 0.936s 0.21363491981816501A 0.936000000001s 0.21363493890408236A 0.9480000000000001s 0.21363493890408236A 0.948000000001s 0.2136349386469052A 0.96s 0.2136349386469052A 0.9600000000009999s 0.21363493942757136A 0.972s 0.21363493942757136A 0.972000000001s 0.21363493903618427A 0.984s 0.21363493903618427A 0.984000000001s 0.21363493904250833A 0.996s 0.21363493904250833A 0.996000000001s 0.21363493888511031A 1.008s 0.21363493888511031A 1.008000000001s 0.2136349395863747A 1.02s 0.2136349395863747A 1.020000000001s 0.21363493945954282A 1.032s 0.21363493945954282A 1.0320000000010001s 0.21363493841572684A 1.044s 0.21363493841572684A 1.0440000000010001s 0.2136348457722258A 1.056s 0.2136348457722258A 1.0560000000010001s 0.21363484068454508A 1.068s 0.21363484068454508A 1.0680000000010001s 0.2136353090568358A 1.08s 0.2136353090568358A 1.0800000000010002s 0.21363530922231455A 1.092s 0.21363530922231455A 1.0920000000010002s 0.2136353090982933A 1.104s 0.2136353090982933A 1.1040000000010002s 0.21363530885095355A 1.116s 0.21363530885095355A 1.1160000000010002s 0.21363530913131878A 1.1280000000000001s 0.21363530913131878A 1.1280000000010002s 0.21363530969521136A 1.1400000000000001s 0.21363530969521136A 1.1400000000010002s 0.2136353094292508A 1.1520000000000001s 0.2136353094292508A 1.1520000000010002s 0.21363530865350336A 1.164s 0.21363530865350336A 1.164000000001s 0.2136353092303953A 1.176s 0.2136353092303953A 1.176000000001s 0.21363493650516766A 1.188s 0.21363493650516766A 1.188000000001s 0.21363494066848626A 1.2s 0.21363494066848626A 1.200000000001s 0.21363494055886975A 1.212s 0.21363494055886975A 1.212000000001s 0.2136349404815761A 1.224s 0.2136349404815761A 1.224000000001s 0.21363494052654694A 1.236s 0.21363494052654694A 1.236000000001s 0.21363494018610343A 1.248s 0.21363494018610343A 1.248000000001s 0.21363494036563555A 1.26s 0.21363494036563555A 1.260000000001s 0.21363494028201785A 1.272s 0.21363494028201785A 1.272000000001s 0.2136349402050755A 1.284s 0.2136349402050755A 1.2840000000010001s 0.2136349404879001A 1.296s 0.2136349404879001A 1.2960000000010001s 0.21363491980903032A 1.308s 0.21363491980903032A 1.3080000000010001s 0.2136349261291939A 1.32s 0.2136349261291939A 1.3200000000010002s 0.21363492641553183A 1.332s 0.21363492641553183A 1.3320000000010002s 0.21363492671346387A 1.344s 0.21363492671346387A 1.3440000000010002s 0.2136349267493A 1.356s 0.2136349267493A 1.3560000000010002s 0.21363492717863125A 1.368s 0.21363492717863125A 1.3680000000010002s 0.21363492632313075A 1.3800000000000001s 0.21363492632313075A 1.3800000000010002s 0.21363492697134367A 1.3920000000000001s 0.21363492697134367A 1.3920000000010002s 0.2136349270026125A 1.4040000000000001s 0.2136349270026125A 1.4040000000010002s 0.21363492680621626A 1.416s 0.21363492680621626A 1.416000000001s 0.21363492645136803A 1.428s 0.21363492645136803A 1.428000000001s 0.21363488089693292A 1.44s 0.21363488089693292A 1.440000000001s 0.21363484002965683A 1.452s 0.21363484002965683A 1.452000000001s 0.21363485567776214A 1.464s 0.21363485567776214A 1.464000000001s 0.2136353090817806A 1.476s 0.2136353090817806A 1.476000000001s 0.21363530926377206A 1.488s 0.21363530926377206A 1.488000000001s 0.21363530850594267A 1.5s 0.21363530850594267A 1.500000000001s 0.21363530928028485A 1.512s 0.21363530928028485A 1.512000000001s 0.21363530907334857A 1.524s 0.21363530907334857A 1.524000000001s 0.21363530884252155A 1.536s 0.21363530884252155A 1.5360000000010001s 0.21363530889205978A 1.548s 0.21363530889205978A 1.5480000000010001s 0.2136353090238104A 1.56s 0.2136353090238104A 1.5600000000010001s 0.21363530953711068A 1.572s 0.21363530953711068A 1.5720000000010002s 0.21363493125622418A 1.584s 0.21363493125622418A 1.5840000000010002s 0.21363494064248745A 1.596s 0.21363494064248745A 1.5960000000010002s 0.2136349404042824A 1.608s 0.2136349404042824A 1.6080000000010002s 0.2136349405975166A 1.62s 0.2136349405975166A 1.6200000000010002s 0.2136349405651938A 1.6320000000000001s 0.2136349405651938A 1.6320000000010002s 0.21363494010916112A 1.6440000000000001s 0.21363494010916112A 1.6440000000010002s 0.21363494044925324A 1.6560000000000001s 0.21363494044925324A 1.6560000000010002s 0.21363494023072294A 1.668s 0.21363494023072294A 1.668000000001s 0.21363494033998814A 1.68s 0.21363494033998814A 1.680000000001s 0.2136349403719596A 1.692s 0.2136349403719596A 1.692000000001s 0.21363491483939803A 1.704s 0.21363491483939803A 1.704000000001s 0.21363492654868776A 1.716s 0.21363492654868776A 1.716000000001s 0.2136349273240839A 1.728s 0.2136349273240839A 1.728000000001s 0.21363492694042618A 1.74s 0.21363492694042618A 1.740000000001s 0.21363492630802333A 1.752s 0.21363492630802333A 1.752000000001s 0.21363492605787293A 1.764s 0.21363492605787293A 1.764000000001s 0.21363492654868776A 1.776s 0.21363492654868776A 1.7760000000010001s 0.21363492689896868A 1.788s 0.21363492689896868A 1.7880000000010001s 0.2136349266670876A 1.8s 0.2136349266670876A 1.8000000000010001s 0.2136349266825463A 1.812s 0.2136349266825463A 1.8120000000010001s 0.21363492638461437A 1.824s 0.21363492638461437A 1.8240000000010002s 0.2136348515334156A 1.836s 0.2136348515334156A 1.8360000000010002s 0.21363484002333277A 1.848s 0.21363484002333277A 1.8480000000010002s 0.21363489962132667A 1.86s 0.21363489962132667A 1.8600000000010002s 0.21363530908986128A 1.872s 0.21363530908986128A 1.8720000000010002s 0.21363593532289743A)
R_0_4_6_1 Node0_4_6 Node0_4_7 9.88780952380952
R_0_4_6_2 Node0_4_6 Node0_5_6 13.020765027322405
R_0_4_6_3 Node0_4_6 Node1_4_6 2.595018540202965
C_0_4_6 Node0_4_6 GND 0.0009924144753600006
I_0_4_7 GND Node0_4_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.21364960617861256A 0.024s 0.21364960617861256A 0.024000000001s 0.2136736447938566A 0.036000000000000004s 0.2136736447938566A 0.036000000001s 0.21367862573906676A 0.048s 0.21367862573906676A 0.048000000001s 0.21368355630285168A 0.06s 0.21368355630285168A 0.060000000000999996s 0.21368308997603275A 0.07200000000000001s 0.21368308997603275A 0.07200000000100001s 0.2136507610164441A 0.084s 0.2136507610164441A 0.08400000000100001s 0.21367033479745293A 0.096s 0.21367033479745293A 0.09600000000100001s 0.21367755775122366A 0.108s 0.21367755775122366A 0.108000000001s 0.21368251315438624A 0.12s 0.21368251315438624A 0.120000000001s 0.2136846132236453A 0.132s 0.2136846132236453A 0.132000000001s 0.21365188202072438A 0.14400000000000002s 0.21365188202072438A 0.14400000000100002s 0.2136665141006318A 0.156s 0.2136665141006318A 0.156000000001s 0.21367642163954248A 0.168s 0.21367642163954248A 0.16800000000100002s 0.2136808165229982A 0.18s 0.2136808165229982A 0.180000000001s 0.21368355630285168A 0.192s 0.21368355630285168A 0.192000000001s 0.21366438093562473A 0.20400000000000001s 0.21366438093562473A 0.20400000000100002s 0.21365397945497167A 0.216s 0.21365397945497167A 0.216000000001s 0.2136726557509665A 0.228s 0.2136726557509665A 0.228000000001s 0.21367916633808456A 0.24s 0.21367916633808456A 0.240000000001s 0.21368240258929178A 0.252s 0.21368240258929178A 0.252000000001s 0.21368036273883537A 0.264s 0.21368036273883537A 0.264000000001s 0.21365182468286792A 0.276s 0.21365182468286792A 0.276000000001s 0.2136681831170963A 0.28800000000000003s 0.2136681831170963A 0.288000000001s 0.21367755775122366A 0.3s 0.21367755775122366A 0.30000000000099997s 0.21368240258929178A 0.312s 0.21368240258929178A 0.312000000001s 0.2136846132236453A 0.324s 0.2136846132236453A 0.324000000001s 0.2136523815838253A 0.336s 0.2136523815838253A 0.336000000001s 0.21366438093562473A 0.34800000000000003s 0.21366438093562473A 0.348000000001s 0.21367590370162604A 0.36s 0.21367590370162604A 0.36000000000099996s 0.21368026155438286A 0.372s 0.21368026155438286A 0.372000000001s 0.21368402414041066A 0.384s 0.21368402414041066A 0.384000000001s 0.21366229822230998A 0.396s 0.21366229822230998A 0.396000000001s 0.21365175445102053A 0.40800000000000003s 0.21365175445102053A 0.408000000001s 0.21367314877923818A 0.42s 0.21367314877923818A 0.42000000000099996s 0.21367916633808456A 0.432s 0.21367916633808456A 0.432000000001s 0.21368240258929178A 0.444s 0.21368240258929178A 0.444000000001s 0.21368251315438624A 0.456s 0.21368251315438624A 0.456000000001s 0.21365128071103506A 0.468s 0.21365128071103506A 0.468000000001s 0.2136686987713359A 0.48s 0.2136686987713359A 0.48000000000099996s 0.21367755775122366A 0.492s 0.21367755775122366A 0.49200000000099997s 0.21368240258929178A 0.504s 0.21368240258929178A 0.504000000001s 0.2136846132236453A 0.516s 0.2136846132236453A 0.516000000001s 0.21365298542312594A 0.528s 0.21365298542312594A 0.528000000001s 0.21366338844965257A 0.54s 0.21366338844965257A 0.540000000001s 0.21367642163954248A 0.552s 0.21367642163954248A 0.552000000001s 0.21367981026469782A 0.5640000000000001s 0.21367981026469782A 0.564000000001s 0.2136829764948585A 0.5760000000000001s 0.2136829764948585A 0.576000000001s 0.21366494946576745A 0.588s 0.21366494946576745A 0.588000000001s 0.21365408854445955A 0.6s 0.21365408854445955A 0.600000000001s 0.21367202960189946A 0.612s 0.21367202960189946A 0.612000000001s 0.21367853277585103A 0.624s 0.21367853277585103A 0.624000000001s 0.21368251315438624A 0.636s 0.21368251315438624A 0.636000000001s 0.21367871979142078A 0.648s 0.21367871979142078A 0.648000000001s 0.21365241207969507A 0.66s 0.21365241207969507A 0.660000000001s 0.21366706327222126A 0.672s 0.21366706327222126A 0.672000000001s 0.21363808950475852A 0.684s 0.21363808950475852A 0.684000000001s 0.2136349276845535A 0.6960000000000001s 0.2136349276845535A 0.696000000001s 0.21363492681640495A 0.708s 0.21363492681640495A 0.7080000000009999s 0.2136349263948031A 0.72s 0.2136349263948031A 0.720000000001s 0.21363492637442566A 0.732s 0.21363492637442566A 0.732000000001s 0.21363492766347342A 0.744s 0.21363492766347342A 0.744000000001s 0.21363492653322902A 0.756s 0.21363492653322902A 0.756000000001s 0.21363492641026183A 0.768s 0.21363492641026183A 0.768000000001s 0.21363492687332122A 0.78s 0.21363492687332122A 0.780000000001s 0.21363492662071143A 0.792s 0.21363492662071143A 0.792000000001s 0.213634927116445A 0.804s 0.213634927116445A 0.804000000001s 0.2136349144174448A 0.8160000000000001s 0.2136349144174448A 0.816000000001s 0.2136349403719596A 0.8280000000000001s 0.2136349403719596A 0.828000000001s 0.21363494066848626A 0.84s 0.21363494066848626A 0.840000000001s 0.21363494035263617A 0.852s 0.21363494035263617A 0.852000000001s 0.21363494034631214A 0.864s 0.21363494034631214A 0.864000000001s 0.21363494034631214A 0.876s 0.21363494034631214A 0.876000000001s 0.21363494026936974A 0.888s 0.21363494026936974A 0.888000000001s 0.21363494041693046A 0.9s 0.21363494041693046A 0.900000000001s 0.21363494050722356A 0.912s 0.21363494050722356A 0.912000000001s 0.21363494039128306A 0.924s 0.21363494039128306A 0.924000000001s 0.21363491981816501A 0.936s 0.21363491981816501A 0.936000000001s 0.21363493890408236A 0.9480000000000001s 0.21363493890408236A 0.948000000001s 0.2136349386469052A 0.96s 0.2136349386469052A 0.9600000000009999s 0.21363493942757136A 0.972s 0.21363493942757136A 0.972000000001s 0.21363493903618427A 0.984s 0.21363493903618427A 0.984000000001s 0.21363493904250833A 0.996s 0.21363493904250833A 0.996000000001s 0.21363493888511031A 1.008s 0.21363493888511031A 1.008000000001s 0.2136349395863747A 1.02s 0.2136349395863747A 1.020000000001s 0.21363493945954282A 1.032s 0.21363493945954282A 1.0320000000010001s 0.21363493841572684A 1.044s 0.21363493841572684A 1.0440000000010001s 0.2136348457722258A 1.056s 0.2136348457722258A 1.0560000000010001s 0.21363484068454508A 1.068s 0.21363484068454508A 1.0680000000010001s 0.2136353090568358A 1.08s 0.2136353090568358A 1.0800000000010002s 0.21363530922231455A 1.092s 0.21363530922231455A 1.0920000000010002s 0.2136353090982933A 1.104s 0.2136353090982933A 1.1040000000010002s 0.21363530885095355A 1.116s 0.21363530885095355A 1.1160000000010002s 0.21363530913131878A 1.1280000000000001s 0.21363530913131878A 1.1280000000010002s 0.21363530969521136A 1.1400000000000001s 0.21363530969521136A 1.1400000000010002s 0.2136353094292508A 1.1520000000000001s 0.2136353094292508A 1.1520000000010002s 0.21363530865350336A 1.164s 0.21363530865350336A 1.164000000001s 0.2136353092303953A 1.176s 0.2136353092303953A 1.176000000001s 0.21363493650516766A 1.188s 0.21363493650516766A 1.188000000001s 0.21363494066848626A 1.2s 0.21363494066848626A 1.200000000001s 0.21363494055886975A 1.212s 0.21363494055886975A 1.212000000001s 0.2136349404815761A 1.224s 0.2136349404815761A 1.224000000001s 0.21363494052654694A 1.236s 0.21363494052654694A 1.236000000001s 0.21363494018610343A 1.248s 0.21363494018610343A 1.248000000001s 0.21363494036563555A 1.26s 0.21363494036563555A 1.260000000001s 0.21363494028201785A 1.272s 0.21363494028201785A 1.272000000001s 0.2136349402050755A 1.284s 0.2136349402050755A 1.2840000000010001s 0.2136349404879001A 1.296s 0.2136349404879001A 1.2960000000010001s 0.21363491980903032A 1.308s 0.21363491980903032A 1.3080000000010001s 0.2136349261291939A 1.32s 0.2136349261291939A 1.3200000000010002s 0.21363492641553183A 1.332s 0.21363492641553183A 1.3320000000010002s 0.21363492671346387A 1.344s 0.21363492671346387A 1.3440000000010002s 0.2136349267493A 1.356s 0.2136349267493A 1.3560000000010002s 0.21363492717863125A 1.368s 0.21363492717863125A 1.3680000000010002s 0.21363492632313075A 1.3800000000000001s 0.21363492632313075A 1.3800000000010002s 0.21363492697134367A 1.3920000000000001s 0.21363492697134367A 1.3920000000010002s 0.2136349270026125A 1.4040000000000001s 0.2136349270026125A 1.4040000000010002s 0.21363492680621626A 1.416s 0.21363492680621626A 1.416000000001s 0.21363492645136803A 1.428s 0.21363492645136803A 1.428000000001s 0.21363488089693292A 1.44s 0.21363488089693292A 1.440000000001s 0.21363484002965683A 1.452s 0.21363484002965683A 1.452000000001s 0.21363485567776214A 1.464s 0.21363485567776214A 1.464000000001s 0.2136353090817806A 1.476s 0.2136353090817806A 1.476000000001s 0.21363530926377206A 1.488s 0.21363530926377206A 1.488000000001s 0.21363530850594267A 1.5s 0.21363530850594267A 1.500000000001s 0.21363530928028485A 1.512s 0.21363530928028485A 1.512000000001s 0.21363530907334857A 1.524s 0.21363530907334857A 1.524000000001s 0.21363530884252155A 1.536s 0.21363530884252155A 1.5360000000010001s 0.21363530889205978A 1.548s 0.21363530889205978A 1.5480000000010001s 0.2136353090238104A 1.56s 0.2136353090238104A 1.5600000000010001s 0.21363530953711068A 1.572s 0.21363530953711068A 1.5720000000010002s 0.21363493125622418A 1.584s 0.21363493125622418A 1.5840000000010002s 0.21363494064248745A 1.596s 0.21363494064248745A 1.5960000000010002s 0.2136349404042824A 1.608s 0.2136349404042824A 1.6080000000010002s 0.2136349405975166A 1.62s 0.2136349405975166A 1.6200000000010002s 0.2136349405651938A 1.6320000000000001s 0.2136349405651938A 1.6320000000010002s 0.21363494010916112A 1.6440000000000001s 0.21363494010916112A 1.6440000000010002s 0.21363494044925324A 1.6560000000000001s 0.21363494044925324A 1.6560000000010002s 0.21363494023072294A 1.668s 0.21363494023072294A 1.668000000001s 0.21363494033998814A 1.68s 0.21363494033998814A 1.680000000001s 0.2136349403719596A 1.692s 0.2136349403719596A 1.692000000001s 0.21363491483939803A 1.704s 0.21363491483939803A 1.704000000001s 0.21363492654868776A 1.716s 0.21363492654868776A 1.716000000001s 0.2136349273240839A 1.728s 0.2136349273240839A 1.728000000001s 0.21363492694042618A 1.74s 0.21363492694042618A 1.740000000001s 0.21363492630802333A 1.752s 0.21363492630802333A 1.752000000001s 0.21363492605787293A 1.764s 0.21363492605787293A 1.764000000001s 0.21363492654868776A 1.776s 0.21363492654868776A 1.7760000000010001s 0.21363492689896868A 1.788s 0.21363492689896868A 1.7880000000010001s 0.2136349266670876A 1.8s 0.2136349266670876A 1.8000000000010001s 0.2136349266825463A 1.812s 0.2136349266825463A 1.8120000000010001s 0.21363492638461437A 1.824s 0.21363492638461437A 1.8240000000010002s 0.2136348515334156A 1.836s 0.2136348515334156A 1.8360000000010002s 0.21363484002333277A 1.848s 0.21363484002333277A 1.8480000000010002s 0.21363489962132667A 1.86s 0.21363489962132667A 1.8600000000010002s 0.21363530908986128A 1.872s 0.21363530908986128A 1.8720000000010002s 0.21363593532289743A)
R_0_4_7_1 Node0_4_7 Node0_4_8 9.887809523809524
R_0_4_7_2 Node0_4_7 Node0_5_7 13.020765027322405
R_0_4_7_3 Node0_4_7 Node1_4_7 2.595018540202965
C_0_4_7 Node0_4_7 GND 0.0009924144753600006
I_0_4_8 GND Node0_4_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.04202943072366125A 0.024s 0.04202943072366125A 0.024000000001s 0.042034159631578104A 0.036000000000000004s 0.042034159631578104A 0.036000000001s 0.042035139489652235A 0.048s 0.042035139489652235A 0.048000000001s 0.04203610943662632A 0.06s 0.04203610943662632A 0.060000000000999996s 0.04203601770020292A 0.07200000000000001s 0.04203601770020292A 0.07200000000100001s 0.04202965790487401A 0.084s 0.04202965790487401A 0.08400000000100001s 0.042033508484744596A 0.096s 0.042033508484744596A 0.09600000000100001s 0.0420349293936831A 0.108s 0.0420349293936831A 0.108000000001s 0.042035904227092136A 0.12s 0.042035904227092136A 0.120000000001s 0.04203631735547097A 0.132s 0.04203631735547097A 0.132000000001s 0.04202987843030619A 0.14400000000000002s 0.04202987843030619A 0.14400000000100002s 0.04203275687225519A 0.156s 0.04203275687225519A 0.156000000001s 0.0420347058963032A 0.168s 0.0420347058963032A 0.16800000000100002s 0.04203557046354039A 0.18s 0.04203557046354039A 0.180000000001s 0.04203610943662632A 0.192s 0.04203610943662632A 0.192000000001s 0.04203233723323741A 0.20400000000000001s 0.04203233723323741A 0.20400000000100002s 0.04203029104032205A 0.216s 0.04203029104032205A 0.216000000001s 0.042033965065763665A 0.228s 0.042033965065763665A 0.228000000001s 0.042035245837A 0.24s 0.042035245837A 0.240000000001s 0.04203588247658174A 0.252s 0.04203588247658174A 0.252000000001s 0.04203548119452475A 0.264s 0.04203548119452475A 0.264000000001s 0.04202986715072787A 0.276s 0.04202986715072787A 0.276000000001s 0.04203308520336296A 0.28800000000000003s 0.04203308520336296A 0.288000000001s 0.0420349293936831A 0.3s 0.0420349293936831A 0.30000000000099997s 0.04203588247658174A 0.312s 0.04203588247658174A 0.312000000001s 0.04203631735547097A 0.324s 0.04203631735547097A 0.324000000001s 0.04202997670501457A 0.336s 0.04202997670501457A 0.336000000001s 0.04203233723323741A 0.34800000000000003s 0.04203233723323741A 0.348000000001s 0.04203460400687701A 0.36s 0.04203460400687701A 0.36000000000099996s 0.04203546128938655A 0.372s 0.04203546128938655A 0.372000000001s 0.042036201470244484A 0.384s 0.042036201470244484A 0.384000000001s 0.042031927519142705A 0.396s 0.042031927519142705A 0.396000000001s 0.04202985333462675A 0.40800000000000003s 0.04202985333462675A 0.408000000001s 0.04203406205493186A 0.42s 0.04203406205493186A 0.42000000000099996s 0.042035245837A 0.432s 0.042035245837A 0.432000000001s 0.04203588247658174A 0.444s 0.04203588247658174A 0.444000000001s 0.042035904227092136A 0.456s 0.042035904227092136A 0.456000000001s 0.04202976013987551A 0.468s 0.04202976013987551A 0.468000000001s 0.04203318664354125A 0.48s 0.04203318664354125A 0.48000000000099996s 0.0420349293936831A 0.492s 0.0420349293936831A 0.49200000000099997s 0.04203588247658174A 0.504s 0.04203588247658174A 0.504000000001s 0.04203631735547097A 0.516s 0.04203631735547097A 0.516000000001s 0.04203009549307371A 0.528s 0.04203009549307371A 0.528000000001s 0.04203214199009535A 0.54s 0.04203214199009535A 0.540000000001s 0.0420347058963032A 0.552s 0.0420347058963032A 0.552000000001s 0.042035372511087854A 0.5640000000000001s 0.042035372511087854A 0.564000000001s 0.0420359953760375A 0.5760000000000001s 0.0420359953760375A 0.576000000001s 0.042032449075232695A 0.588s 0.042032449075232695A 0.588000000001s 0.04203031250054918A 0.6s 0.04203031250054918A 0.600000000001s 0.042033841888898006A 0.612s 0.042033841888898006A 0.612000000001s 0.04203512120180652A 0.624s 0.04203512120180652A 0.624000000001s 0.042035904227092136A 0.636s 0.042035904227092136A 0.636000000001s 0.04203515799175467A 0.648s 0.04203515799175467A 0.648000000001s 0.042029982704202065A 0.66s 0.042029982704202065A 0.660000000001s 0.0420328649060105A 0.672s 0.0420328649060105A 0.672000000001s 0.04202716514847685A 0.684s 0.04202716514847685A 0.684000000001s 0.04202654315105946A 0.6960000000000001s 0.04202654315105946A 0.696000000001s 0.042026542980276145A 0.708s 0.042026542980276145A 0.7080000000009999s 0.04202654289733808A 0.72s 0.04202654289733808A 0.720000000001s 0.0420265428933294A 0.732s 0.0420265428933294A 0.732000000001s 0.04202654314691256A 0.744s 0.04202654314691256A 0.744000000001s 0.04202654292456941A 0.756s 0.04202654292456941A 0.756000000001s 0.04202654290037913A 0.768s 0.04202654290037913A 0.768000000001s 0.042026542991472786A 0.78s 0.042026542991472786A 0.780000000001s 0.04202654294177906A 0.792s 0.04202654294177906A 0.792000000001s 0.04202654303930041A 0.804s 0.04202654303930041A 0.804000000001s 0.04202654054113644A 0.8160000000000001s 0.04202654054113644A 0.816000000001s 0.04202654564694263A 0.8280000000000001s 0.04202654564694263A 0.828000000001s 0.042026545705275746A 0.84s 0.042026545705275746A 0.840000000001s 0.0420265456431413A 0.852s 0.0420265456431413A 0.852000000001s 0.04202654564189723A 0.864s 0.04202654564189723A 0.864000000001s 0.04202654564189723A 0.876s 0.04202654564189723A 0.876000000001s 0.04202654562676103A 0.888s 0.04202654562676103A 0.888000000001s 0.04202654565578935A 0.9s 0.04202654565578935A 0.900000000001s 0.042026545673551935A 0.912s 0.042026545673551935A 0.912000000001s 0.04202654565074396A 0.924s 0.04202654565074396A 0.924000000001s 0.042026541603573206A 0.936s 0.042026541603573206A 0.936000000001s 0.042026545358179894A 0.9480000000000001s 0.042026545358179894A 0.948000000001s 0.04202654530758766A 0.96s 0.04202654530758766A 0.9600000000009999s 0.04202654546116134A 0.972s 0.04202654546116134A 0.972000000001s 0.042026545384167155A 0.984s 0.042026545384167155A 0.984000000001s 0.04202654538541123A 0.996s 0.04202654538541123A 0.996000000001s 0.04202654535444769A 1.008s 0.04202654535444769A 1.008000000001s 0.04202654549240134A 1.02s 0.04202654549240134A 1.020000000001s 0.04202654546745081A 1.032s 0.04202654546745081A 1.0320000000010001s 0.04202654526210996A 1.044s 0.04202654526210996A 1.0440000000010001s 0.04202652703715893A 1.056s 0.04202652703715893A 1.0560000000010001s 0.04202652603630371A 1.068s 0.04202652603630371A 1.0680000000010001s 0.042026618175114994A 1.08s 0.042026618175114994A 1.0800000000010002s 0.04202661820766819A 1.092s 0.04202661820766819A 1.0920000000010002s 0.042026618183270574A 1.104s 0.042026618183270574A 1.1040000000010002s 0.04202661813461357A 1.116s 0.04202661813461357A 1.1160000000010002s 0.04202661818976739A 1.1280000000000001s 0.04202661818976739A 1.1280000000010002s 0.04202661830069707A 1.1400000000000001s 0.04202661830069707A 1.1400000000010002s 0.04202661824837697A 1.1520000000000001s 0.04202661824837697A 1.1520000000010002s 0.04202661809577091A 1.164s 0.04202661809577091A 1.164000000001s 0.04202661820925785A 1.176s 0.04202661820925785A 1.176000000001s 0.04202654488626224A 1.188s 0.04202654488626224A 1.188000000001s 0.042026545705275746A 1.2s 0.042026545705275746A 1.200000000001s 0.042026545683711836A 1.212s 0.042026545683711836A 1.212000000001s 0.04202654566850653A 1.224s 0.04202654566850653A 1.224000000001s 0.042026545677353255A 1.236s 0.042026545677353255A 1.236000000001s 0.04202654561038076A 1.248s 0.04202654561038076A 1.248000000001s 0.04202654564569855A 1.26s 0.04202654564569855A 1.260000000001s 0.042026545629249165A 1.272s 0.042026545629249165A 1.272000000001s 0.042026545614112974A 1.284s 0.042026545614112974A 1.2840000000010001s 0.0420265456697506A 1.296s 0.0420265456697506A 1.2960000000010001s 0.042026541601776206A 1.308s 0.042026541601776206A 1.3080000000010001s 0.042026542845087084A 1.32s 0.042026542845087084A 1.3200000000010002s 0.04202654290141586A 1.332s 0.04202654290141586A 1.3320000000010002s 0.042026542960025434A 1.344s 0.042026542960025434A 1.3440000000010002s 0.04202654296707517A 1.356s 0.04202654296707517A 1.3560000000010002s 0.04202654305153378A 1.368s 0.04202654305153378A 1.3680000000010002s 0.04202654288323859A 1.3800000000000001s 0.04202654288323859A 1.3800000000010002s 0.04202654301075589A 1.3920000000000001s 0.04202654301075589A 1.3920000000010002s 0.04202654301690713A 1.4040000000000001s 0.04202654301690713A 1.4040000000010002s 0.04202654297827181A 1.416s 0.04202654297827181A 1.416000000001s 0.0420265429084656A 1.428s 0.0420265429084656A 1.428000000001s 0.04202653394693738A 1.44s 0.04202653394693738A 1.440000000001s 0.04202652590747323A 1.452s 0.04202652590747323A 1.452000000001s 0.04202652898578903A 1.464s 0.04202652898578903A 1.464000000001s 0.04202661818002217A 1.476s 0.04202661818002217A 1.476000000001s 0.04202661821582378A 1.488s 0.04202661821582378A 1.488000000001s 0.04202661806674258A 1.5s 0.04202661806674258A 1.500000000001s 0.042026618219072186A 1.512s 0.042026618219072186A 1.512000000001s 0.04202661817836341A 1.524s 0.04202661817836341A 1.524000000001s 0.042026618132954816A 1.536s 0.042026618132954816A 1.5360000000010001s 0.04202661814270005A 1.548s 0.04202661814270005A 1.5480000000010001s 0.0420266181686182A 1.56s 0.0420266181686182A 1.5600000000010001s 0.042026618269595306A 1.572s 0.042026618269595306A 1.5720000000010002s 0.0420265438536832A 1.584s 0.0420265438536832A 1.5840000000010002s 0.042026545700161226A 1.596s 0.042026545700161226A 1.5960000000010002s 0.04202654565330122A 1.608s 0.04202654565330122A 1.6080000000010002s 0.0420265456913145A 1.62s 0.0420265456913145A 1.6200000000010002s 0.04202654568495592A 1.6320000000000001s 0.04202654568495592A 1.6320000000010002s 0.04202654559524456A 1.6440000000000001s 0.04202654559524456A 1.6440000000010002s 0.04202654566214793A 1.6560000000000001s 0.04202654566214793A 1.6560000000010002s 0.04202654561915836A 1.668s 0.04202654561915836A 1.668000000001s 0.042026545640653154A 1.68s 0.042026545640653154A 1.680000000001s 0.04202654564694263A 1.692s 0.04202654564694263A 1.692000000001s 0.04202654062414363A 1.704s 0.04202654062414363A 1.704000000001s 0.04202654292761046A 1.716s 0.04202654292761046A 1.716000000001s 0.04202654308014741A 1.728s 0.04202654308014741A 1.728000000001s 0.04202654300467376A 1.74s 0.04202654300467376A 1.740000000001s 0.042026542880266644A 1.752s 0.042026542880266644A 1.752000000001s 0.042026542831056724A 1.764s 0.042026542831056724A 1.764000000001s 0.04202654292761046A 1.776s 0.04202654292761046A 1.7760000000010001s 0.04202654299651819A 1.788s 0.04202654299651819A 1.7880000000010001s 0.04202654295090224A 1.8s 0.04202654295090224A 1.8000000000010001s 0.0420265429539433A 1.812s 0.0420265429539433A 1.8120000000010001s 0.04202654289533374A 1.824s 0.04202654289533374A 1.8240000000010002s 0.04202652817050774A 1.836s 0.04202652817050774A 1.8360000000010002s 0.042026525906229156A 1.848s 0.042026525906229156A 1.8480000000010002s 0.042026537630424673A 1.86s 0.042026537630424673A 1.8600000000010002s 0.04202661818161182A 1.872s 0.04202661818161182A 1.8720000000010002s 0.04202674137499597A)
R_0_4_8_1 Node0_4_8 Node0_4_9 9.887809523809524
R_0_4_8_2 Node0_4_8 Node0_5_8 13.020765027322419
R_0_4_8_3 Node0_4_8 Node1_4_8 2.595018540202968
C_0_4_8 Node0_4_8 GND 0.0009924144753599995
R_0_4_9_2 Node0_4_9 Node0_5_9 13.020765027322405
R_0_4_9_3 Node0_4_9 Node1_4_9 2.5950185402029646
C_0_4_9 Node0_4_9 GND 0.0009924144753600006
I_0_5_0 GND Node0_5_0 PWL(0s 0A 0.012s 0A 0.012000000001s 4.253369606205272A 0.024s 4.253369606205272A 0.024000000001s 12.656371961911294A 0.036000000000000004s 12.656371961911294A 0.036000000001s 14.317231747469469A 0.048s 14.317231747469469A 0.048000000001s 15.810387671874867A 0.06s 15.810387671874867A 0.060000000000999996s 16.51464358260125A 0.07200000000000001s 16.51464358260125A 0.07200000000100001s 6.458576596700237A 0.084s 6.458576596700237A 0.08400000000100001s 10.833487160848513A 0.096s 10.833487160848513A 0.09600000000100001s 13.923066380458542A 0.108s 13.923066380458542A 0.108000000001s 15.453325876528822A 0.12s 15.453325876528822A 0.120000000001s 16.597357685811016A 0.132s 16.597357685811016A 0.132000000001s 7.876147266612387A 0.14400000000000002s 7.876147266612387A 0.14400000000100002s 8.505394170644955A 0.156s 8.505394170644955A 0.156000000001s 13.22511043157489A 0.168s 13.22511043157489A 0.16800000000100002s 15.050219841337054A 0.18s 15.050219841337054A 0.180000000001s 15.824987847645172A 0.192s 15.824987847645172A 0.192000000001s 12.798682756134564A 0.20400000000000001s 12.798682756134564A 0.20400000000100002s 5.829512123316906A 0.216s 5.829512123316906A 0.216000000001s 12.090739541667027A 0.228s 12.090739541667027A 0.228000000001s 14.143305027846583A 0.24s 14.143305027846583A 0.240000000001s 15.70755822539533A 0.252s 15.70755822539533A 0.252000000001s 15.207542239142924A 0.264s 15.207542239142924A 0.264000000001s 7.5808146480394285A 0.276s 7.5808146480394285A 0.276000000001s 9.362618488176562A 0.28800000000000003s 9.362618488176562A 0.288000000001s 13.31642352977073A 0.3s 13.31642352977073A 0.30000000000099997s 15.590512758585817A 0.312s 15.590512758585817A 0.312000000001s 16.00412764530534A 0.324s 16.00412764530534A 0.324000000001s 8.745050615127493A 0.336s 8.745050615127493A 0.336000000001s 7.112180595212342A 0.34800000000000003s 7.112180595212342A 0.348000000001s 13.321184908232272A 0.36s 13.321184908232272A 0.36000000000099996s 14.757541982498397A 0.372s 14.757541982498397A 0.372000000001s 15.686983292153421A 0.384s 15.686983292153421A 0.384000000001s 12.300268256850229A 0.396s 12.300268256850229A 0.396000000001s 5.484516661769875A 0.40800000000000003s 5.484516661769875A 0.408000000001s 12.231189636957364A 0.42s 12.231189636957364A 0.42000000000099996s 14.390783373061927A 0.432s 14.390783373061927A 0.432000000001s 15.359246162348406A 0.444s 15.359246162348406A 0.444000000001s 16.740585127439473A 0.456s 16.740585127439473A 0.456000000001s 7.138272982558391A 0.468s 7.138272982558391A 0.468000000001s 9.546122729050783A 0.48s 9.546122729050783A 0.48000000000099996s 13.603539112954792A 0.492s 13.603539112954792A 0.49200000000099997s 15.269145550186419A 0.504s 15.269145550186419A 0.504000000001s 16.403708386063855A 0.516s 16.403708386063855A 0.516000000001s 8.852848947246628A 0.528s 8.852848947246628A 0.528000000001s 7.182559859850013A 0.54s 7.182559859850013A 0.540000000001s 13.411779658298697A 0.552s 13.411779658298697A 0.552000000001s 14.238336625395332A 0.5640000000000001s 14.238336625395332A 0.564000000001s 15.875114159914297A 0.5760000000000001s 15.875114159914297A 0.576000000001s 13.125689987675171A 0.588s 13.125689987675171A 0.588000000001s 6.542265215101779A 0.6s 6.542265215101779A 0.600000000001s 10.573141921337047A 0.612s 10.573141921337047A 0.612000000001s 13.777310908523681A 0.624s 13.777310908523681A 0.624000000001s 15.63462881391901A 0.636s 15.63462881391901A 0.636000000001s 15.800049539832873A 0.648s 15.800049539832873A 0.648000000001s 8.081112887970862A 0.66s 8.081112887970862A 0.660000000001s 8.003271082579817A 0.672s 8.003271082579817A 0.672000000001s 11.357657421795588A 0.684s 11.357657421795588A 0.684000000001s 11.13286444931648A 0.6960000000000001s 11.13286444931648A 0.696000000001s 11.085874533019073A 0.708s 11.085874533019073A 0.7080000000009999s 11.124601608639386A 0.72s 11.124601608639386A 0.720000000001s 11.033358426089567A 0.732s 11.033358426089567A 0.732000000001s 11.17379625393615A 0.744s 11.17379625393615A 0.744000000001s 11.048901043102639A 0.756s 11.048901043102639A 0.756000000001s 11.101213741761306A 0.768s 11.101213741761306A 0.768000000001s 11.110017360051426A 0.78s 11.110017360051426A 0.780000000001s 11.041020806136707A 0.792s 11.041020806136707A 0.792000000001s 11.218969168579388A 0.804s 11.218969168579388A 0.804000000001s 9.637310752020571A 0.8160000000000001s 9.637310752020571A 0.816000000001s 12.44434688047997A 0.8280000000000001s 12.44434688047997A 0.828000000001s 12.462596840351406A 0.84s 12.462596840351406A 0.840000000001s 12.40358690790658A 0.852s 12.40358690790658A 0.852000000001s 12.423198173421902A 0.864s 12.423198173421902A 0.864000000001s 12.42537044785944A 0.876s 12.42537044785944A 0.876000000001s 12.400724919134351A 0.888s 12.400724919134351A 0.888000000001s 12.44090419366617A 0.9s 12.44090419366617A 0.900000000001s 12.431501607919436A 0.912s 12.431501607919436A 0.912000000001s 12.411445933027645A 0.924s 12.411445933027645A 0.924000000001s 10.330919297433041A 0.936s 10.330919297433041A 0.936000000001s 12.353540480411404A 0.9480000000000001s 12.353540480411404A 0.948000000001s 12.343823581675597A 0.96s 12.343823581675597A 0.9600000000009999s 12.386284483634029A 0.972s 12.386284483634029A 0.972000000001s 12.367393410756378A 0.984s 12.367393410756378A 0.984000000001s 12.366785308592249A 0.996s 12.366785308592249A 0.996000000001s 12.35215802147847A 1.008s 12.35215802147847A 1.008000000001s 12.420135660252841A 1.02s 12.420135660252841A 1.020000000001s 12.404587626826657A 1.032s 12.404587626826657A 1.0320000000010001s 12.307228845425328A 1.044s 12.307228845425328A 1.0440000000010001s 3.4898986420055715A 1.056s 3.4898986420055715A 1.0560000000010001s 3.2013005572744815A 1.068s 3.2013005572744815A 1.0680000000010001s 14.039382710229273A 1.08s 14.039382710229273A 1.0800000000010002s 14.06606009654168A 1.092s 14.06606009654168A 1.0920000000010002s 14.033939859164349A 1.104s 14.033939859164349A 1.1040000000010002s 14.009591515851728A 1.116s 14.009591515851728A 1.1160000000010002s 14.01276298675809A 1.1280000000000001s 14.01276298675809A 1.1280000000010002s 14.078781406436685A 1.1400000000000001s 14.078781406436685A 1.1400000000010002s 14.069233148455112A 1.1520000000000001s 14.069233148455112A 1.1520000000010002s 13.983470761139923A 1.164s 13.983470761139923A 1.164000000001s 14.07075504342833A 1.176s 14.07075504342833A 1.176000000001s 12.392714073417617A 1.188s 12.392714073417617A 1.188000000001s 12.451384367482326A 1.2s 12.451384367482326A 1.200000000001s 12.47326152354832A 1.212s 12.47326152354832A 1.212000000001s 12.434573460741378A 1.224s 12.434573460741378A 1.224000000001s 12.414144126539536A 1.236s 12.414144126539536A 1.236000000001s 12.387729465541035A 1.248s 12.387729465541035A 1.248000000001s 12.400767869826446A 1.26s 12.400767869826446A 1.260000000001s 12.432242573233344A 1.272s 12.432242573233344A 1.272000000001s 12.430253666338121A 1.284s 12.430253666338121A 1.2840000000010001s 12.456374289299337A 1.296s 12.456374289299337A 1.2960000000010001s 10.282632267306623A 1.308s 10.282632267306623A 1.3080000000010001s 11.013546109175062A 1.32s 11.013546109175062A 1.3200000000010002s 11.074491003968289A 1.332s 11.074491003968289A 1.3320000000010002s 11.109889152089139A 1.344s 11.109889152089139A 1.3440000000010002s 11.083417882254128A 1.356s 11.083417882254128A 1.3560000000010002s 11.154772288630813A 1.368s 11.154772288630813A 1.3680000000010002s 11.009343250739235A 1.3800000000000001s 11.009343250739235A 1.3800000000010002s 11.121586452487684A 1.3920000000000001s 11.121586452487684A 1.3920000000010002s 11.101996750152132A 1.4040000000000001s 11.101996750152132A 1.4040000000010002s 11.129686171296338A 1.416s 11.129686171296338A 1.416000000001s 11.096009695958864A 1.428s 11.096009695958864A 1.428000000001s 6.601780411056355A 1.44s 6.601780411056355A 1.440000000001s 3.0825221749646463A 1.452s 3.0825221749646463A 1.452000000001s 4.630994901769875A 1.464s 4.630994901769875A 1.464000000001s 14.06536192089137A 1.476s 14.06536192089137A 1.476000000001s 14.065041591292054A 1.488s 14.065041591292054A 1.488000000001s 13.94394647734305A 1.5s 13.94394647734305A 1.500000000001s 14.08041326923506A 1.512s 14.08041326923506A 1.512000000001s 14.0216583766531A 1.524s 14.0216583766531A 1.524000000001s 13.983278127139494A 1.536s 13.983278127139494A 1.5360000000010001s 14.03527182834369A 1.548s 14.03527182834369A 1.5480000000010001s 14.052681482956935A 1.56s 14.052681482956935A 1.5600000000010001s 14.060569376095996A 1.572s 14.060569376095996A 1.5720000000010002s 11.853936068360834A 1.584s 11.853936068360834A 1.5840000000010002s 12.467186152543391A 1.596s 12.467186152543391A 1.5960000000010002s 12.425073774810375A 1.608s 12.425073774810375A 1.6080000000010002s 12.4384817102207A 1.62s 12.4384817102207A 1.6200000000010002s 12.435572510820663A 1.6320000000000001s 12.435572510820663A 1.6320000000010002s 12.3763665774159A 1.6440000000000001s 12.3763665774159A 1.6440000000010002s 12.414243041954151A 1.6560000000000001s 12.414243041954151A 1.6560000000010002s 12.431980565228201A 1.668s 12.431980565228201A 1.668000000001s 12.444911914840375A 1.68s 12.444911914840375A 1.680000000001s 12.449329980544253A 1.692s 12.449329980544253A 1.692000000001s 9.791790177055926A 1.704s 9.791790177055926A 1.704000000001s 11.09757309236769A 1.716s 11.09757309236769A 1.716000000001s 11.114037524336837A 1.728s 11.114037524336837A 1.728000000001s 11.11794168954789A 1.74s 11.11794168954789A 1.740000000001s 11.109992093216203A 1.752s 11.109992093216203A 1.752000000001s 10.990706690722096A 1.764s 10.990706690722096A 1.764000000001s 11.093055569607888A 1.776s 11.093055569607888A 1.7760000000010001s 11.116095702764092A 1.788s 11.116095702764092A 1.7880000000010001s 11.064145698838658A 1.8s 11.064145698838658A 1.8000000000010001s 11.154217077008788A 1.812s 11.154217077008788A 1.8120000000010001s 11.026626732204846A 1.824s 11.026626732204846A 1.8240000000010002s 3.990451951077781A 1.836s 3.990451951077781A 1.8360000000010002s 3.0820631705506756A 1.848s 3.0820631705506756A 1.8480000000010002s 8.805088699892867A 1.86s 8.805088699892867A 1.8600000000010002s 14.067054403599746A 1.872s 14.067054403599746A 1.8720000000010002s 14.056393760754236A)
R_0_5_0_1 Node0_5_0 Node0_5_1 9.887809523809524
R_0_5_0_2 Node0_5_0 Node0_6_0 13.020765027322408
R_0_5_0_3 Node0_5_0 Node1_5_0 2.595018540202966
C_0_5_0 Node0_5_0 GND 0.0009924144753600001
I_0_5_1 GND Node0_5_1 PWL(0s 0A 0.012s 0A 0.012000000001s 4.253369606205271A 0.024s 4.253369606205271A 0.024000000001s 12.656371961911294A 0.036000000000000004s 12.656371961911294A 0.036000000001s 14.317231747469467A 0.048s 14.317231747469467A 0.048000000001s 15.810387671874867A 0.06s 15.810387671874867A 0.060000000000999996s 16.51464358260125A 0.07200000000000001s 16.51464358260125A 0.07200000000100001s 6.458576596700237A 0.084s 6.458576596700237A 0.08400000000100001s 10.833487160848513A 0.096s 10.833487160848513A 0.09600000000100001s 13.92306638045854A 0.108s 13.92306638045854A 0.108000000001s 15.453325876528822A 0.12s 15.453325876528822A 0.120000000001s 16.597357685811016A 0.132s 16.597357685811016A 0.132000000001s 7.876147266612387A 0.14400000000000002s 7.876147266612387A 0.14400000000100002s 8.505394170644955A 0.156s 8.505394170644955A 0.156000000001s 13.22511043157489A 0.168s 13.22511043157489A 0.16800000000100002s 15.050219841337052A 0.18s 15.050219841337052A 0.180000000001s 15.824987847645172A 0.192s 15.824987847645172A 0.192000000001s 12.798682756134564A 0.20400000000000001s 12.798682756134564A 0.20400000000100002s 5.829512123316906A 0.216s 5.829512123316906A 0.216000000001s 12.090739541667025A 0.228s 12.090739541667025A 0.228000000001s 14.143305027846583A 0.24s 14.143305027846583A 0.240000000001s 15.707558225395328A 0.252s 15.707558225395328A 0.252000000001s 15.207542239142922A 0.264s 15.207542239142922A 0.264000000001s 7.5808146480394285A 0.276s 7.5808146480394285A 0.276000000001s 9.362618488176562A 0.28800000000000003s 9.362618488176562A 0.288000000001s 13.31642352977073A 0.3s 13.31642352977073A 0.30000000000099997s 15.590512758585817A 0.312s 15.590512758585817A 0.312000000001s 16.004127645305335A 0.324s 16.004127645305335A 0.324000000001s 8.745050615127493A 0.336s 8.745050615127493A 0.336000000001s 7.112180595212342A 0.34800000000000003s 7.112180595212342A 0.348000000001s 13.32118490823227A 0.36s 13.32118490823227A 0.36000000000099996s 14.757541982498395A 0.372s 14.757541982498395A 0.372000000001s 15.686983292153421A 0.384s 15.686983292153421A 0.384000000001s 12.300268256850229A 0.396s 12.300268256850229A 0.396000000001s 5.484516661769875A 0.40800000000000003s 5.484516661769875A 0.408000000001s 12.231189636957364A 0.42s 12.231189636957364A 0.42000000000099996s 14.390783373061925A 0.432s 14.390783373061925A 0.432000000001s 15.359246162348406A 0.444s 15.359246162348406A 0.444000000001s 16.740585127439473A 0.456s 16.740585127439473A 0.456000000001s 7.138272982558391A 0.468s 7.138272982558391A 0.468000000001s 9.546122729050783A 0.48s 9.546122729050783A 0.48000000000099996s 13.60353911295479A 0.492s 13.60353911295479A 0.49200000000099997s 15.269145550186417A 0.504s 15.269145550186417A 0.504000000001s 16.403708386063855A 0.516s 16.403708386063855A 0.516000000001s 8.852848947246628A 0.528s 8.852848947246628A 0.528000000001s 7.182559859850012A 0.54s 7.182559859850012A 0.540000000001s 13.411779658298695A 0.552s 13.411779658298695A 0.552000000001s 14.23833662539533A 0.5640000000000001s 14.23833662539533A 0.564000000001s 15.875114159914295A 0.5760000000000001s 15.875114159914295A 0.576000000001s 13.125689987675171A 0.588s 13.125689987675171A 0.588000000001s 6.542265215101779A 0.6s 6.542265215101779A 0.600000000001s 10.573141921337047A 0.612s 10.573141921337047A 0.612000000001s 13.777310908523681A 0.624s 13.777310908523681A 0.624000000001s 15.634628813919008A 0.636s 15.634628813919008A 0.636000000001s 15.800049539832871A 0.648s 15.800049539832871A 0.648000000001s 8.081112887970862A 0.66s 8.081112887970862A 0.660000000001s 8.003271082579817A 0.672s 8.003271082579817A 0.672000000001s 11.357657421795587A 0.684s 11.357657421795587A 0.684000000001s 11.132864449316479A 0.6960000000000001s 11.132864449316479A 0.696000000001s 11.085874533019073A 0.708s 11.085874533019073A 0.7080000000009999s 11.124601608639386A 0.72s 11.124601608639386A 0.720000000001s 11.033358426089567A 0.732s 11.033358426089567A 0.732000000001s 11.17379625393615A 0.744s 11.17379625393615A 0.744000000001s 11.048901043102639A 0.756s 11.048901043102639A 0.756000000001s 11.101213741761306A 0.768s 11.101213741761306A 0.768000000001s 11.110017360051426A 0.78s 11.110017360051426A 0.780000000001s 11.041020806136707A 0.792s 11.041020806136707A 0.792000000001s 11.218969168579388A 0.804s 11.218969168579388A 0.804000000001s 9.637310752020571A 0.8160000000000001s 9.637310752020571A 0.816000000001s 12.444346880479968A 0.8280000000000001s 12.444346880479968A 0.828000000001s 12.462596840351406A 0.84s 12.462596840351406A 0.840000000001s 12.403586907906579A 0.852s 12.403586907906579A 0.852000000001s 12.423198173421902A 0.864s 12.423198173421902A 0.864000000001s 12.42537044785944A 0.876s 12.42537044785944A 0.876000000001s 12.400724919134351A 0.888s 12.400724919134351A 0.888000000001s 12.44090419366617A 0.9s 12.44090419366617A 0.900000000001s 12.431501607919436A 0.912s 12.431501607919436A 0.912000000001s 12.411445933027643A 0.924s 12.411445933027643A 0.924000000001s 10.330919297433041A 0.936s 10.330919297433041A 0.936000000001s 12.353540480411402A 0.9480000000000001s 12.353540480411402A 0.948000000001s 12.343823581675597A 0.96s 12.343823581675597A 0.9600000000009999s 12.386284483634027A 0.972s 12.386284483634027A 0.972000000001s 12.367393410756378A 0.984s 12.367393410756378A 0.984000000001s 12.366785308592247A 0.996s 12.366785308592247A 0.996000000001s 12.35215802147847A 1.008s 12.35215802147847A 1.008000000001s 12.42013566025284A 1.02s 12.42013566025284A 1.020000000001s 12.404587626826657A 1.032s 12.404587626826657A 1.0320000000010001s 12.307228845425328A 1.044s 12.307228845425328A 1.0440000000010001s 3.4898986420055715A 1.056s 3.4898986420055715A 1.0560000000010001s 3.201300557274481A 1.068s 3.201300557274481A 1.0680000000010001s 14.039382710229273A 1.08s 14.039382710229273A 1.0800000000010002s 14.066060096541678A 1.092s 14.066060096541678A 1.0920000000010002s 14.033939859164349A 1.104s 14.033939859164349A 1.1040000000010002s 14.009591515851728A 1.116s 14.009591515851728A 1.1160000000010002s 14.01276298675809A 1.1280000000000001s 14.01276298675809A 1.1280000000010002s 14.078781406436683A 1.1400000000000001s 14.078781406436683A 1.1400000000010002s 14.069233148455112A 1.1520000000000001s 14.069233148455112A 1.1520000000010002s 13.983470761139921A 1.164s 13.983470761139921A 1.164000000001s 14.07075504342833A 1.176s 14.07075504342833A 1.176000000001s 12.392714073417615A 1.188s 12.392714073417615A 1.188000000001s 12.451384367482326A 1.2s 12.451384367482326A 1.200000000001s 12.47326152354832A 1.212s 12.47326152354832A 1.212000000001s 12.434573460741378A 1.224s 12.434573460741378A 1.224000000001s 12.414144126539536A 1.236s 12.414144126539536A 1.236000000001s 12.387729465541035A 1.248s 12.387729465541035A 1.248000000001s 12.400767869826446A 1.26s 12.400767869826446A 1.260000000001s 12.432242573233344A 1.272s 12.432242573233344A 1.272000000001s 12.430253666338121A 1.284s 12.430253666338121A 1.2840000000010001s 12.456374289299335A 1.296s 12.456374289299335A 1.2960000000010001s 10.28263226730662A 1.308s 10.28263226730662A 1.3080000000010001s 11.013546109175062A 1.32s 11.013546109175062A 1.3200000000010002s 11.074491003968289A 1.332s 11.074491003968289A 1.3320000000010002s 11.109889152089139A 1.344s 11.109889152089139A 1.3440000000010002s 11.083417882254126A 1.356s 11.083417882254126A 1.3560000000010002s 11.154772288630813A 1.368s 11.154772288630813A 1.3680000000010002s 11.009343250739235A 1.3800000000000001s 11.009343250739235A 1.3800000000010002s 11.121586452487682A 1.3920000000000001s 11.121586452487682A 1.3920000000010002s 11.101996750152132A 1.4040000000000001s 11.101996750152132A 1.4040000000010002s 11.129686171296337A 1.416s 11.129686171296337A 1.416000000001s 11.096009695958863A 1.428s 11.096009695958863A 1.428000000001s 6.601780411056355A 1.44s 6.601780411056355A 1.440000000001s 3.0825221749646463A 1.452s 3.0825221749646463A 1.452000000001s 4.630994901769874A 1.464s 4.630994901769874A 1.464000000001s 14.06536192089137A 1.476s 14.06536192089137A 1.476000000001s 14.065041591292053A 1.488s 14.065041591292053A 1.488000000001s 13.943946477343049A 1.5s 13.943946477343049A 1.500000000001s 14.080413269235057A 1.512s 14.080413269235057A 1.512000000001s 14.021658376653098A 1.524s 14.021658376653098A 1.524000000001s 13.983278127139492A 1.536s 13.983278127139492A 1.5360000000010001s 14.035271828343689A 1.548s 14.035271828343689A 1.5480000000010001s 14.052681482956935A 1.56s 14.052681482956935A 1.5600000000010001s 14.060569376095994A 1.572s 14.060569376095994A 1.5720000000010002s 11.853936068360834A 1.584s 11.853936068360834A 1.5840000000010002s 12.467186152543391A 1.596s 12.467186152543391A 1.5960000000010002s 12.425073774810373A 1.608s 12.425073774810373A 1.6080000000010002s 12.4384817102207A 1.62s 12.4384817102207A 1.6200000000010002s 12.435572510820661A 1.6320000000000001s 12.435572510820661A 1.6320000000010002s 12.3763665774159A 1.6440000000000001s 12.3763665774159A 1.6440000000010002s 12.414243041954151A 1.6560000000000001s 12.414243041954151A 1.6560000000010002s 12.431980565228201A 1.668s 12.431980565228201A 1.668000000001s 12.444911914840374A 1.68s 12.444911914840374A 1.680000000001s 12.44932998054425A 1.692s 12.44932998054425A 1.692000000001s 9.791790177055926A 1.704s 9.791790177055926A 1.704000000001s 11.09757309236769A 1.716s 11.09757309236769A 1.716000000001s 11.114037524336837A 1.728s 11.114037524336837A 1.728000000001s 11.11794168954789A 1.74s 11.11794168954789A 1.740000000001s 11.109992093216203A 1.752s 11.109992093216203A 1.752000000001s 10.990706690722096A 1.764s 10.990706690722096A 1.764000000001s 11.093055569607888A 1.776s 11.093055569607888A 1.7760000000010001s 11.116095702764092A 1.788s 11.116095702764092A 1.7880000000010001s 11.064145698838658A 1.8s 11.064145698838658A 1.8000000000010001s 11.154217077008788A 1.812s 11.154217077008788A 1.8120000000010001s 11.026626732204845A 1.824s 11.026626732204845A 1.8240000000010002s 3.990451951077781A 1.836s 3.990451951077781A 1.8360000000010002s 3.082063170550675A 1.848s 3.082063170550675A 1.8480000000010002s 8.805088699892867A 1.86s 8.805088699892867A 1.8600000000010002s 14.067054403599744A 1.872s 14.067054403599744A 1.8720000000010002s 14.056393760754236A)
R_0_5_1_1 Node0_5_1 Node0_5_2 9.887809523809524
R_0_5_1_2 Node0_5_1 Node0_6_1 13.020765027322408
R_0_5_1_3 Node0_5_1 Node1_5_1 2.595018540202966
C_0_5_1 Node0_5_1 GND 0.0009924144753600001
I_0_5_2 GND Node0_5_2 PWL(0s 0A 0.012s 0A 0.012000000001s 1.9756159026961713A 0.024s 1.9756159026961713A 0.024000000001s 5.775337965505216A 0.036000000000000004s 5.775337965505216A 0.036000000001s 6.526355937717306A 0.048s 6.526355937717306A 0.048000000001s 7.2015406065939205A 0.06s 7.2015406065939205A 0.060000000000999996s 7.519995037591854A 0.07200000000000001s 7.519995037591854A 0.07200000000100001s 2.9727793450099975A 0.084s 2.9727793450099975A 0.08400000000100001s 4.951054841309255A 0.096s 4.951054841309255A 0.09600000000100001s 6.348119786896945A 0.108s 6.348119786896945A 0.108000000001s 7.040082163725848A 0.12s 7.040082163725848A 0.120000000001s 7.557397437922818A 0.132s 7.557397437922818A 0.132000000001s 3.6137848336176606A 0.14400000000000002s 3.6137848336176606A 0.14400000000100002s 3.8983236657942495A 0.156s 3.8983236657942495A 0.156000000001s 6.032513851104081A 0.168s 6.032513851104081A 0.16800000000100002s 6.857803083769144A 0.18s 6.857803083769144A 0.180000000001s 7.20814259864306A 0.192s 7.20814259864306A 0.192000000001s 5.839687422566497A 0.20400000000000001s 5.839687422566497A 0.20400000000100002s 2.688325843739207A 0.216s 2.688325843739207A 0.216000000001s 5.519566849356663A 0.228s 5.519566849356663A 0.228000000001s 6.447708832204696A 0.24s 6.447708832204696A 0.240000000001s 7.155042419838982A 0.252s 7.155042419838982A 0.252000000001s 6.928941950864498A 0.264s 6.928941950864498A 0.264000000001s 3.480239619481528A 0.276s 3.480239619481528A 0.276000000001s 4.285948581071289A 0.28800000000000003s 4.285948581071289A 0.288000000001s 6.07380450878538A 0.3s 6.07380450878538A 0.30000000000099997s 7.102116122688779A 0.312s 7.102116122688779A 0.312000000001s 7.289147242011097A 0.324s 7.289147242011097A 0.324000000001s 4.006690668752146A 0.336s 4.006690668752146A 0.336000000001s 3.2683319372314483A 0.34800000000000003s 3.2683319372314483A 0.348000000001s 6.075957278445132A 0.36s 6.075957278445132A 0.36000000000099996s 6.725458228256113A 0.372s 6.725458228256113A 0.372000000001s 7.145738985381003A 0.384s 7.145738985381003A 0.384000000001s 5.614311123245608A 0.396s 5.614311123245608A 0.396000000001s 2.5323234535590933A 0.40800000000000003s 2.5323234535590933A 0.408000000001s 5.583076472991972A 0.42s 5.583076472991972A 0.42000000000099996s 6.559615023825294A 0.432s 6.559615023825294A 0.432000000001s 6.9975406536251405A 0.444s 6.9975406536251405A 0.444000000001s 7.622162508058396A 0.456s 7.622162508058396A 0.456000000001s 3.280128479817364A 0.468s 3.280128479817364A 0.468000000001s 4.368926677641387A 0.48s 4.368926677641387A 0.48000000000099996s 6.203634096263418A 0.492s 6.203634096263418A 0.49200000000099997s 6.956798436923477A 0.504s 6.956798436923477A 0.504000000001s 7.469831975878678A 0.516s 7.469831975878678A 0.516000000001s 4.0554356289862685A 0.528s 4.0554356289862685A 0.528000000001s 3.3001562687549204A 0.54s 3.3001562687549204A 0.540000000001s 6.116923023297496A 0.552s 6.116923023297496A 0.552000000001s 6.490680856451387A 0.5640000000000001s 6.490680856451387A 0.564000000001s 7.230808918863191A 0.5760000000000001s 7.230808918863191A 0.576000000001s 5.987555532675629A 0.588s 5.987555532675629A 0.588000000001s 3.010622665297666A 0.6s 3.010622665297666A 0.600000000001s 4.8333306809288406A 0.612s 4.8333306809288406A 0.612000000001s 6.282211405352475A 0.624s 6.282211405352475A 0.624000000001s 7.1220647761249625A 0.636s 7.1220647761249625A 0.636000000001s 7.196865076067423A 0.648s 7.196865076067423A 0.648000000001s 3.706467461526949A 0.66s 3.706467461526949A 0.660000000001s 3.6712708253712756A 0.672s 3.6712708253712756A 0.672000000001s 5.188072111441491A 0.684s 5.188072111441491A 0.684000000001s 5.086423407001262A 0.6960000000000001s 5.086423407001262A 0.696000000001s 5.065175234467872A 0.708s 5.065175234467872A 0.7080000000009999s 5.08268706784263A 0.72s 5.08268706784263A 0.720000000001s 5.041428197044829A 0.732s 5.041428197044829A 0.732000000001s 5.104932187505511A 0.744s 5.104932187505511A 0.744000000001s 5.048456347634073A 0.756s 5.048456347634073A 0.756000000001s 5.072111406726996A 0.768s 5.072111406726996A 0.768000000001s 5.0760922778390585A 0.78s 5.0760922778390585A 0.780000000001s 5.04489301643773A 0.792s 5.04489301643773A 0.792000000001s 5.125358737706211A 0.804s 5.125358737706211A 0.804000000001s 4.410155273387947A 0.8160000000000001s 4.410155273387947A 0.816000000001s 5.67945712928967A 0.8280000000000001s 5.67945712928967A 0.828000000001s 5.687709501854486A 0.84s 5.687709501854486A 0.840000000001s 5.66102604879542A 0.852s 5.66102604879542A 0.852000000001s 5.669893984431446A 0.864s 5.669893984431446A 0.864000000001s 5.670876256069184A 0.876s 5.670876256069184A 0.876000000001s 5.659731898134752A 0.888s 5.659731898134752A 0.888000000001s 5.6779003952249605A 0.9s 5.6779003952249605A 0.900000000001s 5.673648679538937A 0.912s 5.673648679538937A 0.912000000001s 5.6645797882968845A 0.924s 5.6645797882968845A 0.924000000001s 4.723795203075827A 0.936s 4.723795203075827A 0.936000000001s 5.638395765324239A 0.9480000000000001s 5.638395765324239A 0.948000000001s 5.634001921770207A 0.96s 5.634001921770207A 0.9600000000009999s 5.653202138366164A 0.972s 5.653202138366164A 0.972000000001s 5.644659863608648A 0.984s 5.644659863608648A 0.984000000001s 5.64438488844973A 0.996s 5.64438488844973A 0.996000000001s 5.637770637036259A 1.008s 5.637770637036259A 1.008000000001s 5.668509159487512A 1.02s 5.668509159487512A 1.020000000001s 5.661478559673214A 1.032s 5.661478559673214A 1.0320000000010001s 5.61745430196305A 1.044s 5.61745430196305A 1.0440000000010001s 1.6303828575205102A 1.056s 1.6303828575205102A 1.0560000000010001s 1.4998829039057684A 1.068s 1.4998829039057684A 1.0680000000010001s 6.400709755801914A 1.08s 6.400709755801914A 1.0800000000010002s 6.412772890869411A 1.092s 6.412772890869411A 1.0920000000010002s 6.398248575880481A 1.104s 6.398248575880481A 1.1040000000010002s 6.38723860096726A 1.116s 6.38723860096726A 1.1160000000010002s 6.388672695051968A 1.1280000000000001s 6.388672695051968A 1.1280000000010002s 6.41852528646401A 1.1400000000000001s 6.41852528646401A 1.1400000000010002s 6.414207699863052A 1.1520000000000001s 6.414207699863052A 1.1520000000010002s 6.3754271668011295A 1.164s 6.3754271668011295A 1.164000000001s 6.414895879147389A 1.176s 6.414895879147389A 1.176000000001s 5.656109507516939A 1.188s 5.656109507516939A 1.188000000001s 5.682639380925981A 1.2s 5.682639380925981A 1.200000000001s 5.692531920076042A 1.212s 5.692531920076042A 1.212000000001s 5.675037727741208A 1.224s 5.675037727741208A 1.224000000001s 5.6657998730679715A 1.236s 5.6657998730679715A 1.236000000001s 5.653855538654715A 1.248s 5.653855538654715A 1.248000000001s 5.659751319827489A 1.26s 5.659751319827489A 1.260000000001s 5.67398373352651A 1.272s 5.67398373352651A 1.272000000001s 5.673084378086185A 1.284s 5.673084378086185A 1.2840000000010001s 5.68489575267657A 1.296s 5.68489575267657A 1.2960000000010001s 4.701960494097897A 1.308s 4.701960494097897A 1.3080000000010001s 5.03246934882256A 1.32s 5.03246934882256A 1.3200000000010002s 5.060027764364307A 1.332s 5.060027764364307A 1.3320000000010002s 5.0760343040200455A 1.344s 5.0760343040200455A 1.3440000000010002s 5.064064371895198A 1.356s 5.064064371895198A 1.3560000000010002s 5.0963298206802845A 1.368s 5.0963298206802845A 1.3680000000010002s 5.030568875950622A 1.3800000000000001s 5.030568875950622A 1.3800000000010002s 5.081323657069114A 1.3920000000000001s 5.081323657069114A 1.3920000000010002s 5.072465471996618A 1.4040000000000001s 5.072465471996618A 1.4040000000010002s 5.084986234836417A 1.416s 5.084986234836417A 1.416000000001s 5.0697582111523944A 1.428s 5.0697582111523944A 1.428000000001s 3.0375315809574075A 1.44s 3.0375315809574075A 1.440000000001s 1.4461730069869767A 1.452s 1.4461730069869767A 1.452000000001s 2.146370373889341A 1.464s 2.146370373889341A 1.464000000001s 6.412457185759775A 1.476s 6.412457185759775A 1.476000000001s 6.412312337266096A 1.488s 6.412312337266096A 1.488000000001s 6.357554847215385A 1.5s 6.357554847215385A 1.500000000001s 6.419263191636498A 1.512s 6.419263191636498A 1.512000000001s 6.392695063979902A 1.524s 6.392695063979902A 1.524000000001s 6.375340060443012A 1.536s 6.375340060443012A 1.5360000000010001s 6.398850873419226A 1.548s 6.398850873419226A 1.5480000000010001s 6.406723271885052A 1.56s 6.406723271885052A 1.5600000000010001s 6.410290065094108A 1.572s 6.410290065094108A 1.5720000000010002s 5.412481748399734A 1.584s 5.412481748399734A 1.5840000000010002s 5.68978472362436A 1.596s 5.68978472362436A 1.5960000000010002s 5.670742104731424A 1.608s 5.670742104731424A 1.6080000000010002s 5.676804982628716A 1.62s 5.676804982628716A 1.6200000000010002s 5.675489483992907A 1.6320000000000001s 5.675489483992907A 1.6320000000010002s 5.648717402084469A 1.6440000000000001s 5.648717402084469A 1.6440000000010002s 5.665844601213105A 1.6560000000000001s 5.665844601213105A 1.6560000000010002s 5.673865257229102A 1.668s 5.673865257229102A 1.668000000001s 5.679712629799634A 1.68s 5.679712629799634A 1.680000000001s 5.681710416340596A 1.692s 5.681710416340596A 1.692000000001s 4.480008674599291A 1.704s 4.480008674599291A 1.704000000001s 5.070465156796276A 1.716s 5.070465156796276A 1.716000000001s 5.077910139011832A 1.728s 5.077910139011832A 1.728000000001s 5.079675547051258A 1.74s 5.079675547051258A 1.740000000001s 5.076080852535153A 1.752s 5.076080852535153A 1.752000000001s 5.022141688292599A 1.764s 5.022141688292599A 1.764000000001s 5.0684223971876765A 1.776s 5.0684223971876765A 1.7760000000010001s 5.078840818054759A 1.788s 5.078840818054759A 1.7880000000010001s 5.055349764367164A 1.8s 5.055349764367164A 1.8000000000010001s 5.0960787618730565A 1.812s 5.0960787618730565A 1.8120000000010001s 5.038384220711712A 1.824s 5.038384220711712A 1.8240000000010002s 1.8567259521966044A 1.836s 1.8567259521966044A 1.8360000000010002s 1.4459654517123535A 1.848s 1.4459654517123535A 1.8480000000010002s 4.033836285335666A 1.86s 4.033836285335666A 1.8600000000010002s 6.4132225023943015A 1.872s 6.4132225023943015A 1.8720000000010002s 6.408401997173098A)
R_0_5_2_1 Node0_5_2 Node0_5_3 9.887809523809524
R_0_5_2_2 Node0_5_2 Node0_6_2 13.020765027322408
R_0_5_2_3 Node0_5_2 Node1_5_2 2.595018540202966
C_0_5_2 Node0_5_2 GND 0.0009924144753600001
I_0_5_3 GND Node0_5_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629112A 0.024s 0.09547506513629112A 0.024000000001s 0.09548197345930416A 0.036000000000000004s 0.09548197345930416A 0.036000000001s 0.09548338652537505A 0.048s 0.09548338652537505A 0.048000000001s 0.0954847995914459A 0.06s 0.0954847995914459A 0.060000000000999996s 0.09548464258410472A 0.07200000000000001s 0.09548464258410472A 0.07200000000100001s 0.09547537915097351A 0.084s 0.09547537915097351A 0.08400000000100001s 0.09548103141525696A 0.096s 0.09548103141525696A 0.09600000000100001s 0.09548307251069263A 0.108s 0.09548307251069263A 0.108000000001s 0.09548448557676348A 0.12s 0.09548448557676348A 0.120000000001s 0.0954851136061283A 0.132s 0.0954851136061283A 0.132000000001s 0.09547569316565593A 0.14400000000000002s 0.09547569316565593A 0.14400000000100002s 0.0954799323638685A 0.156s 0.0954799323638685A 0.156000000001s 0.0954827584960102A 0.168s 0.0954827584960102A 0.16800000000100002s 0.09548401455473986A 0.18s 0.09548401455473986A 0.180000000001s 0.0954847995914459A 0.192s 0.0954847995914459A 0.192000000001s 0.09547930433450366A 0.20400000000000001s 0.09547930433450366A 0.20400000000100002s 0.09547632119502074A 0.216s 0.09547632119502074A 0.216000000001s 0.09548165944462177A 0.228s 0.09548165944462177A 0.228000000001s 0.09548354353271624A 0.24s 0.09548354353271624A 0.240000000001s 0.09548448557676348A 0.252s 0.09548448557676348A 0.252000000001s 0.09548385754739866A 0.264s 0.09548385754739866A 0.264000000001s 0.09547569316565593A 0.276s 0.09547569316565593A 0.276000000001s 0.09548040338589212A 0.28800000000000003s 0.09548040338589212A 0.288000000001s 0.09548307251069263A 0.3s 0.09548307251069263A 0.30000000000099997s 0.09548448557676348A 0.312s 0.09548448557676348A 0.312000000001s 0.0954851136061283A 0.324s 0.0954851136061283A 0.324000000001s 0.09547585017299712A 0.336s 0.09547585017299712A 0.336000000001s 0.09547930433450366A 0.34800000000000003s 0.09547930433450366A 0.348000000001s 0.095482601488669A 0.36s 0.095482601488669A 0.36000000000099996s 0.09548385754739866A 0.372s 0.09548385754739866A 0.372000000001s 0.09548495659878709A 0.384s 0.09548495659878709A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.09547569316565593A 0.40800000000000003s 0.09547569316565593A 0.408000000001s 0.09548181645196296A 0.42s 0.09548181645196296A 0.42000000000099996s 0.09548354353271624A 0.432s 0.09548354353271624A 0.432000000001s 0.09548448557676348A 0.444s 0.09548448557676348A 0.444000000001s 0.09548448557676348A 0.456s 0.09548448557676348A 0.456000000001s 0.09547553615831472A 0.468s 0.09547553615831472A 0.468000000001s 0.09548056039323331A 0.48s 0.09548056039323331A 0.48000000000099996s 0.09548307251069263A 0.492s 0.09548307251069263A 0.49200000000099997s 0.09548448557676348A 0.504s 0.09548448557676348A 0.504000000001s 0.0954851136061283A 0.516s 0.0954851136061283A 0.516000000001s 0.09547600718033832A 0.528s 0.09547600718033832A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.0954827584960102A 0.552s 0.0954827584960102A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410472A 0.5760000000000001s 0.09548464258410472A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502074A 0.6s 0.09547632119502074A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537505A 0.624s 0.09548338652537505A 0.624000000001s 0.09548448557676348A 0.636s 0.09548448557676348A 0.636000000001s 0.09548338652537505A 0.648s 0.09548338652537505A 0.648000000001s 0.09547585017299712A 0.66s 0.09547585017299712A 0.660000000001s 0.09548008937120969A 0.672s 0.09548008937120969A 0.672000000001s 0.09547176798212575A 0.684s 0.09547176798212575A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541972A 1.08s 0.09547098294541972A 1.0800000000010002s 0.09547098294541972A 1.092s 0.09547098294541972A 1.0920000000010002s 0.09547098294541972A 1.104s 0.09547098294541972A 1.1040000000010002s 0.09547098294541972A 1.116s 0.09547098294541972A 1.1160000000010002s 0.09547098294541972A 1.1280000000000001s 0.09547098294541972A 1.1280000000010002s 0.09547098294541972A 1.1400000000000001s 0.09547098294541972A 1.1400000000010002s 0.09547098294541972A 1.1520000000000001s 0.09547098294541972A 1.1520000000010002s 0.09547098294541972A 1.164s 0.09547098294541972A 1.164000000001s 0.09547098294541972A 1.176s 0.09547098294541972A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541972A 1.476s 0.09547098294541972A 1.476000000001s 0.09547098294541972A 1.488s 0.09547098294541972A 1.488000000001s 0.09547098294541972A 1.5s 0.09547098294541972A 1.500000000001s 0.09547098294541972A 1.512s 0.09547098294541972A 1.512000000001s 0.09547098294541972A 1.524s 0.09547098294541972A 1.524000000001s 0.09547098294541972A 1.536s 0.09547098294541972A 1.5360000000010001s 0.09547098294541972A 1.548s 0.09547098294541972A 1.5480000000010001s 0.09547098294541972A 1.56s 0.09547098294541972A 1.5600000000010001s 0.09547098294541972A 1.572s 0.09547098294541972A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541972A 1.872s 0.09547098294541972A 1.8720000000010002s 0.09547113995276094A)
R_0_5_3_1 Node0_5_3 Node0_5_4 9.887809523809524
R_0_5_3_2 Node0_5_3 Node0_6_3 13.020765027322408
R_0_5_3_3 Node0_5_3 Node1_5_3 2.595018540202966
C_0_5_3 Node0_5_3 GND 0.0009924144753600001
I_0_5_4 GND Node0_5_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629112A 0.024s 0.09547506513629112A 0.024000000001s 0.09548197345930416A 0.036000000000000004s 0.09548197345930416A 0.036000000001s 0.09548338652537504A 0.048s 0.09548338652537504A 0.048000000001s 0.0954847995914459A 0.06s 0.0954847995914459A 0.060000000000999996s 0.09548464258410472A 0.07200000000000001s 0.09548464258410472A 0.07200000000100001s 0.0954753791509735A 0.084s 0.0954753791509735A 0.08400000000100001s 0.09548103141525695A 0.096s 0.09548103141525695A 0.09600000000100001s 0.09548307251069262A 0.108s 0.09548307251069262A 0.108000000001s 0.09548448557676346A 0.12s 0.09548448557676346A 0.120000000001s 0.0954851136061283A 0.132s 0.0954851136061283A 0.132000000001s 0.09547569316565592A 0.14400000000000002s 0.09547569316565592A 0.14400000000100002s 0.09547993236386851A 0.156s 0.09547993236386851A 0.156000000001s 0.0954827584960102A 0.168s 0.0954827584960102A 0.16800000000100002s 0.09548401455473986A 0.18s 0.09548401455473986A 0.180000000001s 0.0954847995914459A 0.192s 0.0954847995914459A 0.192000000001s 0.09547930433450366A 0.20400000000000001s 0.09547930433450366A 0.20400000000100002s 0.09547632119502074A 0.216s 0.09547632119502074A 0.216000000001s 0.09548165944462177A 0.228s 0.09548165944462177A 0.228000000001s 0.09548354353271624A 0.24s 0.09548354353271624A 0.240000000001s 0.09548448557676346A 0.252s 0.09548448557676346A 0.252000000001s 0.09548385754739863A 0.264s 0.09548385754739863A 0.264000000001s 0.09547569316565592A 0.276s 0.09547569316565592A 0.276000000001s 0.09548040338589212A 0.28800000000000003s 0.09548040338589212A 0.288000000001s 0.09548307251069262A 0.3s 0.09548307251069262A 0.30000000000099997s 0.09548448557676346A 0.312s 0.09548448557676346A 0.312000000001s 0.0954851136061283A 0.324s 0.0954851136061283A 0.324000000001s 0.09547585017299712A 0.336s 0.09547585017299712A 0.336000000001s 0.09547930433450366A 0.34800000000000003s 0.09547930433450366A 0.348000000001s 0.095482601488669A 0.36s 0.095482601488669A 0.36000000000099996s 0.09548385754739863A 0.372s 0.09548385754739863A 0.372000000001s 0.09548495659878709A 0.384s 0.09548495659878709A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.09547569316565592A 0.40800000000000003s 0.09547569316565592A 0.408000000001s 0.09548181645196296A 0.42s 0.09548181645196296A 0.42000000000099996s 0.09548354353271624A 0.432s 0.09548354353271624A 0.432000000001s 0.09548448557676346A 0.444s 0.09548448557676346A 0.444000000001s 0.09548448557676346A 0.456s 0.09548448557676346A 0.456000000001s 0.09547553615831472A 0.468s 0.09547553615831472A 0.468000000001s 0.0954805603932333A 0.48s 0.0954805603932333A 0.48000000000099996s 0.09548307251069262A 0.492s 0.09548307251069262A 0.49200000000099997s 0.09548448557676346A 0.504s 0.09548448557676346A 0.504000000001s 0.0954851136061283A 0.516s 0.0954851136061283A 0.516000000001s 0.0954760071803383A 0.528s 0.0954760071803383A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.0954827584960102A 0.552s 0.0954827584960102A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410472A 0.5760000000000001s 0.09548464258410472A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502074A 0.6s 0.09547632119502074A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537504A 0.624s 0.09548338652537504A 0.624000000001s 0.09548448557676346A 0.636s 0.09548448557676346A 0.636000000001s 0.09548338652537504A 0.648s 0.09548338652537504A 0.648000000001s 0.09547585017299712A 0.66s 0.09547585017299712A 0.660000000001s 0.09548008937120969A 0.672s 0.09548008937120969A 0.672000000001s 0.09547176798212573A 0.684s 0.09547176798212573A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541972A 1.08s 0.09547098294541972A 1.0800000000010002s 0.09547098294541972A 1.092s 0.09547098294541972A 1.0920000000010002s 0.09547098294541972A 1.104s 0.09547098294541972A 1.1040000000010002s 0.09547098294541972A 1.116s 0.09547098294541972A 1.1160000000010002s 0.09547098294541972A 1.1280000000000001s 0.09547098294541972A 1.1280000000010002s 0.09547098294541972A 1.1400000000000001s 0.09547098294541972A 1.1400000000010002s 0.09547098294541972A 1.1520000000000001s 0.09547098294541972A 1.1520000000010002s 0.09547098294541972A 1.164s 0.09547098294541972A 1.164000000001s 0.09547098294541972A 1.176s 0.09547098294541972A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541972A 1.476s 0.09547098294541972A 1.476000000001s 0.09547098294541972A 1.488s 0.09547098294541972A 1.488000000001s 0.09547098294541972A 1.5s 0.09547098294541972A 1.500000000001s 0.09547098294541972A 1.512s 0.09547098294541972A 1.512000000001s 0.09547098294541972A 1.524s 0.09547098294541972A 1.524000000001s 0.09547098294541972A 1.536s 0.09547098294541972A 1.5360000000010001s 0.09547098294541972A 1.548s 0.09547098294541972A 1.5480000000010001s 0.09547098294541972A 1.56s 0.09547098294541972A 1.5600000000010001s 0.09547098294541972A 1.572s 0.09547098294541972A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541972A 1.872s 0.09547098294541972A 1.8720000000010002s 0.09547113995276092A)
R_0_5_4_1 Node0_5_4 Node0_5_5 9.887809523809517
R_0_5_4_2 Node0_5_4 Node0_6_4 13.020765027322408
R_0_5_4_3 Node0_5_4 Node1_5_4 2.595018540202966
C_0_5_4 Node0_5_4 GND 0.00099241447536
I_0_5_5 GND Node0_5_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.8413260018331477A 0.024s 0.8413260018331477A 0.024000000001s 1.7232560984048007A 0.036000000000000004s 1.7232560984048007A 0.036000000001s 1.9022197310766749A 0.048s 1.9022197310766749A 0.048000000001s 2.0562165747385137A 0.06s 2.0562165747385137A 0.060000000000999996s 1.9600042519480656A 0.07200000000000001s 1.9600042519480656A 0.07200000000100001s 0.7188587301611336A 0.084s 0.7188587301611336A 0.08400000000100001s 1.6395134978650285A 0.096s 1.6395134978650285A 0.09600000000100001s 1.8390687766122762A 0.108s 1.8390687766122762A 0.108000000001s 2.0834817999130033A 0.12s 2.0834817999130033A 0.120000000001s 2.1076586446802765A 0.132s 2.1076586446802765A 0.132000000001s 0.6769055279020558A 0.14400000000000002s 0.6769055279020558A 0.14400000000100002s 1.5419069852047687A 0.156s 1.5419069852047687A 0.156000000001s 1.7861866105955706A 0.168s 1.7861866105955706A 0.16800000000100002s 2.053685887523941A 0.18s 2.053685887523941A 0.180000000001s 2.0988572371169156A 0.192s 2.0988572371169156A 0.192000000001s 0.9042872794047062A 0.20400000000000001s 0.9042872794047062A 0.20400000000100002s 1.0488768117647447A 0.216s 1.0488768117647447A 0.216000000001s 1.730176626999384A 0.228s 1.730176626999384A 0.228000000001s 1.935373679414994A 0.24s 1.935373679414994A 0.240000000001s 2.0621386840605647A 0.252s 2.0621386840605647A 0.252000000001s 1.6157370118430052A 0.264s 1.6157370118430052A 0.264000000001s 0.7584485553853091A 0.276s 0.7584485553853091A 0.276000000001s 1.6331475949853422A 0.28800000000000003s 1.6331475949853422A 0.288000000001s 1.9530559132139478A 0.3s 1.9530559132139478A 0.30000000000099997s 1.987500093068492A 0.312s 1.987500093068492A 0.312000000001s 2.1488437955437862A 0.324s 2.1488437955437862A 0.324000000001s 0.5472466320904263A 0.336s 0.5472466320904263A 0.336000000001s 1.5516322579176718A 0.34800000000000003s 1.5516322579176718A 0.348000000001s 1.7934520498541275A 0.36s 1.7934520498541275A 0.36000000000099996s 2.012198267839303A 0.372s 2.012198267839303A 0.372000000001s 2.1657425375037427A 0.384s 2.1657425375037427A 0.384000000001s 0.8096299391003708A 0.396s 0.8096299391003708A 0.396000000001s 0.9448280662839645A 0.40800000000000003s 0.9448280662839645A 0.408000000001s 1.7407016882036357A 0.42s 1.7407016882036357A 0.42000000000099996s 1.9328630434061376A 0.432s 1.9328630434061376A 0.432000000001s 2.0851769606493793A 0.444s 2.0851769606493793A 0.444000000001s 1.6164735544848183A 0.456s 1.6164735544848183A 0.456000000001s 0.7637701414677793A 0.468s 0.7637701414677793A 0.468000000001s 1.6460509162650028A 0.48s 1.6460509162650028A 0.48000000000099996s 1.9404978789963918A 0.492s 1.9404978789963918A 0.49200000000099997s 2.0027455292487653A 0.504s 2.0027455292487653A 0.504000000001s 2.126897749078534A 0.516s 2.126897749078534A 0.516000000001s 0.5991293883283528A 0.528s 0.5991293883283528A 0.528000000001s 1.5402287755737023A 0.54s 1.5402287755737023A 0.540000000001s 1.8716858795049345A 0.552s 1.8716858795049345A 0.552000000001s 1.9705326212986307A 0.5640000000000001s 1.9705326212986307A 0.564000000001s 2.132989241633114A 0.5760000000000001s 2.132989241633114A 0.576000000001s 0.7390702986603922A 0.588s 0.7390702986603922A 0.588000000001s 1.108264469305716A 0.6s 1.108264469305716A 0.600000000001s 1.7963664904155408A 0.612s 1.7963664904155408A 0.612000000001s 1.968847442369588A 0.624s 1.968847442369588A 0.624000000001s 2.045346386251122A 0.636s 2.045346386251122A 0.636000000001s 1.3189231136963462A 0.648s 1.3189231136963462A 0.648000000001s 0.8005499033798368A 0.66s 0.8005499033798368A 0.660000000001s 1.6864374722623647A 0.672s 1.6864374722623647A 0.672000000001s 1.3966087698426253A 0.684s 1.3966087698426253A 0.684000000001s 1.415475514489493A 0.6960000000000001s 1.415475514489493A 0.696000000001s 1.4129373988033307A 0.708s 1.4129373988033307A 0.7080000000009999s 1.396799247190102A 0.72s 1.396799247190102A 0.720000000001s 1.3986634142724903A 0.732s 1.3986634142724903A 0.732000000001s 1.4139072051486719A 0.744s 1.4139072051486719A 0.744000000001s 1.4115695914646673A 0.756s 1.4115695914646673A 0.756000000001s 1.4052944617911987A 0.768s 1.4052944617911987A 0.768000000001s 1.402054671428877A 0.78s 1.402054671428877A 0.780000000001s 1.4045494284969853A 0.792s 1.4045494284969853A 0.792000000001s 1.4146971189305577A 0.804s 1.4146971189305577A 0.804000000001s 0.944208923152885A 0.8160000000000001s 0.944208923152885A 0.816000000001s 1.571259429542755A 0.8280000000000001s 1.571259429542755A 0.828000000001s 1.5750469599859018A 0.84s 1.5750469599859018A 0.840000000001s 1.5731731667845639A 0.852s 1.5731731667845639A 0.852000000001s 1.568235978919965A 0.864s 1.568235978919965A 0.864000000001s 1.5679883338089016A 0.876s 1.5679883338089016A 0.876000000001s 1.5718551764552073A 0.888s 1.5718551764552073A 0.888000000001s 1.5684387846436143A 0.9s 1.5684387846436143A 0.900000000001s 1.5694840362552804A 0.912s 1.5694840362552804A 0.912000000001s 1.570898081595997A 0.924s 1.570898081595997A 0.924000000001s 0.9693923337052324A 0.936s 0.9693923337052324A 0.936000000001s 1.5476066884611268A 0.9480000000000001s 1.5476066884611268A 0.948000000001s 1.542774934850795A 0.96s 1.542774934850795A 0.9600000000009999s 1.5538867546374149A 0.972s 1.5538867546374149A 0.972000000001s 1.5489045627740996A 0.984s 1.5489045627740996A 0.984000000001s 1.5484718420236A 0.996s 1.5484718420236A 0.996000000001s 1.5467376268943274A 1.008s 1.5467376268943274A 1.008000000001s 1.5553536200032936A 1.02s 1.5553536200032936A 1.020000000001s 1.553246168318005A 1.032s 1.553246168318005A 1.0320000000010001s 1.541189512463259A 1.044s 1.541189512463259A 1.0440000000010001s 0.5182243149853255A 1.056s 0.5182243149853255A 1.0560000000010001s 0.4581430598394839A 1.068s 0.4581430598394839A 1.0680000000010001s 1.754083929796774A 1.08s 1.754083929796774A 1.0800000000010002s 1.7602357305653336A 1.092s 1.7602357305653336A 1.0920000000010002s 1.7588197106124532A 1.104s 1.7588197106124532A 1.1040000000010002s 1.7523139665542284A 1.116s 1.7523139665542284A 1.1160000000010002s 1.771164161210552A 1.1280000000000001s 1.771164161210552A 1.1280000000010002s 1.7657435306764824A 1.1400000000000001s 1.7657435306764824A 1.1400000000010002s 1.7591685118038825A 1.1520000000000001s 1.7591685118038825A 1.1520000000010002s 1.7692375891367198A 1.164s 1.7692375891367198A 1.164000000001s 1.7658419304636022A 1.176s 1.7658419304636022A 1.176000000001s 1.424243674712988A 1.188s 1.424243674712988A 1.188000000001s 1.5818609028756954A 1.2s 1.5818609028756954A 1.200000000001s 1.5659682572894962A 1.212s 1.5659682572894962A 1.212000000001s 1.5704955554603592A 1.224s 1.5704955554603592A 1.224000000001s 1.5767383513925874A 1.236s 1.5767383513925874A 1.236000000001s 1.569718270639814A 1.248s 1.569718270639814A 1.248000000001s 1.573739665262186A 1.26s 1.573739665262186A 1.260000000001s 1.570714692560093A 1.272s 1.570714692560093A 1.272000000001s 1.562684038787572A 1.284s 1.562684038787572A 1.2840000000010001s 1.5714563526728618A 1.296s 1.5714563526728618A 1.2960000000010001s 0.9624295157881048A 1.308s 0.9624295157881048A 1.3080000000010001s 1.4040740074076152A 1.32s 1.4040740074076152A 1.3200000000010002s 1.4011759014548086A 1.332s 1.4011759014548086A 1.3320000000010002s 1.401216256953503A 1.344s 1.401216256953503A 1.3440000000010002s 1.4089092988554692A 1.356s 1.4089092988554692A 1.3560000000010002s 1.4115119173935589A 1.368s 1.4115119173935589A 1.3680000000010002s 1.3981710447746418A 1.3800000000000001s 1.3981710447746418A 1.3800000000010002s 1.4048288314681534A 1.3920000000000001s 1.4048288314681534A 1.3920000000010002s 1.4134054151793582A 1.4040000000000001s 1.4134054151793582A 1.4040000000010002s 1.4198757401661093A 1.416s 1.4198757401661093A 1.416000000001s 1.392956675407343A 1.428s 1.392956675407343A 1.428000000001s 0.6846117221513129A 1.44s 0.6846117221513129A 1.440000000001s 0.4713788270569121A 1.452s 0.4713788270569121A 1.452000000001s 0.611961652092039A 1.464s 0.611961652092039A 1.464000000001s 1.7547884431178462A 1.476s 1.7547884431178462A 1.476000000001s 1.760075213756557A 1.488s 1.760075213756557A 1.488000000001s 1.7506917264807746A 1.5s 1.7506917264807746A 1.500000000001s 1.7563051254708626A 1.512s 1.7563051254708626A 1.512000000001s 1.7650606965042943A 1.524s 1.7650606965042943A 1.524000000001s 1.7494082502042299A 1.536s 1.7494082502042299A 1.5360000000010001s 1.7546170660928073A 1.548s 1.7546170660928073A 1.5480000000010001s 1.7580388057610636A 1.56s 1.7580388057610636A 1.5600000000010001s 1.7585110181626398A 1.572s 1.7585110181626398A 1.5720000000010002s 1.4072300846230403A 1.584s 1.4072300846230403A 1.5840000000010002s 1.5736543881717193A 1.596s 1.5736543881717193A 1.5960000000010002s 1.567913587775926A 1.608s 1.567913587775926A 1.6080000000010002s 1.574229813383695A 1.62s 1.574229813383695A 1.6200000000010002s 1.5770127767361255A 1.6320000000000001s 1.5770127767361255A 1.6320000000010002s 1.5699710578729356A 1.6440000000000001s 1.5699710578729356A 1.6440000000010002s 1.5747859864365308A 1.6560000000000001s 1.5747859864365308A 1.6560000000010002s 1.5620471136657725A 1.668s 1.5620471136657725A 1.668000000001s 1.5713178030287962A 1.68s 1.5713178030287962A 1.680000000001s 1.5696661500084363A 1.692s 1.5696661500084363A 1.692000000001s 0.921179861324265A 1.704s 0.921179861324265A 1.704000000001s 1.4037197762278948A 1.716s 1.4037197762278948A 1.716000000001s 1.4087453677443766A 1.728s 1.4087453677443766A 1.728000000001s 1.4165109342279636A 1.74s 1.4165109342279636A 1.740000000001s 1.3959048863210124A 1.752s 1.3959048863210124A 1.752000000001s 1.3944796516488716A 1.764s 1.3944796516488716A 1.764000000001s 1.4034810578592067A 1.776s 1.4034810578592067A 1.7760000000010001s 1.4159028461770868A 1.788s 1.4159028461770868A 1.7880000000010001s 1.4056977695790402A 1.8s 1.4056977695790402A 1.8000000000010001s 1.4038479181934216A 1.812s 1.4038479181934216A 1.8120000000010001s 1.4030027572208328A 1.824s 1.4030027572208328A 1.8240000000010002s 0.461787434768326A 1.836s 0.461787434768326A 1.8360000000010002s 0.4713146943769427A 1.848s 0.4713146943769427A 1.8480000000010002s 1.0627948932388678A 1.86s 1.0627948932388678A 1.8600000000010002s 1.756303233139677A 1.872s 1.756303233139677A 1.8720000000010002s 1.7766830661253974A)
R_0_5_5_1 Node0_5_5 Node0_5_6 9.887809523809517
R_0_5_5_2 Node0_5_5 Node0_6_5 13.020765027322392
R_0_5_5_3 Node0_5_5 Node1_5_5 2.5950185402029633
C_0_5_5 Node0_5_5 GND 0.0009924144753600012
I_0_5_6 GND Node0_5_6 PWL(0s 0A 0.012s 0A 0.012000000001s 3.015062688997774A 0.024s 3.015062688997774A 0.024000000001s 6.467303681802086A 0.036000000000000004s 6.467303681802086A 0.036000000001s 7.1678416978170745A 0.048s 7.1678416978170745A 0.048000000001s 7.770648753643046A 0.06s 7.770648753643046A 0.060000000000999996s 7.3940319904686795A 0.07200000000000001s 7.3940319904686795A 0.07200000000100001s 2.535671170270951A 0.084s 2.535671170270951A 0.08400000000100001s 6.139501167464612A 0.096s 6.139501167464612A 0.09600000000100001s 6.920642085357514A 0.108s 6.920642085357514A 0.108000000001s 7.87737771602662A 0.12s 7.87737771602662A 0.120000000001s 7.9720146577038395A 0.132s 7.9720146577038395A 0.132000000001s 2.3714470248610753A 0.14400000000000002s 2.3714470248610753A 0.14400000000100002s 5.757429679313257A 0.156s 5.757429679313257A 0.156000000001s 6.713639013773414A 0.168s 6.713639013773414A 0.16800000000100002s 7.7607448221133035A 0.18s 7.7607448221133035A 0.180000000001s 7.9375630042365755A 0.192s 7.9375630042365755A 0.192000000001s 3.261508383218924A 0.20400000000000001s 3.261508383218924A 0.20400000000100002s 3.8275039099492227A 0.216s 3.8275039099492227A 0.216000000001s 6.494394580568057A 0.228s 6.494394580568057A 0.228000000001s 7.297620332120007A 0.24s 7.297620332120007A 0.240000000001s 7.793831401566808A 0.252s 7.793831401566808A 0.252000000001s 6.046421338533391A 0.264s 6.046421338533391A 0.264000000001s 2.6906421912661083A 0.276s 2.6906421912661083A 0.276000000001s 6.114584062481048A 0.28800000000000003s 6.114584062481048A 0.288000000001s 7.366837721680634A 0.3s 7.366837721680634A 0.30000000000099997s 7.501663227202117A 0.312s 7.501663227202117A 0.312000000001s 8.133231397982392A 0.324s 8.133231397982392A 0.324000000001s 1.863904793293624A 0.336s 1.863904793293624A 0.336000000001s 5.79550049162261A 0.34800000000000003s 5.79550049162261A 0.348000000001s 6.742079586534188A 0.36s 6.742079586534188A 0.36000000000099996s 7.598344543823708A 0.372s 7.598344543823708A 0.372000000001s 8.199380941745433A 0.384s 8.199380941745433A 0.384000000001s 2.8909798761238994A 0.396s 2.8909798761238994A 0.396000000001s 3.420213324837314A 0.40800000000000003s 3.420213324837314A 0.408000000001s 6.535593827800739A 0.42s 6.535593827800739A 0.42000000000099996s 7.28779260186074A 0.432s 7.28779260186074A 0.432000000001s 7.884013318481312A 0.444s 7.884013318481312A 0.444000000001s 6.049302659056405A 0.456s 6.049302659056405A 0.456000000001s 2.711473670310863A 0.468s 2.711473670310863A 0.468000000001s 6.165092862522281A 0.48s 6.165092862522281A 0.48000000000099996s 7.317680069021538A 0.492s 7.317680069021538A 0.49200000000099997s 7.561340549576236A 0.504s 7.561340549576236A 0.504000000001s 8.047324948717339A 0.516s 8.047324948717339A 0.516000000001s 2.0669961943479613A 0.528s 2.0669961943479613A 0.528000000001s 5.750863176447297A 0.54s 5.750863176447297A 0.540000000001s 7.048320643942689A 0.552s 7.048320643942689A 0.552000000001s 7.435247390354344A 0.5640000000000001s 7.435247390354344A 0.564000000001s 8.071171094476462A 0.5760000000000001s 8.071171094476462A 0.576000000001s 2.6147762149096274A 0.588s 2.6147762149096274A 0.588000000001s 4.059973243211207A 0.6s 4.059973243211207A 0.600000000001s 6.753491187999221A 0.612s 6.753491187999221A 0.612000000001s 7.428651776247086A 0.624s 7.428651776247086A 0.624000000001s 7.72809898447316A 0.636s 7.72809898447316A 0.636000000001s 4.884562960264136A 0.648s 4.884562960264136A 0.648000000001s 2.855444871282115A 0.66s 2.855444871282115A 0.660000000001s 6.323184925073467A 0.672s 6.323184925073467A 0.672000000001s 5.188692545318397A 0.684s 5.188692545318397A 0.684000000001s 5.262548002513654A 0.6960000000000001s 5.262548002513654A 0.696000000001s 5.2526127047475A 0.708s 5.2526127047475A 0.7080000000009999s 5.1894409027106905A 0.72s 5.1894409027106905A 0.720000000001s 5.196738070113408A 0.732s 5.196738070113408A 0.732000000001s 5.256408952045841A 0.744s 5.256408952045841A 0.744000000001s 5.247258507036797A 0.756s 5.247258507036797A 0.756000000001s 5.222694897833699A 0.768s 5.222694897833699A 0.768000000001s 5.210012937698837A 0.78s 5.210012937698837A 0.780000000001s 5.219778510821058A 0.792s 5.219778510821058A 0.792000000001s 5.2595010209674475A 0.804s 5.2595010209674475A 0.804000000001s 3.4178039123618023A 0.8160000000000001s 3.4178039123618023A 0.816000000001s 5.872354557695406A 0.8280000000000001s 5.872354557695406A 0.828000000001s 5.8871806126921085A 0.84s 5.8871806126921085A 0.840000000001s 5.879845764438742A 0.852s 5.879845764438742A 0.852000000001s 5.860519446166622A 0.864s 5.860519446166622A 0.864000000001s 5.859550054608877A 0.876s 5.859550054608877A 0.876000000001s 5.874686572347358A 0.888s 5.874686572347358A 0.888000000001s 5.861313316699838A 0.9s 5.861313316699838A 0.900000000001s 5.865404889853525A 0.912s 5.865404889853525A 0.912000000001s 5.870940083379753A 0.924s 5.870940083379753A 0.924000000001s 3.516382824256553A 0.936s 3.516382824256553A 0.936000000001s 5.779767357311705A 0.9480000000000001s 5.779767357311705A 0.948000000001s 5.76085375494399A 0.96s 5.76085375494399A 0.9600000000009999s 5.804350290151508A 0.972s 5.804350290151508A 0.972000000001s 5.784847806494038A 0.984s 5.784847806494038A 0.984000000001s 5.783153947727376A 0.996s 5.783153947727376A 0.996000000001s 5.776365469253432A 1.008s 5.776365469253432A 1.008000000001s 5.810092244417942A 1.02s 5.810092244417942A 1.020000000001s 5.801842754398524A 1.032s 5.801842754398524A 1.0320000000010001s 5.754647716507218A 1.044s 5.754647716507218A 1.0440000000010001s 1.750313360604302A 1.056s 1.750313360604302A 1.0560000000010001s 1.515128982172452A 1.068s 1.515128982172452A 1.0680000000010001s 6.588009363133589A 1.08s 6.588009363133589A 1.0800000000010002s 6.612090208922818A 1.092s 6.612090208922818A 1.0920000000010002s 6.606547285898708A 1.104s 6.606547285898708A 1.1040000000010002s 6.581080950868653A 1.116s 6.581080950868653A 1.1160000000010002s 6.654868878614261A 1.1280000000000001s 6.654868878614261A 1.1280000000010002s 6.63365015374293A 1.1400000000000001s 6.63365015374293A 1.1400000000010002s 6.607912646712217A 1.1520000000000001s 6.607912646712217A 1.1520000000010002s 6.647327430710276A 1.164s 6.647327430710276A 1.164000000001s 6.634035333658286A 1.176s 6.634035333658286A 1.176000000001s 5.296870426490116A 1.188s 5.296870426490116A 1.188000000001s 5.913853373094936A 1.2s 5.913853373094936A 1.200000000001s 5.85164258930297A 1.212s 5.85164258930297A 1.212000000001s 5.869364419576081A 1.224s 5.869364419576081A 1.224000000001s 5.893801460337531A 1.236s 5.893801460337531A 1.236000000001s 5.866321785946995A 1.248s 5.866321785946995A 1.248000000001s 5.8820632878912535A 1.26s 5.8820632878912535A 1.260000000001s 5.870222218276643A 1.272s 5.870222218276643A 1.272000000001s 5.838786717947843A 1.284s 5.838786717947843A 1.2840000000010001s 5.873125401177963A 1.296s 5.873125401177963A 1.2960000000010001s 3.4891273017146416A 1.308s 3.4891273017146416A 1.3080000000010001s 5.217917504203845A 1.32s 5.217917504203845A 1.3200000000010002s 5.20657304667735A 1.332s 5.20657304667735A 1.3320000000010002s 5.206731015795233A 1.344s 5.206731015795233A 1.3440000000010002s 5.236844955218973A 1.356s 5.236844955218973A 1.3560000000010002s 5.247032745432244A 1.368s 5.247032745432244A 1.3680000000010002s 5.194810719993489A 1.3800000000000001s 5.194810719993489A 1.3800000000010002s 5.220872216569159A 1.3920000000000001s 5.220872216569159A 1.3920000000010002s 5.254444726069705A 1.4040000000000001s 5.254444726069705A 1.4040000000010002s 5.279772415322654A 1.416s 5.279772415322654A 1.416000000001s 5.174399391774971A 1.428s 5.174399391774971A 1.428000000001s 2.4016266335749035A 1.44s 2.4016266335749035A 1.440000000001s 1.5669395789807805A 1.452s 1.5669395789807805A 1.452000000001s 2.1172424021129332A 1.464s 2.1172424021129332A 1.464000000001s 6.590767137203241A 1.476s 6.590767137203241A 1.476000000001s 6.611461875746216A 1.488s 6.611461875746216A 1.488000000001s 6.574730791864544A 1.5s 6.574730791864544A 1.500000000001s 6.596704097002216A 1.512s 6.596704097002216A 1.512000000001s 6.630977241368376A 1.524s 6.630977241368376A 1.524000000001s 6.569706702910368A 1.536s 6.569706702910368A 1.5360000000010001s 6.5900962923779565A 1.548s 6.5900962923779565A 1.5480000000010001s 6.603490481881504A 1.56s 6.603490481881504A 1.5600000000010001s 6.605338928287675A 1.572s 6.605338928287675A 1.5720000000010002s 5.230271774373315A 1.584s 5.230271774373315A 1.5840000000010002s 5.881729475964933A 1.596s 5.881729475964933A 1.5960000000010002s 5.859257465859476A 1.608s 5.859257465859476A 1.6080000000010002s 5.8839819425701005A 1.62s 5.8839819425701005A 1.6200000000010002s 5.894875681468386A 1.6320000000000001s 5.894875681468386A 1.6320000000010002s 5.86731130602531A 1.6440000000000001s 5.86731130602531A 1.6440000000010002s 5.886159047782271A 1.6560000000000001s 5.886159047782271A 1.6560000000010002s 5.836293513727753A 1.668s 5.836293513727753A 1.668000000001s 5.8725830571166995A 1.68s 5.8725830571166995A 1.680000000001s 5.866117762940746A 1.692s 5.866117762940746A 1.692000000001s 3.327658066059398A 1.704s 3.327658066059398A 1.704000000001s 5.2165308880350985A 1.716s 5.2165308880350985A 1.716000000001s 5.236203256965926A 1.728s 5.236203256965926A 1.728000000001s 5.266601089404352A 1.74s 5.266601089404352A 1.740000000001s 5.185939982089441A 1.752s 5.185939982089441A 1.752000000001s 5.180360988613467A 1.764s 5.180360988613467A 1.764000000001s 5.215596439661411A 1.776s 5.215596439661411A 1.7760000000010001s 5.264220766124984A 1.788s 5.264220766124984A 1.7880000000010001s 5.224273621366856A 1.8s 5.224273621366856A 1.8000000000010001s 5.217032491878766A 1.812s 5.217032491878766A 1.8120000000010001s 5.213724161226706A 1.824s 5.213724161226706A 1.8240000000010002s 1.5293946637120905A 1.836s 1.5293946637120905A 1.8360000000010002s 1.5666885355490285A 1.848s 1.5666885355490285A 1.8480000000010002s 3.882001399543296A 1.86s 3.882001399543296A 1.8600000000010002s 6.596696689588162A 1.872s 6.596696689588162A 1.8720000000010002s 6.676471834917287A)
R_0_5_6_1 Node0_5_6 Node0_5_7 9.887809523809524
R_0_5_6_2 Node0_5_6 Node0_6_6 13.020765027322408
R_0_5_6_3 Node0_5_6 Node1_5_6 2.595018540202966
C_0_5_6 Node0_5_6 GND 0.0009924144753600001
I_0_5_7 GND Node0_5_7 PWL(0s 0A 0.012s 0A 0.012000000001s 3.015062688997774A 0.024s 3.015062688997774A 0.024000000001s 6.467303681802086A 0.036000000000000004s 6.467303681802086A 0.036000000001s 7.1678416978170745A 0.048s 7.1678416978170745A 0.048000000001s 7.770648753643046A 0.06s 7.770648753643046A 0.060000000000999996s 7.3940319904686795A 0.07200000000000001s 7.3940319904686795A 0.07200000000100001s 2.535671170270951A 0.084s 2.535671170270951A 0.08400000000100001s 6.139501167464612A 0.096s 6.139501167464612A 0.09600000000100001s 6.920642085357514A 0.108s 6.920642085357514A 0.108000000001s 7.87737771602662A 0.12s 7.87737771602662A 0.120000000001s 7.9720146577038395A 0.132s 7.9720146577038395A 0.132000000001s 2.3714470248610753A 0.14400000000000002s 2.3714470248610753A 0.14400000000100002s 5.757429679313257A 0.156s 5.757429679313257A 0.156000000001s 6.713639013773414A 0.168s 6.713639013773414A 0.16800000000100002s 7.7607448221133035A 0.18s 7.7607448221133035A 0.180000000001s 7.9375630042365755A 0.192s 7.9375630042365755A 0.192000000001s 3.261508383218924A 0.20400000000000001s 3.261508383218924A 0.20400000000100002s 3.8275039099492227A 0.216s 3.8275039099492227A 0.216000000001s 6.494394580568057A 0.228s 6.494394580568057A 0.228000000001s 7.297620332120007A 0.24s 7.297620332120007A 0.240000000001s 7.793831401566808A 0.252s 7.793831401566808A 0.252000000001s 6.046421338533391A 0.264s 6.046421338533391A 0.264000000001s 2.6906421912661083A 0.276s 2.6906421912661083A 0.276000000001s 6.114584062481048A 0.28800000000000003s 6.114584062481048A 0.288000000001s 7.366837721680634A 0.3s 7.366837721680634A 0.30000000000099997s 7.501663227202117A 0.312s 7.501663227202117A 0.312000000001s 8.133231397982392A 0.324s 8.133231397982392A 0.324000000001s 1.863904793293624A 0.336s 1.863904793293624A 0.336000000001s 5.79550049162261A 0.34800000000000003s 5.79550049162261A 0.348000000001s 6.742079586534188A 0.36s 6.742079586534188A 0.36000000000099996s 7.598344543823708A 0.372s 7.598344543823708A 0.372000000001s 8.199380941745433A 0.384s 8.199380941745433A 0.384000000001s 2.8909798761238994A 0.396s 2.8909798761238994A 0.396000000001s 3.420213324837314A 0.40800000000000003s 3.420213324837314A 0.408000000001s 6.535593827800739A 0.42s 6.535593827800739A 0.42000000000099996s 7.28779260186074A 0.432s 7.28779260186074A 0.432000000001s 7.884013318481312A 0.444s 7.884013318481312A 0.444000000001s 6.049302659056405A 0.456s 6.049302659056405A 0.456000000001s 2.711473670310863A 0.468s 2.711473670310863A 0.468000000001s 6.165092862522281A 0.48s 6.165092862522281A 0.48000000000099996s 7.317680069021538A 0.492s 7.317680069021538A 0.49200000000099997s 7.561340549576236A 0.504s 7.561340549576236A 0.504000000001s 8.047324948717339A 0.516s 8.047324948717339A 0.516000000001s 2.0669961943479613A 0.528s 2.0669961943479613A 0.528000000001s 5.750863176447297A 0.54s 5.750863176447297A 0.540000000001s 7.048320643942689A 0.552s 7.048320643942689A 0.552000000001s 7.435247390354344A 0.5640000000000001s 7.435247390354344A 0.564000000001s 8.071171094476462A 0.5760000000000001s 8.071171094476462A 0.576000000001s 2.6147762149096274A 0.588s 2.6147762149096274A 0.588000000001s 4.059973243211207A 0.6s 4.059973243211207A 0.600000000001s 6.753491187999221A 0.612s 6.753491187999221A 0.612000000001s 7.428651776247086A 0.624s 7.428651776247086A 0.624000000001s 7.72809898447316A 0.636s 7.72809898447316A 0.636000000001s 4.884562960264136A 0.648s 4.884562960264136A 0.648000000001s 2.855444871282115A 0.66s 2.855444871282115A 0.660000000001s 6.323184925073467A 0.672s 6.323184925073467A 0.672000000001s 5.188692545318397A 0.684s 5.188692545318397A 0.684000000001s 5.262548002513654A 0.6960000000000001s 5.262548002513654A 0.696000000001s 5.2526127047475A 0.708s 5.2526127047475A 0.7080000000009999s 5.1894409027106905A 0.72s 5.1894409027106905A 0.720000000001s 5.196738070113408A 0.732s 5.196738070113408A 0.732000000001s 5.256408952045841A 0.744s 5.256408952045841A 0.744000000001s 5.247258507036797A 0.756s 5.247258507036797A 0.756000000001s 5.222694897833699A 0.768s 5.222694897833699A 0.768000000001s 5.210012937698837A 0.78s 5.210012937698837A 0.780000000001s 5.219778510821058A 0.792s 5.219778510821058A 0.792000000001s 5.2595010209674475A 0.804s 5.2595010209674475A 0.804000000001s 3.4178039123618023A 0.8160000000000001s 3.4178039123618023A 0.816000000001s 5.872354557695406A 0.8280000000000001s 5.872354557695406A 0.828000000001s 5.8871806126921085A 0.84s 5.8871806126921085A 0.840000000001s 5.879845764438742A 0.852s 5.879845764438742A 0.852000000001s 5.860519446166622A 0.864s 5.860519446166622A 0.864000000001s 5.859550054608877A 0.876s 5.859550054608877A 0.876000000001s 5.874686572347358A 0.888s 5.874686572347358A 0.888000000001s 5.861313316699838A 0.9s 5.861313316699838A 0.900000000001s 5.865404889853525A 0.912s 5.865404889853525A 0.912000000001s 5.870940083379753A 0.924s 5.870940083379753A 0.924000000001s 3.516382824256553A 0.936s 3.516382824256553A 0.936000000001s 5.779767357311705A 0.9480000000000001s 5.779767357311705A 0.948000000001s 5.76085375494399A 0.96s 5.76085375494399A 0.9600000000009999s 5.804350290151508A 0.972s 5.804350290151508A 0.972000000001s 5.784847806494038A 0.984s 5.784847806494038A 0.984000000001s 5.783153947727376A 0.996s 5.783153947727376A 0.996000000001s 5.776365469253432A 1.008s 5.776365469253432A 1.008000000001s 5.810092244417942A 1.02s 5.810092244417942A 1.020000000001s 5.801842754398524A 1.032s 5.801842754398524A 1.0320000000010001s 5.754647716507218A 1.044s 5.754647716507218A 1.0440000000010001s 1.750313360604302A 1.056s 1.750313360604302A 1.0560000000010001s 1.515128982172452A 1.068s 1.515128982172452A 1.0680000000010001s 6.588009363133589A 1.08s 6.588009363133589A 1.0800000000010002s 6.612090208922818A 1.092s 6.612090208922818A 1.0920000000010002s 6.606547285898708A 1.104s 6.606547285898708A 1.1040000000010002s 6.581080950868653A 1.116s 6.581080950868653A 1.1160000000010002s 6.654868878614261A 1.1280000000000001s 6.654868878614261A 1.1280000000010002s 6.63365015374293A 1.1400000000000001s 6.63365015374293A 1.1400000000010002s 6.607912646712217A 1.1520000000000001s 6.607912646712217A 1.1520000000010002s 6.647327430710276A 1.164s 6.647327430710276A 1.164000000001s 6.634035333658286A 1.176s 6.634035333658286A 1.176000000001s 5.296870426490116A 1.188s 5.296870426490116A 1.188000000001s 5.913853373094936A 1.2s 5.913853373094936A 1.200000000001s 5.85164258930297A 1.212s 5.85164258930297A 1.212000000001s 5.869364419576081A 1.224s 5.869364419576081A 1.224000000001s 5.893801460337531A 1.236s 5.893801460337531A 1.236000000001s 5.866321785946995A 1.248s 5.866321785946995A 1.248000000001s 5.8820632878912535A 1.26s 5.8820632878912535A 1.260000000001s 5.870222218276643A 1.272s 5.870222218276643A 1.272000000001s 5.838786717947843A 1.284s 5.838786717947843A 1.2840000000010001s 5.873125401177963A 1.296s 5.873125401177963A 1.2960000000010001s 3.4891273017146416A 1.308s 3.4891273017146416A 1.3080000000010001s 5.217917504203845A 1.32s 5.217917504203845A 1.3200000000010002s 5.20657304667735A 1.332s 5.20657304667735A 1.3320000000010002s 5.206731015795233A 1.344s 5.206731015795233A 1.3440000000010002s 5.236844955218973A 1.356s 5.236844955218973A 1.3560000000010002s 5.247032745432244A 1.368s 5.247032745432244A 1.3680000000010002s 5.194810719993489A 1.3800000000000001s 5.194810719993489A 1.3800000000010002s 5.220872216569159A 1.3920000000000001s 5.220872216569159A 1.3920000000010002s 5.254444726069705A 1.4040000000000001s 5.254444726069705A 1.4040000000010002s 5.279772415322654A 1.416s 5.279772415322654A 1.416000000001s 5.174399391774971A 1.428s 5.174399391774971A 1.428000000001s 2.4016266335749035A 1.44s 2.4016266335749035A 1.440000000001s 1.5669395789807805A 1.452s 1.5669395789807805A 1.452000000001s 2.1172424021129332A 1.464s 2.1172424021129332A 1.464000000001s 6.590767137203241A 1.476s 6.590767137203241A 1.476000000001s 6.611461875746216A 1.488s 6.611461875746216A 1.488000000001s 6.574730791864544A 1.5s 6.574730791864544A 1.500000000001s 6.596704097002216A 1.512s 6.596704097002216A 1.512000000001s 6.630977241368376A 1.524s 6.630977241368376A 1.524000000001s 6.569706702910368A 1.536s 6.569706702910368A 1.5360000000010001s 6.5900962923779565A 1.548s 6.5900962923779565A 1.5480000000010001s 6.603490481881504A 1.56s 6.603490481881504A 1.5600000000010001s 6.605338928287675A 1.572s 6.605338928287675A 1.5720000000010002s 5.230271774373315A 1.584s 5.230271774373315A 1.5840000000010002s 5.881729475964933A 1.596s 5.881729475964933A 1.5960000000010002s 5.859257465859476A 1.608s 5.859257465859476A 1.6080000000010002s 5.8839819425701005A 1.62s 5.8839819425701005A 1.6200000000010002s 5.894875681468386A 1.6320000000000001s 5.894875681468386A 1.6320000000010002s 5.86731130602531A 1.6440000000000001s 5.86731130602531A 1.6440000000010002s 5.886159047782271A 1.6560000000000001s 5.886159047782271A 1.6560000000010002s 5.836293513727753A 1.668s 5.836293513727753A 1.668000000001s 5.8725830571166995A 1.68s 5.8725830571166995A 1.680000000001s 5.866117762940746A 1.692s 5.866117762940746A 1.692000000001s 3.327658066059398A 1.704s 3.327658066059398A 1.704000000001s 5.2165308880350985A 1.716s 5.2165308880350985A 1.716000000001s 5.236203256965926A 1.728s 5.236203256965926A 1.728000000001s 5.266601089404352A 1.74s 5.266601089404352A 1.740000000001s 5.185939982089441A 1.752s 5.185939982089441A 1.752000000001s 5.180360988613467A 1.764s 5.180360988613467A 1.764000000001s 5.215596439661411A 1.776s 5.215596439661411A 1.7760000000010001s 5.264220766124984A 1.788s 5.264220766124984A 1.7880000000010001s 5.224273621366856A 1.8s 5.224273621366856A 1.8000000000010001s 5.217032491878766A 1.812s 5.217032491878766A 1.8120000000010001s 5.213724161226706A 1.824s 5.213724161226706A 1.8240000000010002s 1.5293946637120905A 1.836s 1.5293946637120905A 1.8360000000010002s 1.5666885355490285A 1.848s 1.5666885355490285A 1.8480000000010002s 3.882001399543296A 1.86s 3.882001399543296A 1.8600000000010002s 6.596696689588162A 1.872s 6.596696689588162A 1.8720000000010002s 6.676471834917287A)
R_0_5_7_1 Node0_5_7 Node0_5_8 9.88780952380953
R_0_5_7_2 Node0_5_7 Node0_6_7 13.020765027322408
R_0_5_7_3 Node0_5_7 Node1_5_7 2.595018540202966
C_0_5_7 Node0_5_7 GND 0.0009924144753600001
I_0_5_8 GND Node0_5_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.5931270863602145A 0.024s 0.5931270863602145A 0.024000000001s 1.2722564619938457A 0.036000000000000004s 1.2722564619938457A 0.036000000001s 1.410067219242695A 0.048s 1.410067219242695A 0.048000000001s 1.52865221383141A 0.06s 1.52865221383141A 0.060000000000999996s 1.4545636702561253A 0.07200000000000001s 1.4545636702561253A 0.07200000000100001s 0.49882055808608583A 0.084s 0.49882055808608583A 0.08400000000100001s 1.2077707214684414A 0.096s 1.2077707214684414A 0.09600000000100001s 1.3614377872834376A 0.108s 1.3614377872834376A 0.108000000001s 1.5496480752839166A 0.12s 1.5496480752839166A 0.120000000001s 1.5682651785646808A 0.132s 1.5682651785646808A 0.132000000001s 0.4665141688251269A 0.14400000000000002s 0.4665141688251269A 0.14400000000100002s 1.132609117241946A 0.156s 1.132609117241946A 0.156000000001s 1.3207158715619753A 0.168s 1.3207158715619753A 0.16800000000100002s 1.5267038994321165A 0.18s 1.5267038994321165A 0.180000000001s 1.5614878041121043A 0.192s 1.5614878041121043A 0.192000000001s 0.6416082065348666A 0.20400000000000001s 0.6416082065348666A 0.20400000000100002s 0.7529515888424658A 0.216s 0.7529515888424658A 0.216000000001s 1.277585819128135A 0.228s 1.277585819128135A 0.228000000001s 1.4355974423842555A 0.24s 1.4355974423842555A 0.240000000001s 1.5332127347344455A 0.252s 1.5332127347344455A 0.252000000001s 1.189459935449185A 0.264s 1.189459935449185A 0.264000000001s 0.5293066605769363A 0.276s 0.5293066605769363A 0.276000000001s 1.2028689958979044A 0.28800000000000003s 1.2028689958979044A 0.288000000001s 1.4492139780355262A 0.3s 1.4492139780355262A 0.30000000000099997s 1.4757370283020477A 0.312s 1.4757370283020477A 0.312000000001s 1.5999799471440677A 0.324s 1.5999799471440677A 0.324000000001s 0.36666979540202227A 0.336s 0.36666979540202227A 0.336000000001s 1.140098457368376A 0.34800000000000003s 1.140098457368376A 0.348000000001s 1.3263107383345867A 0.36s 1.3263107383345867A 0.36000000000099996s 1.494756303703016A 0.372s 1.494756303703016A 0.372000000001s 1.6129929721466338A 0.384s 1.6129929721466338A 0.384000000001s 0.568717352680108A 0.396s 0.568717352680108A 0.396000000001s 0.6728288507876645A 0.40800000000000003s 0.6728288507876645A 0.408000000001s 1.2856905890755477A 0.42s 1.2856905890755477A 0.42000000000099996s 1.433664118398826A 0.432s 1.433664118398826A 0.432000000001s 1.550953439701233A 0.444s 1.550953439701233A 0.444000000001s 1.1900267526012531A 0.456s 1.1900267526012531A 0.456000000001s 0.5334046564545929A 0.468s 0.5334046564545929A 0.468000000001s 1.2128051532830646A 0.48s 1.2128051532830646A 0.48000000000099996s 1.4395436201353762A 0.492s 1.4395436201353762A 0.49200000000099997s 1.4874768294248248A 0.504s 1.4874768294248248A 0.504000000001s 1.583080317780451A 0.516s 1.583080317780451A 0.516000000001s 0.4066222021668097A 0.528s 0.4066222021668097A 0.528000000001s 1.1313173461863468A 0.54s 1.1313173461863468A 0.540000000001s 1.386554880775603A 0.552s 1.386554880775603A 0.552000000001s 1.4626716177746166A 0.5640000000000001s 1.4626716177746166A 0.564000000001s 1.5877713628478194A 0.5760000000000001s 1.5877713628478194A 0.576000000001s 0.5143822062117269A 0.588s 0.5143822062117269A 0.588000000001s 0.7986832609595771A 0.6s 0.7986832609595771A 0.600000000001s 1.3285556435408228A 0.612s 1.3285556435408228A 0.612000000001s 1.4613741199174513A 0.624s 1.4613741199174513A 0.624000000001s 1.5202817674373343A 0.636s 1.5202817674373343A 0.636000000001s 0.9608976315273655A 0.648s 0.9608976315273655A 0.648000000001s 0.5617268599243472A 0.66s 0.5617268599243472A 0.660000000001s 1.2439052311619865A 0.672s 1.2439052311619865A 0.672000000001s 1.0207264023577116A 0.684s 1.0207264023577116A 0.684000000001s 1.0352553447567785A 0.6960000000000001s 1.0352553447567785A 0.696000000001s 1.0333008599503222A 0.708s 1.0333008599503222A 0.7080000000009999s 1.0208736202053759A 0.72s 1.0208736202053759A 0.720000000001s 1.0223091285468942A 0.732s 1.0223091285468942A 0.732000000001s 1.0340476626975366A 0.744s 1.0340476626975366A 0.744000000001s 1.0322475751547737A 0.756s 1.0322475751547737A 0.756000000001s 1.027415389737771A 0.768s 1.027415389737771A 0.768000000001s 1.0249205779079622A 0.78s 1.0249205779079622A 0.780000000001s 1.0268416742598743A 0.792s 1.0268416742598743A 0.792000000001s 1.0346559385509675A 0.804s 1.0346559385509675A 0.804000000001s 0.6723548680055966A 0.8160000000000001s 0.6723548680055966A 0.816000000001s 1.1552172900384339A 0.8280000000000001s 1.1552172900384339A 0.828000000001s 1.1581338910213919A 0.84s 1.1581338910213919A 0.840000000001s 1.1566909700535166A 0.852s 1.1566909700535166A 0.852000000001s 1.152889071377034A 0.864s 1.152889071377034A 0.864000000001s 1.152698371398461A 0.876s 1.152698371398461A 0.876000000001s 1.1556760470191456A 0.888s 1.1556760470191456A 0.888000000001s 1.1530452426294697A 0.9s 1.1530452426294697A 0.900000000001s 1.1538501422662606A 0.912s 1.1538501422662606A 0.912000000001s 1.1549390327960105A 0.924s 1.1549390327960105A 0.924000000001s 0.6917474408373507A 0.936s 0.6917474408373507A 0.936000000001s 1.137003414553116A 0.9480000000000001s 1.137003414553116A 0.948000000001s 1.1332827058906145A 0.96s 1.1332827058906145A 0.9600000000009999s 1.1418394013412736A 0.972s 1.1418394013412736A 0.972000000001s 1.1380028471791486A 0.984s 1.1380028471791486A 0.984000000001s 1.1376696290611166A 0.996s 1.1376696290611166A 0.996000000001s 1.1363341906727997A 1.008s 1.1363341906727997A 1.008000000001s 1.1429689661149984A 1.02s 1.1429689661149984A 1.020000000001s 1.1413461156193752A 1.032s 1.1413461156193752A 1.0320000000010001s 1.132061845870266A 1.044s 1.132061845870266A 1.0440000000010001s 0.3443239397910083A 1.056s 0.3443239397910083A 1.0560000000010001s 0.2980581604273659A 1.068s 0.2980581604273659A 1.0680000000010001s 1.2960018419279118A 1.08s 1.2960018419279118A 1.0800000000010002s 1.3007390574930058A 1.092s 1.3007390574930058A 1.0920000000010002s 1.299648646406296A 1.104s 1.299648646406296A 1.1040000000010002s 1.2946388755807112A 1.116s 1.2946388755807112A 1.1160000000010002s 1.3091545334978798A 1.1280000000000001s 1.3091545334978798A 1.1280000000010002s 1.3049803581133559A 1.1400000000000001s 1.3049803581133559A 1.1400000000010002s 1.2999172419761664A 1.1520000000000001s 1.2999172419761664A 1.1520000000010002s 1.3076709699757845A 1.164s 1.3076709699757845A 1.164000000001s 1.3050561312114586A 1.176s 1.3050561312114586A 1.176000000001s 1.0420072970144432A 1.188s 1.0420072970144432A 1.188000000001s 1.1633809914285056A 1.2s 1.1633809914285056A 1.200000000001s 1.1511428044530367A 1.212s 1.1511428044530367A 1.212000000001s 1.1546290661461076A 1.224s 1.1546290661461076A 1.224000000001s 1.159436352853278A 1.236s 1.159436352853278A 1.236000000001s 1.1540305152682546A 1.248s 1.1540305152682546A 1.248000000001s 1.1571272041753218A 1.26s 1.1571272041753218A 1.260000000001s 1.1547978134314643A 1.272s 1.1547978134314643A 1.272000000001s 1.1486137805798973A 1.284s 1.1486137805798973A 1.2840000000010001s 1.1553689313792648A 1.296s 1.1553689313792648A 1.2960000000010001s 0.6863856986979584A 1.308s 0.6863856986979584A 1.3080000000010001s 1.0264755745974716A 1.32s 1.0264755745974716A 1.3200000000010002s 1.0242438780348826A 1.332s 1.0242438780348826A 1.3320000000010002s 1.0242749539269251A 1.344s 1.0242749539269251A 1.3440000000010002s 1.0301990075840544A 1.356s 1.0301990075840544A 1.3560000000010002s 1.0322031630358453A 1.368s 1.0322031630358453A 1.3680000000010002s 1.0219299777036313A 1.3800000000000001s 1.0219299777036313A 1.3800000000010002s 1.0270568294890092A 1.3920000000000001s 1.0270568294890092A 1.3920000000010002s 1.0336612575874768A 1.4040000000000001s 1.0336612575874768A 1.4040000000010002s 1.0386437538339588A 1.416s 1.0386437538339588A 1.416000000001s 1.0179146344475294A 1.428s 1.0179146344475294A 1.428000000001s 0.47245114103112584A 1.44s 0.47245114103112584A 1.440000000001s 0.3082504089798239A 1.452s 0.3082504089798239A 1.452000000001s 0.4165067020550009A 1.464s 0.4165067020550009A 1.464000000001s 1.2965443548596465A 1.476s 1.2965443548596465A 1.476000000001s 1.3006154509664611A 1.488s 1.3006154509664611A 1.488000000001s 1.2933896639733455A 1.5s 1.2933896639733455A 1.500000000001s 1.2977122813774775A 1.512s 1.2977122813774775A 1.512000000001s 1.3044545392855746A 1.524s 1.3044545392855746A 1.524000000001s 1.2924013186053112A 1.536s 1.2924013186053112A 1.5360000000010001s 1.29641238538582A 1.548s 1.29641238538582A 1.5480000000010001s 1.2990473079111082A 1.56s 1.2990473079111082A 1.5600000000010001s 1.2994109367123219A 1.572s 1.2994109367123219A 1.5720000000010002s 1.0289059228275317A 1.584s 1.0289059228275317A 1.5840000000010002s 1.1570615362553902A 1.596s 1.1570615362553902A 1.5960000000010002s 1.1526408129559558A 1.608s 1.1526408129559558A 1.6080000000010002s 1.1575046444400132A 1.62s 1.1575046444400132A 1.6200000000010002s 1.1596476750429543A 1.6320000000000001s 1.1596476750429543A 1.6320000000010002s 1.154225174955792A 1.6440000000000001s 1.154225174955792A 1.6440000000010002s 1.1579329274325714A 1.6560000000000001s 1.1579329274325714A 1.6560000000010002s 1.1481233141759448A 1.668s 1.1481233141759448A 1.668000000001s 1.155262240744262A 1.68s 1.155262240744262A 1.680000000001s 1.1539903795948943A 1.692s 1.1539903795948943A 1.692000000001s 0.654621258896927A 1.704s 0.654621258896927A 1.704000000001s 1.0262027976462431A 1.716s 1.0262027976462431A 1.716000000001s 1.0300727718621434A 1.728s 1.0300727718621434A 1.728000000001s 1.0360526733254405A 1.74s 1.0360526733254405A 1.740000000001s 1.0201849145093924A 1.752s 1.0201849145093924A 1.752000000001s 1.019087407596086A 1.764s 1.019087407596086A 1.764000000001s 1.0260189717366652A 1.776s 1.0260189717366652A 1.7760000000010001s 1.0355844130081877A 1.788s 1.0355844130081877A 1.7880000000010001s 1.0277259583016707A 1.8s 1.0277259583016707A 1.8000000000010001s 1.02630147381221A 1.812s 1.02630147381221A 1.8120000000010001s 1.0256506546675428A 1.824s 1.0256506546675428A 1.8240000000010002s 0.30086452400893415A 1.836s 0.30086452400893415A 1.8360000000010002s 0.3082010233866924A 1.848s 0.3082010233866924A 1.8480000000010002s 0.7636724064675293A 1.86s 0.7636724064675293A 1.8600000000010002s 1.2977108241812705A 1.872s 1.2977108241812705A 1.8720000000010002s 1.3134042953935572A)
R_0_5_8_1 Node0_5_8 Node0_5_9 9.88780952380953
R_0_5_8_2 Node0_5_8 Node0_6_8 13.02076502732242
R_0_5_8_3 Node0_5_8 Node1_5_8 2.595018540202969
C_0_5_8 Node0_5_8 GND 0.0009924144753599988
R_0_5_9_2 Node0_5_9 Node0_6_9 13.020765027322408
R_0_5_9_3 Node0_5_9 Node1_5_9 2.595018540202966
C_0_5_9 Node0_5_9 GND 0.0009924144753600001
I_0_6_0 GND Node0_6_0 PWL(0s 0A 0.012s 0A 0.012000000001s 5.859660821872725A 0.024s 5.859660821872725A 0.024000000001s 13.370523835063214A 0.036000000000000004s 13.370523835063214A 0.036000000001s 15.014679193451899A 0.048s 15.014679193451899A 0.048000000001s 16.706282238697238A 0.06s 16.706282238697238A 0.060000000000999996s 16.82490418286694A 0.07200000000000001s 16.82490418286694A 0.07200000000100001s 5.288763694090423A 0.084s 5.288763694090423A 0.08400000000100001s 12.609535990949222A 0.096s 12.609535990949222A 0.09600000000100001s 14.886442200025716A 0.108s 14.886442200025716A 0.108000000001s 16.31181385578745A 0.12s 16.31181385578745A 0.120000000001s 16.84219766901222A 0.132s 16.84219766901222A 0.132000000001s 5.319074703098352A 0.14400000000000002s 5.319074703098352A 0.14400000000100002s 12.024298727508036A 0.156s 12.024298727508036A 0.156000000001s 14.5201852654639A 0.168s 14.5201852654639A 0.16800000000100002s 15.917445021949863A 0.18s 15.917445021949863A 0.180000000001s 16.664543083196918A 0.192s 16.664543083196918A 0.192000000001s 8.780995952723377A 0.20400000000000001s 8.780995952723377A 0.20400000000100002s 7.168142974244699A 0.216s 7.168142974244699A 0.216000000001s 13.654295870614959A 0.228s 13.654295870614959A 0.228000000001s 15.288589178761521A 0.24s 15.288589178761521A 0.240000000001s 16.50765987702593A 0.252s 16.50765987702593A 0.252000000001s 15.5237710156246A 0.264s 15.5237710156246A 0.264000000001s 5.17144001604457A 0.276s 5.17144001604457A 0.276000000001s 12.722673066072428A 0.28800000000000003s 12.722673066072428A 0.288000000001s 14.828468423226916A 0.3s 14.828468423226916A 0.30000000000099997s 16.71925387052925A 0.312s 16.71925387052925A 0.312000000001s 16.91437221025927A 0.324s 16.91437221025927A 0.324000000001s 4.645650015444611A 0.336s 4.645650015444611A 0.336000000001s 11.928170176644528A 0.34800000000000003s 11.928170176644528A 0.348000000001s 14.461774356940222A 0.36s 14.461774356940222A 0.36000000000099996s 16.279010782292698A 0.372s 16.279010782292698A 0.372000000001s 16.476118714857513A 0.384s 16.476118714857513A 0.384000000001s 7.84245210151275A 0.396s 7.84245210151275A 0.396000000001s 5.830390533773302A 0.40800000000000003s 5.830390533773302A 0.408000000001s 13.114118701487039A 0.42s 13.114118701487039A 0.42000000000099996s 15.602204165759591A 0.432s 15.602204165759591A 0.432000000001s 16.0155514126591A 0.444s 16.0155514126591A 0.444000000001s 17.481106454407545A 0.456s 17.481106454407545A 0.456000000001s 4.974496261444184A 0.468s 4.974496261444184A 0.468000000001s 12.46365801606171A 0.48s 12.46365801606171A 0.48000000000099996s 14.995648197265911A 0.492s 14.995648197265911A 0.49200000000099997s 15.852403792209131A 0.504s 15.852403792209131A 0.504000000001s 17.68263154506107A 0.516s 17.68263154506107A 0.516000000001s 4.900351124542533A 0.528s 4.900351124542533A 0.528000000001s 11.774273785609603A 0.54s 11.774273785609603A 0.540000000001s 14.681609232689095A 0.552s 14.681609232689095A 0.552000000001s 15.607259398225844A 0.5640000000000001s 15.607259398225844A 0.564000000001s 16.760271346492395A 0.5760000000000001s 16.760271346492395A 0.576000000001s 8.958378580227128A 0.588s 8.958378580227128A 0.588000000001s 6.947437892127706A 0.6s 6.947437892127706A 0.600000000001s 13.336330316040284A 0.612s 13.336330316040284A 0.612000000001s 15.313283944563963A 0.624s 15.313283944563963A 0.624000000001s 16.479674190632103A 0.636s 16.479674190632103A 0.636000000001s 16.120354137904435A 0.648s 16.120354137904435A 0.648000000001s 4.725640486822371A 0.66s 4.725640486822371A 0.660000000001s 12.494581355800303A 0.672s 12.494581355800303A 0.672000000001s 11.081922816301695A 0.684s 11.081922816301695A 0.684000000001s 11.258131244911079A 0.6960000000000001s 11.258131244911079A 0.696000000001s 11.134297502566962A 0.708s 11.134297502566962A 0.7080000000009999s 11.090136863252626A 0.72s 11.090136863252626A 0.720000000001s 11.132560561354191A 0.732s 11.132560561354191A 0.732000000001s 11.22924919861153A 0.744s 11.22924919861153A 0.744000000001s 11.164508594437544A 0.756s 11.164508594437544A 0.756000000001s 11.113804045562462A 0.768s 11.113804045562462A 0.768000000001s 11.11339851724877A 0.78s 11.11339851724877A 0.780000000001s 11.145267449787875A 0.792s 11.145267449787875A 0.792000000001s 11.212073974304696A 0.804s 11.212073974304696A 0.804000000001s 11.414334538572962A 0.8160000000000001s 11.414334538572962A 0.816000000001s 12.480725543672598A 0.8280000000000001s 12.480725543672598A 0.828000000001s 12.5266801868438A 0.84s 12.5266801868438A 0.840000000001s 12.496631541358479A 0.852s 12.496631541358479A 0.852000000001s 12.517666129402187A 0.864s 12.517666129402187A 0.864000000001s 12.508991909012217A 0.876s 12.508991909012217A 0.876000000001s 12.471518958885795A 0.888s 12.471518958885795A 0.888000000001s 12.470571801808447A 0.9s 12.470571801808447A 0.900000000001s 12.505342735564602A 0.912s 12.505342735564602A 0.912000000001s 12.508722443505466A 0.924s 12.508722443505466A 0.924000000001s 11.990504270563534A 0.936s 11.990504270563534A 0.936000000001s 12.353165049787874A 0.9480000000000001s 12.353165049787874A 0.948000000001s 12.327960379927152A 0.96s 12.327960379927152A 0.9600000000009999s 12.406587621684166A 0.972s 12.406587621684166A 0.972000000001s 12.367419547563749A 0.984s 12.367419547563749A 0.984000000001s 12.365886535350336A 0.996s 12.365886535350336A 0.996000000001s 12.354474893233341A 1.008s 12.354474893233341A 1.008000000001s 12.41757402308978A 1.02s 12.41757402308978A 1.020000000001s 12.403607757960147A 1.032s 12.403607757960147A 1.0320000000010001s 12.309447381049928A 1.044s 12.309447381049928A 1.0440000000010001s 3.7574600265009646A 1.056s 3.7574600265009646A 1.0560000000010001s 3.2490998258067285A 1.068s 3.2490998258067285A 1.0680000000010001s 14.17284651094065A 1.08s 14.17284651094065A 1.0800000000010002s 14.17599089559889A 1.092s 14.17599089559889A 1.0920000000010002s 14.19058740953932A 1.104s 14.19058740953932A 1.1040000000010002s 14.148094339524324A 1.116s 14.148094339524324A 1.1160000000010002s 14.170778775367477A 1.1280000000000001s 14.170778775367477A 1.1280000000010002s 14.246928056224558A 1.1400000000000001s 14.246928056224558A 1.1400000000010002s 14.220917478465827A 1.1520000000000001s 14.220917478465827A 1.1520000000010002s 14.105499097973007A 1.164s 14.105499097973007A 1.164000000001s 14.174566370584962A 1.176s 14.174566370584962A 1.176000000001s 11.997988716211701A 1.188s 11.997988716211701A 1.188000000001s 12.543968043265483A 1.2s 12.543968043265483A 1.200000000001s 12.556985101864154A 1.212s 12.556985101864154A 1.212000000001s 12.48059083601457A 1.224s 12.48059083601457A 1.224000000001s 12.477129944615386A 1.236s 12.477129944615386A 1.236000000001s 12.485601858838656A 1.248s 12.485601858838656A 1.248000000001s 12.500649139644315A 1.26s 12.500649139644315A 1.260000000001s 12.508973639597176A 1.272s 12.508973639597176A 1.272000000001s 12.50016099325477A 1.284s 12.50016099325477A 1.2840000000010001s 12.51020294788087A 1.296s 12.51020294788087A 1.2960000000010001s 11.936468372487681A 1.308s 11.936468372487681A 1.3080000000010001s 11.089508287465183A 1.32s 11.089508287465183A 1.3200000000010002s 11.126937107418044A 1.332s 11.126937107418044A 1.3320000000010002s 11.088859133490468A 1.344s 11.088859133490468A 1.3440000000010002s 11.204937082528392A 1.356s 11.204937082528392A 1.3560000000010002s 11.169042734501824A 1.368s 11.169042734501824A 1.3680000000010002s 11.116975955637457A 1.3800000000000001s 11.116975955637457A 1.3800000000010002s 11.120522890627814A 1.3920000000000001s 11.120522890627814A 1.3920000000010002s 11.222179725493893A 1.4040000000000001s 11.222179725493893A 1.4040000000010002s 11.173147969933577A 1.416s 11.173147969933577A 1.416000000001s 11.066749080025716A 1.428s 11.066749080025716A 1.428000000001s 7.865101290936363A 1.44s 7.865101290936363A 1.440000000001s 3.1659819551403476A 1.452s 3.1659819551403476A 1.452000000001s 4.662111452701951A 1.464s 4.662111452701951A 1.464000000001s 14.154929785952437A 1.476s 14.154929785952437A 1.476000000001s 14.202863147306623A 1.488s 14.202863147306623A 1.488000000001s 14.136833604113994A 1.5s 14.136833604113994A 1.500000000001s 14.180625471437757A 1.512s 14.180625471437757A 1.512000000001s 14.199148935076067A 1.524s 14.199148935076067A 1.524000000001s 14.160284238645813A 1.536s 14.160284238645813A 1.5360000000010001s 14.158495772496252A 1.548s 14.158495772496252A 1.5480000000010001s 14.18773106094708A 1.56s 14.18773106094708A 1.5600000000010001s 14.230223988755093A 1.572s 14.230223988755093A 1.5720000000010002s 11.433422082948363A 1.584s 11.433422082948363A 1.5840000000010002s 12.562299724053998A 1.596s 12.562299724053998A 1.5960000000010002s 12.494978138384404A 1.608s 12.494978138384404A 1.6080000000010002s 12.48554977343904A 1.62s 12.48554977343904A 1.6200000000010002s 12.504867136850228A 1.6320000000000001s 12.504867136850228A 1.6320000000010002s 12.481383614861798A 1.6440000000000001s 12.481383614861798A 1.6440000000010002s 12.524911700775665A 1.6560000000000001s 12.524911700775665A 1.6560000000010002s 12.514590518551536A 1.668s 12.514590518551536A 1.668000000001s 12.505571324928223A 1.68s 12.505571324928223A 1.680000000001s 12.513371168939365A 1.692s 12.513371168939365A 1.692000000001s 11.360438977878724A 1.704s 11.360438977878724A 1.704000000001s 11.125152183895437A 1.716s 11.125152183895437A 1.716000000001s 11.191102664186847A 1.728s 11.191102664186847A 1.728000000001s 11.229495718602958A 1.74s 11.229495718602958A 1.740000000001s 11.062946816575963A 1.752s 11.062946816575963A 1.752000000001s 11.053446289950722A 1.764s 11.053446289950722A 1.764000000001s 11.127327478140135A 1.776s 11.127327478140135A 1.7760000000010001s 11.203690968725095A 1.788s 11.203690968725095A 1.7880000000010001s 11.121899826492395A 1.8s 11.121899826492395A 1.8000000000010001s 11.114238492084855A 1.812s 11.114238492084855A 1.8120000000010001s 11.133495174938936A 1.824s 11.133495174938936A 1.8240000000010002s 4.764195636288838A 1.836s 4.764195636288838A 1.8360000000010002s 3.1655427990572105A 1.848s 3.1655427990572105A 1.8480000000010002s 8.803813155517464A 1.86s 8.803813155517464A 1.8600000000010002s 14.158088345301053A 1.872s 14.158088345301053A 1.8720000000010002s 14.192277330430688A)
R_0_6_0_1 Node0_6_0 Node0_6_1 9.887809523809524
R_0_6_0_2 Node0_6_0 Node0_7_0 13.020765027322408
R_0_6_0_3 Node0_6_0 Node1_6_0 2.595018540202966
C_0_6_0 Node0_6_0 GND 0.00099241447536
I_0_6_1 GND Node0_6_1 PWL(0s 0A 0.012s 0A 0.012000000001s 5.859660821872725A 0.024s 5.859660821872725A 0.024000000001s 13.370523835063214A 0.036000000000000004s 13.370523835063214A 0.036000000001s 15.014679193451899A 0.048s 15.014679193451899A 0.048000000001s 16.706282238697238A 0.06s 16.706282238697238A 0.060000000000999996s 16.82490418286694A 0.07200000000000001s 16.82490418286694A 0.07200000000100001s 5.288763694090423A 0.084s 5.288763694090423A 0.08400000000100001s 12.609535990949222A 0.096s 12.609535990949222A 0.09600000000100001s 14.886442200025716A 0.108s 14.886442200025716A 0.108000000001s 16.31181385578745A 0.12s 16.31181385578745A 0.120000000001s 16.84219766901222A 0.132s 16.84219766901222A 0.132000000001s 5.319074703098352A 0.14400000000000002s 5.319074703098352A 0.14400000000100002s 12.024298727508036A 0.156s 12.024298727508036A 0.156000000001s 14.5201852654639A 0.168s 14.5201852654639A 0.16800000000100002s 15.917445021949863A 0.18s 15.917445021949863A 0.180000000001s 16.664543083196918A 0.192s 16.664543083196918A 0.192000000001s 8.780995952723377A 0.20400000000000001s 8.780995952723377A 0.20400000000100002s 7.168142974244699A 0.216s 7.168142974244699A 0.216000000001s 13.654295870614959A 0.228s 13.654295870614959A 0.228000000001s 15.288589178761521A 0.24s 15.288589178761521A 0.240000000001s 16.50765987702593A 0.252s 16.50765987702593A 0.252000000001s 15.5237710156246A 0.264s 15.5237710156246A 0.264000000001s 5.17144001604457A 0.276s 5.17144001604457A 0.276000000001s 12.722673066072428A 0.28800000000000003s 12.722673066072428A 0.288000000001s 14.828468423226916A 0.3s 14.828468423226916A 0.30000000000099997s 16.71925387052925A 0.312s 16.71925387052925A 0.312000000001s 16.91437221025927A 0.324s 16.91437221025927A 0.324000000001s 4.645650015444611A 0.336s 4.645650015444611A 0.336000000001s 11.928170176644528A 0.34800000000000003s 11.928170176644528A 0.348000000001s 14.461774356940222A 0.36s 14.461774356940222A 0.36000000000099996s 16.279010782292698A 0.372s 16.279010782292698A 0.372000000001s 16.476118714857513A 0.384s 16.476118714857513A 0.384000000001s 7.84245210151275A 0.396s 7.84245210151275A 0.396000000001s 5.830390533773302A 0.40800000000000003s 5.830390533773302A 0.408000000001s 13.114118701487039A 0.42s 13.114118701487039A 0.42000000000099996s 15.602204165759591A 0.432s 15.602204165759591A 0.432000000001s 16.0155514126591A 0.444s 16.0155514126591A 0.444000000001s 17.481106454407545A 0.456s 17.481106454407545A 0.456000000001s 4.974496261444184A 0.468s 4.974496261444184A 0.468000000001s 12.46365801606171A 0.48s 12.46365801606171A 0.48000000000099996s 14.995648197265911A 0.492s 14.995648197265911A 0.49200000000099997s 15.852403792209131A 0.504s 15.852403792209131A 0.504000000001s 17.68263154506107A 0.516s 17.68263154506107A 0.516000000001s 4.900351124542533A 0.528s 4.900351124542533A 0.528000000001s 11.774273785609603A 0.54s 11.774273785609603A 0.540000000001s 14.681609232689095A 0.552s 14.681609232689095A 0.552000000001s 15.607259398225844A 0.5640000000000001s 15.607259398225844A 0.564000000001s 16.760271346492395A 0.5760000000000001s 16.760271346492395A 0.576000000001s 8.958378580227128A 0.588s 8.958378580227128A 0.588000000001s 6.947437892127706A 0.6s 6.947437892127706A 0.600000000001s 13.336330316040284A 0.612s 13.336330316040284A 0.612000000001s 15.313283944563963A 0.624s 15.313283944563963A 0.624000000001s 16.479674190632103A 0.636s 16.479674190632103A 0.636000000001s 16.120354137904435A 0.648s 16.120354137904435A 0.648000000001s 4.725640486822371A 0.66s 4.725640486822371A 0.660000000001s 12.494581355800303A 0.672s 12.494581355800303A 0.672000000001s 11.081922816301695A 0.684s 11.081922816301695A 0.684000000001s 11.258131244911079A 0.6960000000000001s 11.258131244911079A 0.696000000001s 11.134297502566962A 0.708s 11.134297502566962A 0.7080000000009999s 11.090136863252626A 0.72s 11.090136863252626A 0.720000000001s 11.132560561354191A 0.732s 11.132560561354191A 0.732000000001s 11.22924919861153A 0.744s 11.22924919861153A 0.744000000001s 11.164508594437544A 0.756s 11.164508594437544A 0.756000000001s 11.113804045562462A 0.768s 11.113804045562462A 0.768000000001s 11.11339851724877A 0.78s 11.11339851724877A 0.780000000001s 11.145267449787875A 0.792s 11.145267449787875A 0.792000000001s 11.212073974304696A 0.804s 11.212073974304696A 0.804000000001s 11.414334538572962A 0.8160000000000001s 11.414334538572962A 0.816000000001s 12.480725543672598A 0.8280000000000001s 12.480725543672598A 0.828000000001s 12.5266801868438A 0.84s 12.5266801868438A 0.840000000001s 12.496631541358479A 0.852s 12.496631541358479A 0.852000000001s 12.517666129402187A 0.864s 12.517666129402187A 0.864000000001s 12.508991909012217A 0.876s 12.508991909012217A 0.876000000001s 12.471518958885795A 0.888s 12.471518958885795A 0.888000000001s 12.470571801808447A 0.9s 12.470571801808447A 0.900000000001s 12.505342735564602A 0.912s 12.505342735564602A 0.912000000001s 12.508722443505466A 0.924s 12.508722443505466A 0.924000000001s 11.990504270563534A 0.936s 11.990504270563534A 0.936000000001s 12.353165049787874A 0.9480000000000001s 12.353165049787874A 0.948000000001s 12.327960379927152A 0.96s 12.327960379927152A 0.9600000000009999s 12.406587621684166A 0.972s 12.406587621684166A 0.972000000001s 12.367419547563749A 0.984s 12.367419547563749A 0.984000000001s 12.365886535350336A 0.996s 12.365886535350336A 0.996000000001s 12.354474893233341A 1.008s 12.354474893233341A 1.008000000001s 12.41757402308978A 1.02s 12.41757402308978A 1.020000000001s 12.403607757960147A 1.032s 12.403607757960147A 1.0320000000010001s 12.309447381049928A 1.044s 12.309447381049928A 1.0440000000010001s 3.7574600265009646A 1.056s 3.7574600265009646A 1.0560000000010001s 3.2490998258067285A 1.068s 3.2490998258067285A 1.0680000000010001s 14.17284651094065A 1.08s 14.17284651094065A 1.0800000000010002s 14.17599089559889A 1.092s 14.17599089559889A 1.0920000000010002s 14.19058740953932A 1.104s 14.19058740953932A 1.1040000000010002s 14.148094339524324A 1.116s 14.148094339524324A 1.1160000000010002s 14.170778775367477A 1.1280000000000001s 14.170778775367477A 1.1280000000010002s 14.246928056224558A 1.1400000000000001s 14.246928056224558A 1.1400000000010002s 14.220917478465827A 1.1520000000000001s 14.220917478465827A 1.1520000000010002s 14.105499097973007A 1.164s 14.105499097973007A 1.164000000001s 14.174566370584962A 1.176s 14.174566370584962A 1.176000000001s 11.997988716211701A 1.188s 11.997988716211701A 1.188000000001s 12.543968043265483A 1.2s 12.543968043265483A 1.200000000001s 12.556985101864154A 1.212s 12.556985101864154A 1.212000000001s 12.48059083601457A 1.224s 12.48059083601457A 1.224000000001s 12.477129944615386A 1.236s 12.477129944615386A 1.236000000001s 12.485601858838656A 1.248s 12.485601858838656A 1.248000000001s 12.500649139644315A 1.26s 12.500649139644315A 1.260000000001s 12.508973639597176A 1.272s 12.508973639597176A 1.272000000001s 12.50016099325477A 1.284s 12.50016099325477A 1.2840000000010001s 12.51020294788087A 1.296s 12.51020294788087A 1.2960000000010001s 11.936468372487681A 1.308s 11.936468372487681A 1.3080000000010001s 11.089508287465183A 1.32s 11.089508287465183A 1.3200000000010002s 11.126937107418044A 1.332s 11.126937107418044A 1.3320000000010002s 11.088859133490468A 1.344s 11.088859133490468A 1.3440000000010002s 11.204937082528392A 1.356s 11.204937082528392A 1.3560000000010002s 11.169042734501824A 1.368s 11.169042734501824A 1.3680000000010002s 11.116975955637457A 1.3800000000000001s 11.116975955637457A 1.3800000000010002s 11.120522890627814A 1.3920000000000001s 11.120522890627814A 1.3920000000010002s 11.222179725493893A 1.4040000000000001s 11.222179725493893A 1.4040000000010002s 11.173147969933577A 1.416s 11.173147969933577A 1.416000000001s 11.066749080025716A 1.428s 11.066749080025716A 1.428000000001s 7.865101290936363A 1.44s 7.865101290936363A 1.440000000001s 3.1659819551403476A 1.452s 3.1659819551403476A 1.452000000001s 4.662111452701951A 1.464s 4.662111452701951A 1.464000000001s 14.154929785952437A 1.476s 14.154929785952437A 1.476000000001s 14.202863147306623A 1.488s 14.202863147306623A 1.488000000001s 14.136833604113994A 1.5s 14.136833604113994A 1.500000000001s 14.180625471437757A 1.512s 14.180625471437757A 1.512000000001s 14.199148935076067A 1.524s 14.199148935076067A 1.524000000001s 14.160284238645813A 1.536s 14.160284238645813A 1.5360000000010001s 14.158495772496252A 1.548s 14.158495772496252A 1.5480000000010001s 14.18773106094708A 1.56s 14.18773106094708A 1.5600000000010001s 14.230223988755093A 1.572s 14.230223988755093A 1.5720000000010002s 11.433422082948363A 1.584s 11.433422082948363A 1.5840000000010002s 12.562299724053998A 1.596s 12.562299724053998A 1.5960000000010002s 12.494978138384404A 1.608s 12.494978138384404A 1.6080000000010002s 12.48554977343904A 1.62s 12.48554977343904A 1.6200000000010002s 12.504867136850228A 1.6320000000000001s 12.504867136850228A 1.6320000000010002s 12.481383614861798A 1.6440000000000001s 12.481383614861798A 1.6440000000010002s 12.524911700775665A 1.6560000000000001s 12.524911700775665A 1.6560000000010002s 12.514590518551536A 1.668s 12.514590518551536A 1.668000000001s 12.505571324928223A 1.68s 12.505571324928223A 1.680000000001s 12.513371168939365A 1.692s 12.513371168939365A 1.692000000001s 11.360438977878724A 1.704s 11.360438977878724A 1.704000000001s 11.125152183895437A 1.716s 11.125152183895437A 1.716000000001s 11.191102664186847A 1.728s 11.191102664186847A 1.728000000001s 11.229495718602958A 1.74s 11.229495718602958A 1.740000000001s 11.062946816575963A 1.752s 11.062946816575963A 1.752000000001s 11.053446289950722A 1.764s 11.053446289950722A 1.764000000001s 11.127327478140135A 1.776s 11.127327478140135A 1.7760000000010001s 11.203690968725095A 1.788s 11.203690968725095A 1.7880000000010001s 11.121899826492395A 1.8s 11.121899826492395A 1.8000000000010001s 11.114238492084855A 1.812s 11.114238492084855A 1.8120000000010001s 11.133495174938936A 1.824s 11.133495174938936A 1.8240000000010002s 4.764195636288838A 1.836s 4.764195636288838A 1.8360000000010002s 3.1655427990572105A 1.848s 3.1655427990572105A 1.8480000000010002s 8.803813155517464A 1.86s 8.803813155517464A 1.8600000000010002s 14.158088345301053A 1.872s 14.158088345301053A 1.8720000000010002s 14.192277330430688A)
R_0_6_1_1 Node0_6_1 Node0_6_2 9.887809523809524
R_0_6_1_2 Node0_6_1 Node0_7_1 13.020765027322408
R_0_6_1_3 Node0_6_1 Node1_6_1 2.595018540202966
C_0_6_1 Node0_6_1 GND 0.00099241447536
I_0_6_2 GND Node0_6_2 PWL(0s 0A 0.012s 0A 0.012000000001s 2.701957968797164A 0.024s 2.701957968797164A 0.024000000001s 6.098267296124457A 0.036000000000000004s 6.098267296124457A 0.036000000001s 6.841731763701165A 0.048s 6.841731763701165A 0.048000000001s 7.606651401154308A 0.06s 7.606651401154308A 0.060000000000999996s 7.660290472957899A 0.07200000000000001s 7.660290472957899A 0.07200000000100001s 2.4438065707424452A 0.084s 2.4438065707424452A 0.08400000000100001s 5.7541588888001485A 0.096s 5.7541588888001485A 0.09600000000100001s 6.783744645198494A 0.108s 6.783744645198494A 0.108000000001s 7.4282782308496245A 0.12s 7.4282782308496245A 0.120000000001s 7.668110599725545A 0.132s 7.668110599725545A 0.132000000001s 2.457512950389319A 0.14400000000000002s 2.457512950389319A 0.14400000000100002s 5.489522311042446A 0.156s 5.489522311042446A 0.156000000001s 6.618128291018373A 0.168s 6.618128291018373A 0.16800000000100002s 7.249949989210183A 0.18s 7.249949989210183A 0.180000000001s 7.5877775480523875A 0.192s 7.5877775480523875A 0.192000000001s 4.022946531952969A 0.20400000000000001s 4.022946531952969A 0.20400000000100002s 3.2936356957297783A 0.216s 3.2936356957297783A 0.216000000001s 6.226584806845414A 0.228s 6.226584806845414A 0.228000000001s 6.96559005345175A 0.24s 6.96559005345175A 0.240000000001s 7.516837019141889A 0.252s 7.516837019141889A 0.252000000001s 7.07193611072165A 0.264s 7.07193611072165A 0.264000000001s 2.3907546424456014A 0.276s 2.3907546424456014A 0.276000000001s 5.805317522715457A 0.28800000000000003s 5.805317522715457A 0.288000000001s 6.757529727001223A 0.3s 6.757529727001223A 0.30000000000099997s 7.612516816750632A 0.312s 7.612516816750632A 0.312000000001s 7.700746901846823A 0.324s 7.700746901846823A 0.324000000001s 2.1529999604255976A 0.336s 2.1529999604255976A 0.336000000001s 5.44605400205939A 0.34800000000000003s 5.44605400205939A 0.348000000001s 6.591715622054875A 0.36s 6.591715622054875A 0.36000000000099996s 7.413444803026486A 0.372s 7.413444803026486A 0.372000000001s 7.50257481176769A 0.384s 7.50257481176769A 0.384000000001s 3.598549992894918A 0.396s 3.598549992894918A 0.396000000001s 2.688722704424031A 0.40800000000000003s 2.688722704424031A 0.408000000001s 5.982324451624926A 0.42s 5.982324451624926A 0.42000000000099996s 7.107402294840223A 0.432s 7.107402294840223A 0.432000000001s 7.294312563260167A 0.444s 7.294312563260167A 0.444000000001s 7.957015731045326A 0.456s 7.957015731045326A 0.456000000001s 2.301699388712443A 0.468s 2.301699388712443A 0.468000000001s 5.68819468310671A 0.48s 5.68819468310671A 0.48000000000099996s 6.833126045589895A 0.492s 6.833126045589895A 0.49200000000099997s 7.220539527237026A 0.504s 7.220539527237026A 0.504000000001s 8.04814285788425A 0.516s 8.04814285788425A 0.516000000001s 2.2681722692662483A 0.528s 2.2681722692662483A 0.528000000001s 5.376464068517795A 0.54s 5.376464068517795A 0.540000000001s 6.691121915542335A 0.552s 6.691121915542335A 0.552000000001s 7.109688285149337A 0.5640000000000001s 7.109688285149337A 0.564000000001s 7.631064422630066A 0.5760000000000001s 7.631064422630066A 0.576000000001s 4.103156521930681A 0.588s 4.103156521930681A 0.588000000001s 3.1938359932970948A 0.6s 3.1938359932970948A 0.600000000001s 6.082805214599293A 0.612s 6.082805214599293A 0.612000000001s 6.976756589682167A 0.624s 6.976756589682167A 0.624000000001s 7.504182289365446A 0.636s 7.504182289365446A 0.636000000001s 7.341702264539675A 0.648s 7.341702264539675A 0.648000000001s 2.1891705151059786A 0.66s 2.1891705151059786A 0.660000000001s 5.7021775199559475A 0.672s 5.7021775199559475A 0.672000000001s 5.063388840377995A 0.684s 5.063388840377995A 0.684000000001s 5.143067272222316A 0.6960000000000001s 5.143067272222316A 0.696000000001s 5.08707141332081A 0.708s 5.08707141332081A 0.7080000000009999s 5.067102599641787A 0.72s 5.067102599641787A 0.720000000001s 5.086285993182249A 0.732s 5.086285993182249A 0.732000000001s 5.130007221231673A 0.744s 5.130007221231673A 0.744000000001s 5.100732439836059A 0.756s 5.100732439836059A 0.756000000001s 5.077804563227245A 0.768s 5.077804563227245A 0.768000000001s 5.077621189085399A 0.78s 5.077621189085399A 0.780000000001s 5.092031867596933A 0.792s 5.092031867596933A 0.792000000001s 5.122240828819703A 0.804s 5.122240828819703A 0.804000000001s 5.213700182334452A 0.8160000000000001s 5.213700182334452A 0.816000000001s 5.6959070439300525A 0.8280000000000001s 5.6959070439300525A 0.828000000001s 5.716687080664571A 0.84s 5.716687080664571A 0.840000000001s 5.703099510096755A 0.852s 5.703099510096755A 0.852000000001s 5.71261105195805A 0.864s 5.71261105195805A 0.864000000001s 5.7086886927379945A 0.876s 5.7086886927379945A 0.876000000001s 5.691743957093397A 0.888s 5.691743957093397A 0.888000000001s 5.691315666119897A 0.9s 5.691315666119897A 0.900000000001s 5.707038588351163A 0.912s 5.707038588351163A 0.912000000001s 5.708566844264314A 0.924s 5.708566844264314A 0.924000000001s 5.474235949122538A 0.936s 5.474235949122538A 0.936000000001s 5.638226000930266A 0.9480000000000001s 5.638226000930266A 0.948000000001s 5.626828807318382A 0.96s 5.626828807318382A 0.9600000000009999s 5.662382928932551A 0.972s 5.662382928932551A 0.972000000001s 5.644671682301596A 0.984s 5.644671682301596A 0.984000000001s 5.6439784759591936A 0.996s 5.6439784759591936A 0.996000000001s 5.638818293526509A 1.008s 5.638818293526509A 1.008000000001s 5.667350823557221A 1.02s 5.667350823557221A 1.020000000001s 5.661035476893412A 1.032s 5.661035476893412A 1.0320000000010001s 5.618457492252315A 1.044s 5.618457492252315A 1.0440000000010001s 1.751370314170749A 1.056s 1.751370314170749A 1.0560000000010001s 1.5214970540207602A 1.068s 1.5214970540207602A 1.0680000000010001s 6.461060190276594A 1.08s 6.461060190276594A 1.0800000000010002s 6.462482036344734A 1.092s 6.462482036344734A 1.0920000000010002s 6.46908237256643A 1.104s 6.46908237256643A 1.1040000000010002s 6.449867610032326A 1.116s 6.449867610032326A 1.1160000000010002s 6.4601251896280685A 1.1280000000000001s 6.4601251896280685A 1.1280000000010002s 6.494558812529291A 1.1400000000000001s 6.494558812529291A 1.1400000000010002s 6.482797198815985A 1.1520000000000001s 6.482797198815985A 1.1520000000010002s 6.430606646981117A 1.164s 6.430606646981117A 1.164000000001s 6.461837886372589A 1.176s 6.461837886372589A 1.176000000001s 5.477620309108254A 1.188s 5.477620309108254A 1.188000000001s 5.724504403718639A 1.2s 5.724504403718639A 1.200000000001s 5.730390532675142A 1.212s 5.730390532675142A 1.212000000001s 5.695846131040972A 1.224s 5.695846131040972A 1.224000000001s 5.694281165121395A 1.236s 5.694281165121395A 1.236000000001s 5.698112044367163A 1.248s 5.698112044367163A 1.248000000001s 5.704916210960978A 1.26s 5.704916210960978A 1.260000000001s 5.708680431568078A 1.272s 5.708680431568078A 1.272000000001s 5.7046954780990395A 1.284s 5.7046954780990395A 1.2840000000010001s 5.709236307308383A 1.296s 5.709236307308383A 1.2960000000010001s 5.44980168373578A 1.308s 5.44980168373578A 1.3080000000010001s 5.06681836660129A 1.32s 5.06681836660129A 1.3200000000010002s 5.083743147208389A 1.332s 5.083743147208389A 1.3320000000010002s 5.066524828396877A 1.344s 5.066524828396877A 1.3440000000010002s 5.119013627756922A 1.356s 5.119013627756922A 1.3560000000010002s 5.10278271355365A 1.368s 5.10278271355365A 1.3680000000010002s 5.079238855897769A 1.3800000000000001s 5.079238855897769A 1.3800000000010002s 5.080842729506796A 1.3920000000000001s 5.080842729506796A 1.3920000000010002s 5.12681050592848A 1.4040000000000001s 5.12681050592848A 1.4040000000010002s 5.10463904269014A 1.416s 5.10463904269014A 1.416000000001s 5.056526976352022A 1.428s 5.056526976352022A 1.428000000001s 3.608787334017903A 1.44s 3.608787334017903A 1.440000000001s 1.4839123338150604A 1.452s 1.4839123338150604A 1.452000000001s 2.1604408361277523A 1.464s 2.1604408361277523A 1.464000000001s 6.452958501791486A 1.476s 6.452958501791486A 1.476000000001s 6.474633286775416A 1.488s 6.474633286775416A 1.488000000001s 6.4447756654683666A 1.5s 6.4447756654683666A 1.500000000001s 6.464577725692636A 1.512s 6.464577725692636A 1.512000000001s 6.472953772774987A 1.524s 6.472953772774987A 1.524000000001s 6.455379709225241A 1.536s 6.455379709225241A 1.5360000000010001s 6.454570990242311A 1.548s 6.454570990242311A 1.5480000000010001s 6.467790772315021A 1.56s 6.467790772315021A 1.5600000000010001s 6.487005470545147A 1.572s 6.487005470545147A 1.5720000000010002s 5.222331298711853A 1.584s 5.222331298711853A 1.5840000000010002s 5.732793729321095A 1.596s 5.732793729321095A 1.5960000000010002s 5.70235186476285A 1.608s 5.70235186476285A 1.6080000000010002s 5.698088492089468A 1.62s 5.698088492089468A 1.6200000000010002s 5.706823529369664A 1.6320000000000001s 5.706823529369664A 1.6320000000010002s 5.696204614372164A 1.6440000000000001s 5.696204614372164A 1.6440000000010002s 5.715887396390591A 1.6560000000000001s 5.715887396390591A 1.6560000000010002s 5.711220304428588A 1.668s 5.711220304428588A 1.668000000001s 5.707141953213675A 1.68s 5.707141953213675A 1.680000000001s 5.710668931858058A 1.692s 5.710668931858058A 1.692000000001s 5.189329375517795A 1.704s 5.189329375517795A 1.704000000001s 5.0829360301510365A 1.716s 5.0829360301510365A 1.716000000001s 5.112757900337452A 1.728s 5.112757900337452A 1.728000000001s 5.130118694069328A 1.74s 5.130118694069328A 1.740000000001s 5.054807646841273A 1.752s 5.054807646841273A 1.752000000001s 5.050511643681499A 1.764s 5.050511643681499A 1.764000000001s 5.083919667302668A 1.776s 5.083919667302668A 1.7760000000010001s 5.1184501527994195A 1.788s 5.1184501527994195A 1.7880000000010001s 5.0814653603417375A 1.8s 5.0814653603417375A 1.8000000000010001s 5.078001013772207A 1.812s 5.078001013772207A 1.8120000000010001s 5.086708612166607A 1.824s 5.086708612166607A 1.8240000000010002s 2.2066018535693632A 1.836s 2.2066018535693632A 1.8360000000010002s 1.483713753673642A 1.848s 1.483713753673642A 1.8480000000010002s 4.033259502291597A 1.86s 4.033259502291597A 1.8600000000010002s 6.454386757453225A 1.872s 6.454386757453225A 1.8720000000010002s 6.469846616794553A)
R_0_6_2_1 Node0_6_2 Node0_6_3 9.887809523809524
R_0_6_2_2 Node0_6_2 Node0_7_2 13.020765027322408
R_0_6_2_3 Node0_6_2 Node1_6_2 2.595018540202966
C_0_6_2 Node0_6_2 GND 0.0009924144753600001
I_0_6_3 GND Node0_6_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629112A 0.024s 0.09547506513629112A 0.024000000001s 0.09548197345930416A 0.036000000000000004s 0.09548197345930416A 0.036000000001s 0.09548338652537504A 0.048s 0.09548338652537504A 0.048000000001s 0.0954847995914459A 0.06s 0.0954847995914459A 0.060000000000999996s 0.09548464258410472A 0.07200000000000001s 0.09548464258410472A 0.07200000000100001s 0.09547537915097351A 0.084s 0.09547537915097351A 0.08400000000100001s 0.09548103141525695A 0.096s 0.09548103141525695A 0.09600000000100001s 0.09548307251069262A 0.108s 0.09548307251069262A 0.108000000001s 0.09548448557676348A 0.12s 0.09548448557676348A 0.120000000001s 0.0954851136061283A 0.132s 0.0954851136061283A 0.132000000001s 0.09547569316565592A 0.14400000000000002s 0.09547569316565592A 0.14400000000100002s 0.09547993236386851A 0.156s 0.09547993236386851A 0.156000000001s 0.0954827584960102A 0.168s 0.0954827584960102A 0.16800000000100002s 0.09548401455473986A 0.18s 0.09548401455473986A 0.180000000001s 0.0954847995914459A 0.192s 0.0954847995914459A 0.192000000001s 0.09547930433450366A 0.20400000000000001s 0.09547930433450366A 0.20400000000100002s 0.09547632119502075A 0.216s 0.09547632119502075A 0.216000000001s 0.09548165944462177A 0.228s 0.09548165944462177A 0.228000000001s 0.09548354353271624A 0.24s 0.09548354353271624A 0.240000000001s 0.09548448557676348A 0.252s 0.09548448557676348A 0.252000000001s 0.09548385754739865A 0.264s 0.09548385754739865A 0.264000000001s 0.09547569316565592A 0.276s 0.09547569316565592A 0.276000000001s 0.09548040338589212A 0.28800000000000003s 0.09548040338589212A 0.288000000001s 0.09548307251069262A 0.3s 0.09548307251069262A 0.30000000000099997s 0.09548448557676348A 0.312s 0.09548448557676348A 0.312000000001s 0.0954851136061283A 0.324s 0.0954851136061283A 0.324000000001s 0.09547585017299713A 0.336s 0.09547585017299713A 0.336000000001s 0.09547930433450366A 0.34800000000000003s 0.09547930433450366A 0.348000000001s 0.09548260148866901A 0.36s 0.09548260148866901A 0.36000000000099996s 0.09548385754739865A 0.372s 0.09548385754739865A 0.372000000001s 0.0954849565987871A 0.384s 0.0954849565987871A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.09547569316565592A 0.40800000000000003s 0.09547569316565592A 0.408000000001s 0.09548181645196296A 0.42s 0.09548181645196296A 0.42000000000099996s 0.09548354353271624A 0.432s 0.09548354353271624A 0.432000000001s 0.09548448557676348A 0.444s 0.09548448557676348A 0.444000000001s 0.09548448557676348A 0.456s 0.09548448557676348A 0.456000000001s 0.09547553615831474A 0.468s 0.09547553615831474A 0.468000000001s 0.09548056039323331A 0.48s 0.09548056039323331A 0.48000000000099996s 0.09548307251069262A 0.492s 0.09548307251069262A 0.49200000000099997s 0.09548448557676348A 0.504s 0.09548448557676348A 0.504000000001s 0.0954851136061283A 0.516s 0.0954851136061283A 0.516000000001s 0.09547600718033832A 0.528s 0.09547600718033832A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.0954827584960102A 0.552s 0.0954827584960102A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410472A 0.5760000000000001s 0.09548464258410472A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502075A 0.6s 0.09547632119502075A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537504A 0.624s 0.09548338652537504A 0.624000000001s 0.09548448557676348A 0.636s 0.09548448557676348A 0.636000000001s 0.09548338652537504A 0.648s 0.09548338652537504A 0.648000000001s 0.09547585017299713A 0.66s 0.09547585017299713A 0.660000000001s 0.09548008937120969A 0.672s 0.09548008937120969A 0.672000000001s 0.09547176798212574A 0.684s 0.09547176798212574A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541972A 1.08s 0.09547098294541972A 1.0800000000010002s 0.09547098294541972A 1.092s 0.09547098294541972A 1.0920000000010002s 0.09547098294541972A 1.104s 0.09547098294541972A 1.1040000000010002s 0.09547098294541972A 1.116s 0.09547098294541972A 1.1160000000010002s 0.09547098294541972A 1.1280000000000001s 0.09547098294541972A 1.1280000000010002s 0.09547098294541972A 1.1400000000000001s 0.09547098294541972A 1.1400000000010002s 0.09547098294541972A 1.1520000000000001s 0.09547098294541972A 1.1520000000010002s 0.09547098294541972A 1.164s 0.09547098294541972A 1.164000000001s 0.09547098294541972A 1.176s 0.09547098294541972A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541972A 1.476s 0.09547098294541972A 1.476000000001s 0.09547098294541972A 1.488s 0.09547098294541972A 1.488000000001s 0.09547098294541972A 1.5s 0.09547098294541972A 1.500000000001s 0.09547098294541972A 1.512s 0.09547098294541972A 1.512000000001s 0.09547098294541972A 1.524s 0.09547098294541972A 1.524000000001s 0.09547098294541972A 1.536s 0.09547098294541972A 1.5360000000010001s 0.09547098294541972A 1.548s 0.09547098294541972A 1.5480000000010001s 0.09547098294541972A 1.56s 0.09547098294541972A 1.5600000000010001s 0.09547098294541972A 1.572s 0.09547098294541972A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541972A 1.872s 0.09547098294541972A 1.8720000000010002s 0.09547113995276092A)
R_0_6_3_1 Node0_6_3 Node0_6_4 9.887809523809523
R_0_6_3_2 Node0_6_3 Node0_7_3 13.020765027322408
R_0_6_3_3 Node0_6_3 Node1_6_3 2.595018540202966
C_0_6_3 Node0_6_3 GND 0.00099241447536
I_0_6_4 GND Node0_6_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.09547506513629112A 0.024s 0.09547506513629112A 0.024000000001s 0.09548197345930418A 0.036000000000000004s 0.09548197345930418A 0.036000000001s 0.09548338652537505A 0.048s 0.09548338652537505A 0.048000000001s 0.0954847995914459A 0.06s 0.0954847995914459A 0.060000000000999996s 0.09548464258410473A 0.07200000000000001s 0.09548464258410473A 0.07200000000100001s 0.09547537915097351A 0.084s 0.09547537915097351A 0.08400000000100001s 0.09548103141525696A 0.096s 0.09548103141525696A 0.09600000000100001s 0.09548307251069263A 0.108s 0.09548307251069263A 0.108000000001s 0.09548448557676348A 0.12s 0.09548448557676348A 0.120000000001s 0.09548511360612831A 0.132s 0.09548511360612831A 0.132000000001s 0.09547569316565593A 0.14400000000000002s 0.09547569316565593A 0.14400000000100002s 0.09547993236386851A 0.156s 0.09547993236386851A 0.156000000001s 0.09548275849601022A 0.168s 0.09548275849601022A 0.16800000000100002s 0.09548401455473987A 0.18s 0.09548401455473987A 0.180000000001s 0.0954847995914459A 0.192s 0.0954847995914459A 0.192000000001s 0.09547930433450366A 0.20400000000000001s 0.09547930433450366A 0.20400000000100002s 0.09547632119502075A 0.216s 0.09547632119502075A 0.216000000001s 0.09548165944462178A 0.228s 0.09548165944462178A 0.228000000001s 0.09548354353271625A 0.24s 0.09548354353271625A 0.240000000001s 0.09548448557676348A 0.252s 0.09548448557676348A 0.252000000001s 0.09548385754739866A 0.264s 0.09548385754739866A 0.264000000001s 0.09547569316565593A 0.276s 0.09547569316565593A 0.276000000001s 0.09548040338589213A 0.28800000000000003s 0.09548040338589213A 0.288000000001s 0.09548307251069263A 0.3s 0.09548307251069263A 0.30000000000099997s 0.09548448557676348A 0.312s 0.09548448557676348A 0.312000000001s 0.09548511360612831A 0.324s 0.09548511360612831A 0.324000000001s 0.09547585017299712A 0.336s 0.09547585017299712A 0.336000000001s 0.09547930433450366A 0.34800000000000003s 0.09547930433450366A 0.348000000001s 0.095482601488669A 0.36s 0.095482601488669A 0.36000000000099996s 0.09548385754739866A 0.372s 0.09548385754739866A 0.372000000001s 0.09548495659878709A 0.384s 0.09548495659878709A 0.384000000001s 0.09547867630513884A 0.396s 0.09547867630513884A 0.396000000001s 0.09547569316565593A 0.40800000000000003s 0.09547569316565593A 0.408000000001s 0.09548181645196298A 0.42s 0.09548181645196298A 0.42000000000099996s 0.09548354353271625A 0.432s 0.09548354353271625A 0.432000000001s 0.09548448557676348A 0.444s 0.09548448557676348A 0.444000000001s 0.09548448557676348A 0.456s 0.09548448557676348A 0.456000000001s 0.09547553615831472A 0.468s 0.09547553615831472A 0.468000000001s 0.09548056039323333A 0.48s 0.09548056039323333A 0.48000000000099996s 0.09548307251069263A 0.492s 0.09548307251069263A 0.49200000000099997s 0.09548448557676348A 0.504s 0.09548448557676348A 0.504000000001s 0.09548511360612831A 0.516s 0.09548511360612831A 0.516000000001s 0.09547600718033833A 0.528s 0.09547600718033833A 0.528000000001s 0.09547899031982124A 0.54s 0.09547899031982124A 0.540000000001s 0.09548275849601022A 0.552s 0.09548275849601022A 0.552000000001s 0.09548370054005745A 0.5640000000000001s 0.09548370054005745A 0.564000000001s 0.09548464258410473A 0.5760000000000001s 0.09548464258410473A 0.576000000001s 0.09547946134184487A 0.588s 0.09547946134184487A 0.588000000001s 0.09547632119502075A 0.6s 0.09547632119502075A 0.600000000001s 0.09548150243728057A 0.612s 0.09548150243728057A 0.612000000001s 0.09548338652537505A 0.624s 0.09548338652537505A 0.624000000001s 0.09548448557676348A 0.636s 0.09548448557676348A 0.636000000001s 0.09548338652537505A 0.648s 0.09548338652537505A 0.648000000001s 0.09547585017299712A 0.66s 0.09547585017299712A 0.660000000001s 0.0954800893712097A 0.672s 0.0954800893712097A 0.672000000001s 0.09547176798212575A 0.684s 0.09547176798212575A 0.684000000001s 0.09547082593807851A 0.6960000000000001s 0.09547082593807851A 0.696000000001s 0.09547082593807851A 0.708s 0.09547082593807851A 0.7080000000009999s 0.09547082593807851A 0.72s 0.09547082593807851A 0.720000000001s 0.09547082593807851A 0.732s 0.09547082593807851A 0.732000000001s 0.09547082593807851A 0.744s 0.09547082593807851A 0.744000000001s 0.09547082593807851A 0.756s 0.09547082593807851A 0.756000000001s 0.09547082593807851A 0.768s 0.09547082593807851A 0.768000000001s 0.09547082593807851A 0.78s 0.09547082593807851A 0.780000000001s 0.09547082593807851A 0.792s 0.09547082593807851A 0.792000000001s 0.09547082593807851A 0.804s 0.09547082593807851A 0.804000000001s 0.09547082593807851A 0.8160000000000001s 0.09547082593807851A 0.816000000001s 0.09547082593807851A 0.8280000000000001s 0.09547082593807851A 0.828000000001s 0.09547082593807851A 0.84s 0.09547082593807851A 0.840000000001s 0.09547082593807851A 0.852s 0.09547082593807851A 0.852000000001s 0.09547082593807851A 0.864s 0.09547082593807851A 0.864000000001s 0.09547082593807851A 0.876s 0.09547082593807851A 0.876000000001s 0.09547082593807851A 0.888s 0.09547082593807851A 0.888000000001s 0.09547082593807851A 0.9s 0.09547082593807851A 0.900000000001s 0.09547082593807851A 0.912s 0.09547082593807851A 0.912000000001s 0.09547082593807851A 0.924s 0.09547082593807851A 0.924000000001s 0.09547082593807851A 0.936s 0.09547082593807851A 0.936000000001s 0.09547082593807851A 0.9480000000000001s 0.09547082593807851A 0.948000000001s 0.09547082593807851A 0.96s 0.09547082593807851A 0.9600000000009999s 0.09547082593807851A 0.972s 0.09547082593807851A 0.972000000001s 0.09547082593807851A 0.984s 0.09547082593807851A 0.984000000001s 0.09547082593807851A 0.996s 0.09547082593807851A 0.996000000001s 0.09547082593807851A 1.008s 0.09547082593807851A 1.008000000001s 0.09547082593807851A 1.02s 0.09547082593807851A 1.020000000001s 0.09547082593807851A 1.032s 0.09547082593807851A 1.0320000000010001s 0.09547082593807851A 1.044s 0.09547082593807851A 1.0440000000010001s 0.09547082593807851A 1.056s 0.09547082593807851A 1.0560000000010001s 0.09547082593807851A 1.068s 0.09547082593807851A 1.0680000000010001s 0.09547098294541972A 1.08s 0.09547098294541972A 1.0800000000010002s 0.09547098294541972A 1.092s 0.09547098294541972A 1.0920000000010002s 0.09547098294541972A 1.104s 0.09547098294541972A 1.1040000000010002s 0.09547098294541972A 1.116s 0.09547098294541972A 1.1160000000010002s 0.09547098294541972A 1.1280000000000001s 0.09547098294541972A 1.1280000000010002s 0.09547098294541972A 1.1400000000000001s 0.09547098294541972A 1.1400000000010002s 0.09547098294541972A 1.1520000000000001s 0.09547098294541972A 1.1520000000010002s 0.09547098294541972A 1.164s 0.09547098294541972A 1.164000000001s 0.09547098294541972A 1.176s 0.09547098294541972A 1.176000000001s 0.09547082593807851A 1.188s 0.09547082593807851A 1.188000000001s 0.09547082593807851A 1.2s 0.09547082593807851A 1.200000000001s 0.09547082593807851A 1.212s 0.09547082593807851A 1.212000000001s 0.09547082593807851A 1.224s 0.09547082593807851A 1.224000000001s 0.09547082593807851A 1.236s 0.09547082593807851A 1.236000000001s 0.09547082593807851A 1.248s 0.09547082593807851A 1.248000000001s 0.09547082593807851A 1.26s 0.09547082593807851A 1.260000000001s 0.09547082593807851A 1.272s 0.09547082593807851A 1.272000000001s 0.09547082593807851A 1.284s 0.09547082593807851A 1.2840000000010001s 0.09547082593807851A 1.296s 0.09547082593807851A 1.2960000000010001s 0.09547082593807851A 1.308s 0.09547082593807851A 1.3080000000010001s 0.09547082593807851A 1.32s 0.09547082593807851A 1.3200000000010002s 0.09547082593807851A 1.332s 0.09547082593807851A 1.3320000000010002s 0.09547082593807851A 1.344s 0.09547082593807851A 1.3440000000010002s 0.09547082593807851A 1.356s 0.09547082593807851A 1.3560000000010002s 0.09547082593807851A 1.368s 0.09547082593807851A 1.3680000000010002s 0.09547082593807851A 1.3800000000000001s 0.09547082593807851A 1.3800000000010002s 0.09547082593807851A 1.3920000000000001s 0.09547082593807851A 1.3920000000010002s 0.09547082593807851A 1.4040000000000001s 0.09547082593807851A 1.4040000000010002s 0.09547082593807851A 1.416s 0.09547082593807851A 1.416000000001s 0.09547082593807851A 1.428s 0.09547082593807851A 1.428000000001s 0.09547082593807851A 1.44s 0.09547082593807851A 1.440000000001s 0.09547082593807851A 1.452s 0.09547082593807851A 1.452000000001s 0.09547082593807851A 1.464s 0.09547082593807851A 1.464000000001s 0.09547098294541972A 1.476s 0.09547098294541972A 1.476000000001s 0.09547098294541972A 1.488s 0.09547098294541972A 1.488000000001s 0.09547098294541972A 1.5s 0.09547098294541972A 1.500000000001s 0.09547098294541972A 1.512s 0.09547098294541972A 1.512000000001s 0.09547098294541972A 1.524s 0.09547098294541972A 1.524000000001s 0.09547098294541972A 1.536s 0.09547098294541972A 1.5360000000010001s 0.09547098294541972A 1.548s 0.09547098294541972A 1.5480000000010001s 0.09547098294541972A 1.56s 0.09547098294541972A 1.5600000000010001s 0.09547098294541972A 1.572s 0.09547098294541972A 1.5720000000010002s 0.09547082593807851A 1.584s 0.09547082593807851A 1.5840000000010002s 0.09547082593807851A 1.596s 0.09547082593807851A 1.5960000000010002s 0.09547082593807851A 1.608s 0.09547082593807851A 1.6080000000010002s 0.09547082593807851A 1.62s 0.09547082593807851A 1.6200000000010002s 0.09547082593807851A 1.6320000000000001s 0.09547082593807851A 1.6320000000010002s 0.09547082593807851A 1.6440000000000001s 0.09547082593807851A 1.6440000000010002s 0.09547082593807851A 1.6560000000000001s 0.09547082593807851A 1.6560000000010002s 0.09547082593807851A 1.668s 0.09547082593807851A 1.668000000001s 0.09547082593807851A 1.68s 0.09547082593807851A 1.680000000001s 0.09547082593807851A 1.692s 0.09547082593807851A 1.692000000001s 0.09547082593807851A 1.704s 0.09547082593807851A 1.704000000001s 0.09547082593807851A 1.716s 0.09547082593807851A 1.716000000001s 0.09547082593807851A 1.728s 0.09547082593807851A 1.728000000001s 0.09547082593807851A 1.74s 0.09547082593807851A 1.740000000001s 0.09547082593807851A 1.752s 0.09547082593807851A 1.752000000001s 0.09547082593807851A 1.764s 0.09547082593807851A 1.764000000001s 0.09547082593807851A 1.776s 0.09547082593807851A 1.7760000000010001s 0.09547082593807851A 1.788s 0.09547082593807851A 1.7880000000010001s 0.09547082593807851A 1.8s 0.09547082593807851A 1.8000000000010001s 0.09547082593807851A 1.812s 0.09547082593807851A 1.8120000000010001s 0.09547082593807851A 1.824s 0.09547082593807851A 1.8240000000010002s 0.09547082593807851A 1.836s 0.09547082593807851A 1.8360000000010002s 0.09547082593807851A 1.848s 0.09547082593807851A 1.8480000000010002s 0.09547082593807851A 1.86s 0.09547082593807851A 1.8600000000010002s 0.09547098294541972A 1.872s 0.09547098294541972A 1.8720000000010002s 0.09547113995276094A)
R_0_6_4_1 Node0_6_4 Node0_6_5 9.887809523809516
R_0_6_4_2 Node0_6_4 Node0_7_4 13.020765027322405
R_0_6_4_3 Node0_6_4 Node1_6_4 2.595018540202966
C_0_6_4 Node0_6_4 GND 0.0009924144753600001
I_0_6_5 GND Node0_6_5 PWL(0s 0A 0.012s 0A 0.012000000001s 1.66682650121881A 0.024s 1.66682650121881A 0.024000000001s 3.568321835668465A 0.036000000000000004s 3.568321835668465A 0.036000000001s 3.9849616701076065A 0.048s 3.9849616701076065A 0.048000000001s 4.295534182435471A 0.06s 4.295534182435471A 0.060000000000999996s 4.227659200302588A 0.07200000000000001s 4.227659200302588A 0.07200000000100001s 1.411962389112886A 0.084s 1.411962389112886A 0.08400000000100001s 3.3725213066880393A 0.096s 3.3725213066880393A 0.09600000000100001s 3.8874021336455695A 0.108s 3.8874021336455695A 0.108000000001s 4.287043570050286A 0.12s 4.287043570050286A 0.120000000001s 4.499515667055497A 0.132s 4.499515667055497A 0.132000000001s 1.3372668642221623A 0.14400000000000002s 1.3372668642221623A 0.14400000000100002s 3.1952950143333902A 0.156s 3.1952950143333902A 0.156000000001s 3.776573614636571A 0.168s 3.776573614636571A 0.16800000000100002s 4.2186267606647085A 0.18s 4.2186267606647085A 0.180000000001s 4.399305288259342A 0.192s 4.399305288259342A 0.192000000001s 2.005090239890849A 0.20400000000000001s 2.005090239890849A 0.20400000000100002s 2.05625746632844A 0.216s 2.05625746632844A 0.216000000001s 3.576842861040583A 0.228s 3.576842861040583A 0.228000000001s 4.051835776845875A 0.24s 4.051835776845875A 0.240000000001s 4.273457482730809A 0.252s 4.273457482730809A 0.252000000001s 3.695360816680527A 0.264s 3.695360816680527A 0.264000000001s 1.4484862015494968A 0.276s 1.4484862015494968A 0.276000000001s 3.353725801800534A 0.28800000000000003s 3.353725801800534A 0.288000000001s 4.0510817727456345A 0.3s 4.0510817727456345A 0.30000000000099997s 4.154425026026287A 0.312s 4.154425026026287A 0.312000000001s 4.5505004294410405A 0.324s 4.5505004294410405A 0.324000000001s 1.1330454898547941A 0.336s 1.1330454898547941A 0.336000000001s 3.185856791240043A 0.34800000000000003s 3.185856791240043A 0.348000000001s 3.7796334860827185A 0.36s 3.7796334860827185A 0.36000000000099996s 4.157972180165994A 0.372s 4.157972180165994A 0.372000000001s 4.499770610625063A 0.384s 4.499770610625063A 0.384000000001s 1.8279913081052646A 0.396s 1.8279913081052646A 0.396000000001s 1.777823575125671A 0.40800000000000003s 1.777823575125671A 0.408000000001s 3.5835267524799437A 0.42s 3.5835267524799437A 0.42000000000099996s 3.998842555658817A 0.432s 3.998842555658817A 0.432000000001s 4.374520005813445A 0.444s 4.374520005813445A 0.444000000001s 3.6905204394053293A 0.456s 3.6905204394053293A 0.456000000001s 1.4683872633449049A 0.468s 1.4683872633449049A 0.468000000001s 3.3604468683216746A 0.48s 3.3604468683216746A 0.48000000000099996s 3.9886496762725248A 0.492s 3.9886496762725248A 0.49200000000099997s 4.218901129064642A 0.504s 4.218901129064642A 0.504000000001s 4.443382166528391A 0.516s 4.443382166528391A 0.516000000001s 1.3005173446053473A 0.528s 1.3005173446053473A 0.528000000001s 3.08250251411091A 0.54s 3.08250251411091A 0.540000000001s 3.8258572569478355A 0.552s 3.8258572569478355A 0.552000000001s 4.070954110207955A 0.5640000000000001s 4.070954110207955A 0.564000000001s 4.451152609984755A 0.5760000000000001s 4.451152609984755A 0.576000000001s 1.915493650621688A 0.588s 1.915493650621688A 0.588000000001s 2.0656341541307404A 0.6s 2.0656341541307404A 0.600000000001s 3.658387343837348A 0.612s 3.658387343837348A 0.612000000001s 4.067246497568503A 0.624s 4.067246497568503A 0.624000000001s 4.277499481119495A 0.636s 4.277499481119495A 0.636000000001s 3.250463159326945A 0.648s 3.250463159326945A 0.648000000001s 1.5029367479192197A 0.66s 1.5029367479192197A 0.660000000001s 3.4182676816030497A 0.672s 3.4182676816030497A 0.672000000001s 2.902670254344141A 0.684s 2.902670254344141A 0.684000000001s 2.94193595319887A 0.6960000000000001s 2.94193595319887A 0.696000000001s 2.9230515672721507A 0.708s 2.9230515672721507A 0.7080000000009999s 2.8965451494962777A 0.72s 2.8965451494962777A 0.720000000001s 2.909013198795613A 0.732s 2.909013198795613A 0.732000000001s 2.936876798755617A 0.744s 2.936876798755617A 0.744000000001s 2.9188090273107195A 0.756s 2.9188090273107195A 0.756000000001s 2.9123723561529453A 0.768s 2.9123723561529453A 0.768000000001s 2.918622380448353A 0.78s 2.918622380448353A 0.780000000001s 2.911858143950959A 0.792s 2.911858143950959A 0.792000000001s 2.9235761107533316A 0.804s 2.9235761107533316A 0.804000000001s 2.2598479544559207A 0.8160000000000001s 2.2598479544559207A 0.816000000001s 3.2719788199026785A 0.8280000000000001s 3.2719788199026785A 0.828000000001s 3.2808324120346697A 0.84s 3.2808324120346697A 0.840000000001s 3.2778577750801654A 0.852s 3.2778577750801654A 0.852000000001s 3.27071762383954A 0.864s 3.27071762383954A 0.864000000001s 3.2706228429810302A 0.876s 3.2706228429810302A 0.876000000001s 3.2759482129803157A 0.888s 3.2759482129803157A 0.888000000001s 3.27238703525301A 0.9s 3.27238703525301A 0.900000000001s 3.274676265719406A 0.912s 3.274676265719406A 0.912000000001s 3.2761826205054927A 0.924s 3.2761826205054927A 0.924000000001s 2.313013756835751A 0.936s 2.313013756835751A 0.936000000001s 3.2277888369471754A 0.9480000000000001s 3.2277888369471754A 0.948000000001s 3.214897475530134A 0.96s 3.214897475530134A 0.9600000000009999s 3.244598597512849A 0.972s 3.244598597512849A 0.972000000001s 3.2306062715589885A 0.984s 3.2306062715589885A 0.984000000001s 3.230260457391429A 0.996s 3.230260457391429A 0.996000000001s 3.226594730623341A 1.008s 3.226594730623341A 1.008000000001s 3.2446553313975715A 1.02s 3.2446553313975715A 1.020000000001s 3.240309793850253A 1.032s 3.240309793850253A 1.0320000000010001s 3.214811397564274A 1.044s 3.214811397564274A 1.0440000000010001s 0.9819409654808442A 1.056s 0.9819409654808442A 1.0560000000010001s 0.8660148548487462A 1.068s 0.8660148548487462A 1.0680000000010001s 3.6790878145032426A 1.08s 3.6790878145032426A 1.0800000000010002s 3.688683777803008A 1.092s 3.688683777803008A 1.0920000000010002s 3.691335784796794A 1.104s 3.691335784796794A 1.1040000000010002s 3.673968377703014A 1.116s 3.673968377703014A 1.1160000000010002s 3.7079063317462966A 1.1280000000000001s 3.7079063317462966A 1.1280000000010002s 3.7073688199399975A 1.1400000000000001s 3.7073688199399975A 1.1400000000010002s 3.690346957753011A 1.1520000000000001s 3.690346957753011A 1.1520000000010002s 3.6994444413727523A 1.164s 3.6994444413727523A 1.164000000001s 3.7008730407013717A 1.176s 3.7008730407013717A 1.176000000001s 2.9721569803255043A 1.188s 2.9721569803255043A 1.188000000001s 3.2889154546459114A 1.2s 3.2889154546459114A 1.200000000001s 3.2676624928746087A 1.212s 3.2676624928746087A 1.212000000001s 3.273157828390644A 1.224s 3.273157828390644A 1.224000000001s 3.28330057589725A 1.236s 3.28330057589725A 1.236000000001s 3.2722299953215765A 1.248s 3.2722299953215765A 1.248000000001s 3.281242969526277A 1.26s 3.281242969526277A 1.260000000001s 3.271631502362503A 1.272s 3.271631502362503A 1.272000000001s 3.25899862807638A 1.284s 3.25899862807638A 1.2840000000010001s 3.2723262229224623A 1.296s 3.2723262229224623A 1.2960000000010001s 2.3127504465179163A 1.308s 2.3127504465179163A 1.3080000000010001s 2.907437525389428A 1.32s 2.907437525389428A 1.3200000000010002s 2.9048855316746933A 1.332s 2.9048855316746933A 1.3320000000010002s 2.910945639512705A 1.344s 2.910945639512705A 1.3440000000010002s 2.917927229284864A 1.356s 2.917927229284864A 1.3560000000010002s 2.9243475524674944A 1.368s 2.9243475524674944A 1.3680000000010002s 2.9080131183613593A 1.3800000000000001s 2.9080131183613593A 1.3800000000010002s 2.924939278647053A 1.3920000000000001s 2.924939278647053A 1.3920000000010002s 2.9237411665350606A 1.4040000000000001s 2.9237411665350606A 1.4040000000010002s 2.932831931457566A 1.416s 2.932831931457566A 1.416000000001s 2.9013110853751436A 1.428s 2.9013110853751436A 1.428000000001s 1.576879225113729A 1.44s 1.576879225113729A 1.440000000001s 0.8799400248166057A 1.452s 0.8799400248166057A 1.452000000001s 1.208421759264146A 1.464s 1.208421759264146A 1.464000000001s 3.6817620803871085A 1.476s 3.6817620803871085A 1.476000000001s 3.688960605652447A 1.488s 3.688960605652447A 1.488000000001s 3.6741138372844726A 1.5s 3.6741138372844726A 1.500000000001s 3.6831889711920516A 1.512s 3.6831889711920516A 1.512000000001s 3.6985857196357337A 1.524s 3.6985857196357337A 1.524000000001s 3.67332544816941A 1.536s 3.67332544816941A 1.5360000000010001s 3.67977530028283A 1.548s 3.67977530028283A 1.5480000000010001s 3.684752816357397A 1.56s 3.684752816357397A 1.5600000000010001s 3.6919534700649885A 1.572s 3.6919534700649885A 1.5720000000010002s 2.9100885301348036A 1.584s 2.9100885301348036A 1.5840000000010002s 3.2775769820453826A 1.596s 3.2775769820453826A 1.5960000000010002s 3.271287096471495A 1.608s 3.271287096471495A 1.6080000000010002s 3.2785553143302195A 1.62s 3.2785553143302195A 1.6200000000010002s 3.2836334537945433A 1.6320000000000001s 3.2836334537945433A 1.6320000000010002s 3.273660849174873A 1.6440000000000001s 3.273660849174873A 1.6440000000010002s 3.2782812239652452A 1.6560000000000001s 3.2782812239652452A 1.6560000000010002s 3.2583981637438324A 1.668s 3.2583981637438324A 1.668000000001s 3.2719367970585953A 1.68s 3.2719367970585953A 1.680000000001s 3.269118133677409A 1.692s 3.269118133677409A 1.692000000001s 2.2084526538116807A 1.704s 2.2084526538116807A 1.704000000001s 2.9095347152301536A 1.716s 2.9095347152301536A 1.716000000001s 2.931299082266794A 1.728s 2.931299082266794A 1.728000000001s 2.920461824693764A 1.74s 2.920461824693764A 1.740000000001s 2.8974231650494526A 1.752s 2.8974231650494526A 1.752000000001s 2.90472644771212A 1.764s 2.90472644771212A 1.764000000001s 2.9079802931231615A 1.776s 2.9079802931231615A 1.7760000000010001s 2.9256702970543094A 1.788s 2.9256702970543094A 1.7880000000010001s 2.922773072570344A 1.8s 2.922773072570344A 1.8000000000010001s 2.908676777768544A 1.812s 2.908676777768544A 1.8120000000010001s 2.905847771354716A 1.824s 2.905847771354716A 1.8240000000010002s 1.0000247034481322A 1.836s 1.0000247034481322A 1.8360000000010002s 0.8798164202340759A 1.848s 0.8798164202340759A 1.8480000000010002s 2.2137169988498933A 1.86s 2.2137169988498933A 1.8600000000010002s 3.6831980918662888A 1.872s 3.6831980918662888A 1.8720000000010002s 3.7110535524621384A)
R_0_6_5_1 Node0_6_5 Node0_6_6 9.887809523809517
R_0_6_5_2 Node0_6_5 Node0_7_5 13.02076502732239
R_0_6_5_3 Node0_6_5 Node1_6_5 2.5950185402029624
C_0_6_5 Node0_6_5 GND 0.0009924144753600012
I_0_6_6 GND Node0_6_6 PWL(0s 0A 0.012s 0A 0.012000000001s 6.246433627769448A 0.024s 6.246433627769448A 0.024000000001s 13.689700043711166A 0.036000000000000004s 13.689700043711166A 0.036000000001s 15.32060693509321A 0.048s 15.32060693509321A 0.048000000001s 16.536319816927367A 0.06s 16.536319816927367A 0.060000000000999996s 16.270627831086355A 0.07200000000000001s 16.270627831086355A 0.07200000000100001s 5.248782819215771A 0.084s 5.248782819215771A 0.08400000000100001s 12.923253659755735A 0.096s 12.923253659755735A 0.09600000000100001s 14.938717044439686A 0.108s 14.938717044439686A 0.108000000001s 16.503084752072A 0.12s 16.503084752072A 0.120000000001s 17.334791878980077A 0.132s 17.334791878980077A 0.132000000001s 4.956390865429613A 0.14400000000000002s 4.956390865429613A 0.14400000000100002s 12.22951544039426A 0.156s 12.22951544039426A 0.156000000001s 14.504886537613029A 0.168s 14.504886537613029A 0.16800000000100002s 16.235272731947724A 0.18s 16.235272731947724A 0.180000000001s 16.94252542902936A 0.192s 16.94252542902936A 0.192000000001s 7.57053387560317A 0.20400000000000001s 7.57053387560317A 0.20400000000100002s 7.770833531022072A 0.216s 7.770833531022072A 0.216000000001s 13.723055988686529A 0.228s 13.723055988686529A 0.228000000001s 15.582381055753164A 0.24s 15.582381055753164A 0.240000000001s 16.449902848767955A 0.252s 16.449902848767955A 0.252000000001s 14.186980831266341A 0.264s 14.186980831266341A 0.264000000001s 5.391752121705595A 0.276s 5.391752121705595A 0.276000000001s 12.849681642099851A 0.28800000000000003s 12.849681642099851A 0.288000000001s 15.57943092583673A 0.3s 15.57943092583673A 0.30000000000099997s 15.98395761717592A 0.312s 15.98395761717592A 0.312000000001s 17.534368595911722A 0.324s 17.534368595911722A 0.324000000001s 4.156978396948789A 0.336s 4.156978396948789A 0.336000000001s 12.1925719268738A 0.34800000000000003s 12.1925719268738A 0.348000000001s 14.516864673803305A 0.36s 14.516864673803305A 0.36000000000099996s 15.99784456426827A 0.372s 15.99784456426827A 0.372000000001s 17.33579029749304A 0.384s 17.33579029749304A 0.384000000001s 6.877292828592243A 0.396s 6.877292828592243A 0.396000000001s 6.680923017201632A 0.40800000000000003s 6.680923017201632A 0.408000000001s 13.749219213096211A 0.42s 13.749219213096211A 0.42000000000099996s 15.374942350357834A 0.432s 15.374942350357834A 0.432000000001s 16.84550588029998A 0.444s 16.84550588029998A 0.444000000001s 14.168031641739876A 0.456s 14.168031641739876A 0.456000000001s 5.46965406182987A 0.468s 5.46965406182987A 0.468000000001s 12.875990386080998A 0.48s 12.875990386080998A 0.48000000000099996s 15.335044323599746A 0.492s 15.335044323599746A 0.49200000000099997s 16.23634535741162A 0.504s 16.23634535741162A 0.504000000001s 17.115060743226916A 0.516s 17.115060743226916A 0.516000000001s 4.812536215710306A 0.528s 4.812536215710306A 0.528000000001s 11.787998880239986A 0.54s 11.787998880239986A 0.540000000001s 14.697804324628246A 0.552s 14.697804324628246A 0.552000000001s 15.657218138384405A 0.5640000000000001s 15.657218138384405A 0.564000000001s 17.145479039040076A 0.5760000000000001s 17.145479039040076A 0.576000000001s 7.219813079271477A 0.588s 7.219813079271477A 0.588000000001s 7.807537998782948A 0.6s 7.807537998782948A 0.600000000001s 14.042257309415044A 0.612s 14.042257309415044A 0.612000000001s 15.642705831892012A 0.624s 15.642705831892012A 0.624000000001s 16.46572500288837A 0.636s 16.46572500288837A 0.636000000001s 12.44545768433683A 0.648s 12.44545768433683A 0.648000000001s 5.6048949793186225A 0.66s 5.6048949793186225A 0.660000000001s 13.102327776610245A 0.672s 13.102327776610245A 0.672000000001s 11.084077607645169A 0.684s 11.084077607645169A 0.684000000001s 11.237783516605958A 0.6960000000000001s 11.237783516605958A 0.696000000001s 11.163861749235057A 0.708s 11.163861749235057A 0.7080000000009999s 11.060104006925222A 0.72s 11.060104006925222A 0.720000000001s 11.108909419155776A 0.732s 11.108909419155776A 0.732000000001s 11.217979767662314A 0.744s 11.217979767662314A 0.744000000001s 11.1472545874609A 0.756s 11.1472545874609A 0.756000000001s 11.122058634051857A 0.768s 11.122058634051857A 0.768000000001s 11.146523969796446A 0.78s 11.146523969796446A 0.780000000001s 11.120045782009857A 0.792s 11.120045782009857A 0.792000000001s 11.165915042434115A 0.804s 11.165915042434115A 0.804000000001s 8.567791992114847A 0.8160000000000001s 8.567791992114847A 0.816000000001s 12.529716021564177A 0.8280000000000001s 12.529716021564177A 0.828000000001s 12.564372863492611A 0.84s 12.564372863492611A 0.840000000001s 12.552728830066425A 0.852s 12.552728830066425A 0.852000000001s 12.524779147135208A 0.864s 12.524779147135208A 0.864000000001s 12.524408133293338A 0.876s 12.524408133293338A 0.876000000001s 12.545253966659525A 0.888s 12.545253966659525A 0.888000000001s 12.531313955448898A 0.9s 12.531313955448898A 0.900000000001s 12.540275007328049A 0.912s 12.540275007328049A 0.912000000001s 12.546171540501394A 0.924s 12.546171540501394A 0.924000000001s 8.775906255976002A 0.936s 8.775906255976002A 0.936000000001s 12.356737050850656A 0.9480000000000001s 12.356737050850656A 0.948000000001s 12.306274609367906A 0.96s 12.306274609367906A 0.9600000000009999s 12.422537824829655A 0.972s 12.422537824829655A 0.972000000001s 12.367765725373905A 0.984s 12.367765725373905A 0.984000000001s 12.36641205708164A 0.996s 12.36641205708164A 0.996000000001s 12.352062795080354A 1.008s 12.352062795080354A 1.008000000001s 12.42275990613242A 1.02s 12.42275990613242A 1.020000000001s 12.405749566642385A 1.032s 12.405749566642385A 1.0320000000010001s 12.305937662464112A 1.044s 12.305937662464112A 1.0440000000010001s 3.565503671634884A 1.056s 3.565503671634884A 1.0560000000010001s 3.111718040711378A 1.068s 3.111718040711378A 1.0680000000010001s 14.123318687225199A 1.08s 14.123318687225199A 1.0800000000010002s 14.160881495436044A 1.092s 14.160881495436044A 1.0920000000010002s 14.17126261372188A 1.104s 14.17126261372188A 1.1040000000010002s 14.10327896670238A 1.116s 14.10327896670238A 1.1160000000010002s 14.236127000711377A 1.1280000000000001s 14.236127000711377A 1.1280000000010002s 14.234022943801158A 1.1400000000000001s 14.234022943801158A 1.1400000000010002s 14.167391911069213A 1.1520000000000001s 14.167391911069213A 1.1520000000010002s 14.20300345122777A 1.164s 14.20300345122777A 1.164000000001s 14.208595615444613A 1.176s 14.208595615444613A 1.176000000001s 11.356081868780805A 1.188s 11.356081868780805A 1.188000000001s 12.596013436708809A 1.2s 12.596013436708809A 1.200000000001s 12.512820024855369A 1.212s 12.512820024855369A 1.212000000001s 12.534331177784448A 1.224s 12.534331177784448A 1.224000000001s 12.574034339147207A 1.236s 12.574034339147207A 1.236000000001s 12.530699232294838A 1.248s 12.530699232294838A 1.248000000001s 12.56597996554532A 1.26s 12.56597996554532A 1.260000000001s 12.528356468412259A 1.272s 12.528356468412259A 1.272000000001s 12.478905858907224A 1.284s 12.478905858907224A 1.2840000000010001s 12.531075909320766A 1.296s 12.531075909320766A 1.2960000000010001s 8.774875543929717A 1.308s 8.774875543929717A 1.3080000000010001s 11.102741542506964A 1.32s 11.102741542506964A 1.3200000000010002s 11.092751920051427A 1.332s 11.092751920051427A 1.3320000000010002s 11.116473839502895A 1.344s 11.116473839502895A 1.3440000000010002s 11.143802843316909A 1.356s 11.143802843316909A 1.3560000000010002s 11.168934803582605A 1.368s 11.168934803582605A 1.3680000000010002s 11.104994665798161A 1.3800000000000001s 11.104994665798161A 1.3800000000010002s 11.171251079322907A 1.3920000000000001s 11.171251079322907A 1.3920000000010002s 11.166561143141207A 1.4040000000000001s 11.166561143141207A 1.4040000000010002s 11.202146383372618A 1.416s 11.202146383372618A 1.416000000001s 11.078759969830728A 1.428s 11.078759969830728A 1.428000000001s 5.89435290185558A 1.44s 5.89435290185558A 1.440000000001s 3.1662272621898437A 1.452s 3.1662272621898437A 1.452000000001s 4.452048810936361A 1.464s 4.452048810936361A 1.464000000001s 14.133786936567391A 1.476s 14.133786936567391A 1.476000000001s 14.161965121028498A 1.488s 14.161965121028498A 1.488000000001s 14.103848359288623A 1.5s 14.103848359288623A 1.500000000001s 14.13937241287337A 1.512s 14.13937241287337A 1.512000000001s 14.199642037797302A 1.524s 14.199642037797302A 1.524000000001s 14.100762258581533A 1.536s 14.100762258581533A 1.5360000000010001s 14.126009808030858A 1.548s 14.126009808030858A 1.5480000000010001s 14.145493988600819A 1.56s 14.145493988600819A 1.5600000000010001s 14.173680504718236A 1.572s 14.173680504718236A 1.5720000000010002s 11.113118737553034A 1.584s 11.113118737553034A 1.5840000000010002s 12.551629682999788A 1.596s 12.551629682999788A 1.5960000000010002s 12.527008312731951A 1.608s 12.527008312731951A 1.6080000000010002s 12.55545930456396A 1.62s 12.55545930456396A 1.6200000000010002s 12.575337369205059A 1.6320000000000001s 12.575337369205059A 1.6320000000010002s 12.536300221709881A 1.6440000000000001s 12.536300221709881A 1.6440000000010002s 12.554386394686096A 1.6560000000000001s 12.554386394686096A 1.6560000000010002s 12.476555378204417A 1.668s 12.476555378204417A 1.668000000001s 12.529551525725308A 1.68s 12.529551525725308A 1.680000000001s 12.518518041259913A 1.692s 12.518518041259913A 1.692000000001s 8.36660824841654A 1.704s 8.36660824841654A 1.704000000001s 11.110950863166918A 1.716s 11.110950863166918A 1.716000000001s 11.196146139481467A 1.728s 11.196146139481467A 1.728000000001s 11.153724361174206A 1.74s 11.153724361174206A 1.740000000001s 11.063540944812518A 1.752s 11.063540944812518A 1.752000000001s 11.09212919566317A 1.764s 11.09212919566317A 1.764000000001s 11.1048661734219A 1.776s 11.1048661734219A 1.7760000000010001s 11.174112605922435A 1.788s 11.174112605922435A 1.7880000000010001s 11.162771598851512A 1.8s 11.162771598851512A 1.8000000000010001s 11.107592519734308A 1.812s 11.107592519734308A 1.8120000000010001s 11.096518548103708A 1.824s 11.096518548103708A 1.8240000000010002s 3.636291351806299A 1.836s 3.636291351806299A 1.8360000000010002s 3.1657434196528826A 1.848s 3.1657434196528826A 1.8480000000010002s 8.387215203325479A 1.86s 8.387215203325479A 1.8600000000010002s 14.139408115191776A 1.872s 14.139408115191776A 1.8720000000010002s 14.248446145069643A)
R_0_6_6_1 Node0_6_6 Node0_6_7 9.887809523809524
R_0_6_6_2 Node0_6_6 Node0_7_6 13.020765027322408
R_0_6_6_3 Node0_6_6 Node1_6_6 2.595018540202966
C_0_6_6 Node0_6_6 GND 0.00099241447536
I_0_6_7 GND Node0_6_7 PWL(0s 0A 0.012s 0A 0.012000000001s 6.246433627769448A 0.024s 6.246433627769448A 0.024000000001s 13.689700043711166A 0.036000000000000004s 13.689700043711166A 0.036000000001s 15.32060693509321A 0.048s 15.32060693509321A 0.048000000001s 16.536319816927367A 0.06s 16.536319816927367A 0.060000000000999996s 16.270627831086355A 0.07200000000000001s 16.270627831086355A 0.07200000000100001s 5.248782819215771A 0.084s 5.248782819215771A 0.08400000000100001s 12.923253659755735A 0.096s 12.923253659755735A 0.09600000000100001s 14.938717044439686A 0.108s 14.938717044439686A 0.108000000001s 16.503084752072A 0.12s 16.503084752072A 0.120000000001s 17.334791878980077A 0.132s 17.334791878980077A 0.132000000001s 4.956390865429613A 0.14400000000000002s 4.956390865429613A 0.14400000000100002s 12.22951544039426A 0.156s 12.22951544039426A 0.156000000001s 14.504886537613029A 0.168s 14.504886537613029A 0.16800000000100002s 16.235272731947724A 0.18s 16.235272731947724A 0.180000000001s 16.94252542902936A 0.192s 16.94252542902936A 0.192000000001s 7.57053387560317A 0.20400000000000001s 7.57053387560317A 0.20400000000100002s 7.770833531022072A 0.216s 7.770833531022072A 0.216000000001s 13.723055988686529A 0.228s 13.723055988686529A 0.228000000001s 15.582381055753164A 0.24s 15.582381055753164A 0.240000000001s 16.449902848767955A 0.252s 16.449902848767955A 0.252000000001s 14.186980831266341A 0.264s 14.186980831266341A 0.264000000001s 5.391752121705595A 0.276s 5.391752121705595A 0.276000000001s 12.849681642099851A 0.28800000000000003s 12.849681642099851A 0.288000000001s 15.57943092583673A 0.3s 15.57943092583673A 0.30000000000099997s 15.98395761717592A 0.312s 15.98395761717592A 0.312000000001s 17.534368595911722A 0.324s 17.534368595911722A 0.324000000001s 4.156978396948789A 0.336s 4.156978396948789A 0.336000000001s 12.1925719268738A 0.34800000000000003s 12.1925719268738A 0.348000000001s 14.516864673803305A 0.36s 14.516864673803305A 0.36000000000099996s 15.99784456426827A 0.372s 15.99784456426827A 0.372000000001s 17.33579029749304A 0.384s 17.33579029749304A 0.384000000001s 6.877292828592243A 0.396s 6.877292828592243A 0.396000000001s 6.680923017201632A 0.40800000000000003s 6.680923017201632A 0.408000000001s 13.749219213096211A 0.42s 13.749219213096211A 0.42000000000099996s 15.374942350357834A 0.432s 15.374942350357834A 0.432000000001s 16.84550588029998A 0.444s 16.84550588029998A 0.444000000001s 14.168031641739876A 0.456s 14.168031641739876A 0.456000000001s 5.46965406182987A 0.468s 5.46965406182987A 0.468000000001s 12.875990386080998A 0.48s 12.875990386080998A 0.48000000000099996s 15.335044323599746A 0.492s 15.335044323599746A 0.49200000000099997s 16.23634535741162A 0.504s 16.23634535741162A 0.504000000001s 17.115060743226916A 0.516s 17.115060743226916A 0.516000000001s 4.812536215710306A 0.528s 4.812536215710306A 0.528000000001s 11.787998880239986A 0.54s 11.787998880239986A 0.540000000001s 14.697804324628246A 0.552s 14.697804324628246A 0.552000000001s 15.657218138384405A 0.5640000000000001s 15.657218138384405A 0.564000000001s 17.145479039040076A 0.5760000000000001s 17.145479039040076A 0.576000000001s 7.219813079271477A 0.588s 7.219813079271477A 0.588000000001s 7.807537998782948A 0.6s 7.807537998782948A 0.600000000001s 14.042257309415044A 0.612s 14.042257309415044A 0.612000000001s 15.642705831892012A 0.624s 15.642705831892012A 0.624000000001s 16.46572500288837A 0.636s 16.46572500288837A 0.636000000001s 12.44545768433683A 0.648s 12.44545768433683A 0.648000000001s 5.6048949793186225A 0.66s 5.6048949793186225A 0.660000000001s 13.102327776610245A 0.672s 13.102327776610245A 0.672000000001s 11.084077607645169A 0.684s 11.084077607645169A 0.684000000001s 11.237783516605958A 0.6960000000000001s 11.237783516605958A 0.696000000001s 11.163861749235057A 0.708s 11.163861749235057A 0.7080000000009999s 11.060104006925222A 0.72s 11.060104006925222A 0.720000000001s 11.108909419155776A 0.732s 11.108909419155776A 0.732000000001s 11.217979767662314A 0.744s 11.217979767662314A 0.744000000001s 11.1472545874609A 0.756s 11.1472545874609A 0.756000000001s 11.122058634051857A 0.768s 11.122058634051857A 0.768000000001s 11.146523969796446A 0.78s 11.146523969796446A 0.780000000001s 11.120045782009857A 0.792s 11.120045782009857A 0.792000000001s 11.165915042434115A 0.804s 11.165915042434115A 0.804000000001s 8.567791992114847A 0.8160000000000001s 8.567791992114847A 0.816000000001s 12.529716021564177A 0.8280000000000001s 12.529716021564177A 0.828000000001s 12.564372863492611A 0.84s 12.564372863492611A 0.840000000001s 12.552728830066425A 0.852s 12.552728830066425A 0.852000000001s 12.524779147135208A 0.864s 12.524779147135208A 0.864000000001s 12.524408133293338A 0.876s 12.524408133293338A 0.876000000001s 12.545253966659525A 0.888s 12.545253966659525A 0.888000000001s 12.531313955448898A 0.9s 12.531313955448898A 0.900000000001s 12.540275007328049A 0.912s 12.540275007328049A 0.912000000001s 12.546171540501394A 0.924s 12.546171540501394A 0.924000000001s 8.775906255976002A 0.936s 8.775906255976002A 0.936000000001s 12.356737050850656A 0.9480000000000001s 12.356737050850656A 0.948000000001s 12.306274609367906A 0.96s 12.306274609367906A 0.9600000000009999s 12.422537824829655A 0.972s 12.422537824829655A 0.972000000001s 12.367765725373905A 0.984s 12.367765725373905A 0.984000000001s 12.36641205708164A 0.996s 12.36641205708164A 0.996000000001s 12.352062795080354A 1.008s 12.352062795080354A 1.008000000001s 12.42275990613242A 1.02s 12.42275990613242A 1.020000000001s 12.405749566642385A 1.032s 12.405749566642385A 1.0320000000010001s 12.305937662464112A 1.044s 12.305937662464112A 1.0440000000010001s 3.565503671634884A 1.056s 3.565503671634884A 1.0560000000010001s 3.111718040711378A 1.068s 3.111718040711378A 1.0680000000010001s 14.123318687225199A 1.08s 14.123318687225199A 1.0800000000010002s 14.160881495436044A 1.092s 14.160881495436044A 1.0920000000010002s 14.17126261372188A 1.104s 14.17126261372188A 1.1040000000010002s 14.10327896670238A 1.116s 14.10327896670238A 1.1160000000010002s 14.236127000711377A 1.1280000000000001s 14.236127000711377A 1.1280000000010002s 14.234022943801158A 1.1400000000000001s 14.234022943801158A 1.1400000000010002s 14.167391911069213A 1.1520000000000001s 14.167391911069213A 1.1520000000010002s 14.20300345122777A 1.164s 14.20300345122777A 1.164000000001s 14.208595615444613A 1.176s 14.208595615444613A 1.176000000001s 11.356081868780805A 1.188s 11.356081868780805A 1.188000000001s 12.596013436708809A 1.2s 12.596013436708809A 1.200000000001s 12.512820024855369A 1.212s 12.512820024855369A 1.212000000001s 12.534331177784448A 1.224s 12.534331177784448A 1.224000000001s 12.574034339147207A 1.236s 12.574034339147207A 1.236000000001s 12.530699232294838A 1.248s 12.530699232294838A 1.248000000001s 12.56597996554532A 1.26s 12.56597996554532A 1.260000000001s 12.528356468412259A 1.272s 12.528356468412259A 1.272000000001s 12.478905858907224A 1.284s 12.478905858907224A 1.2840000000010001s 12.531075909320766A 1.296s 12.531075909320766A 1.2960000000010001s 8.774875543929717A 1.308s 8.774875543929717A 1.3080000000010001s 11.102741542506964A 1.32s 11.102741542506964A 1.3200000000010002s 11.092751920051427A 1.332s 11.092751920051427A 1.3320000000010002s 11.116473839502895A 1.344s 11.116473839502895A 1.3440000000010002s 11.143802843316909A 1.356s 11.143802843316909A 1.3560000000010002s 11.168934803582605A 1.368s 11.168934803582605A 1.3680000000010002s 11.104994665798161A 1.3800000000000001s 11.104994665798161A 1.3800000000010002s 11.171251079322907A 1.3920000000000001s 11.171251079322907A 1.3920000000010002s 11.166561143141207A 1.4040000000000001s 11.166561143141207A 1.4040000000010002s 11.202146383372618A 1.416s 11.202146383372618A 1.416000000001s 11.078759969830728A 1.428s 11.078759969830728A 1.428000000001s 5.89435290185558A 1.44s 5.89435290185558A 1.440000000001s 3.1662272621898437A 1.452s 3.1662272621898437A 1.452000000001s 4.452048810936361A 1.464s 4.452048810936361A 1.464000000001s 14.133786936567391A 1.476s 14.133786936567391A 1.476000000001s 14.161965121028498A 1.488s 14.161965121028498A 1.488000000001s 14.103848359288623A 1.5s 14.103848359288623A 1.500000000001s 14.13937241287337A 1.512s 14.13937241287337A 1.512000000001s 14.199642037797302A 1.524s 14.199642037797302A 1.524000000001s 14.100762258581533A 1.536s 14.100762258581533A 1.5360000000010001s 14.126009808030858A 1.548s 14.126009808030858A 1.5480000000010001s 14.145493988600819A 1.56s 14.145493988600819A 1.5600000000010001s 14.173680504718236A 1.572s 14.173680504718236A 1.5720000000010002s 11.113118737553034A 1.584s 11.113118737553034A 1.5840000000010002s 12.551629682999788A 1.596s 12.551629682999788A 1.5960000000010002s 12.527008312731951A 1.608s 12.527008312731951A 1.6080000000010002s 12.55545930456396A 1.62s 12.55545930456396A 1.6200000000010002s 12.575337369205059A 1.6320000000000001s 12.575337369205059A 1.6320000000010002s 12.536300221709881A 1.6440000000000001s 12.536300221709881A 1.6440000000010002s 12.554386394686096A 1.6560000000000001s 12.554386394686096A 1.6560000000010002s 12.476555378204417A 1.668s 12.476555378204417A 1.668000000001s 12.529551525725308A 1.68s 12.529551525725308A 1.680000000001s 12.518518041259913A 1.692s 12.518518041259913A 1.692000000001s 8.36660824841654A 1.704s 8.36660824841654A 1.704000000001s 11.110950863166918A 1.716s 11.110950863166918A 1.716000000001s 11.196146139481467A 1.728s 11.196146139481467A 1.728000000001s 11.153724361174206A 1.74s 11.153724361174206A 1.740000000001s 11.063540944812518A 1.752s 11.063540944812518A 1.752000000001s 11.09212919566317A 1.764s 11.09212919566317A 1.764000000001s 11.1048661734219A 1.776s 11.1048661734219A 1.7760000000010001s 11.174112605922435A 1.788s 11.174112605922435A 1.7880000000010001s 11.162771598851512A 1.8s 11.162771598851512A 1.8000000000010001s 11.107592519734308A 1.812s 11.107592519734308A 1.8120000000010001s 11.096518548103708A 1.824s 11.096518548103708A 1.8240000000010002s 3.636291351806299A 1.836s 3.636291351806299A 1.8360000000010002s 3.1657434196528826A 1.848s 3.1657434196528826A 1.8480000000010002s 8.387215203325479A 1.86s 8.387215203325479A 1.8600000000010002s 14.139408115191776A 1.872s 14.139408115191776A 1.8720000000010002s 14.248446145069643A)
R_0_6_7_1 Node0_6_7 Node0_6_8 9.88780952380953
R_0_6_7_2 Node0_6_7 Node0_7_7 13.020765027322408
R_0_6_7_3 Node0_6_7 Node1_6_7 2.595018540202966
C_0_6_7 Node0_6_7 GND 0.00099241447536
I_0_6_8 GND Node0_6_8 PWL(0s 0A 0.012s 0A 0.012000000001s 1.2288066152989006A 0.024s 1.2288066152989006A 0.024000000001s 2.6930557463038203A 0.036000000000000004s 2.6930557463038203A 0.036000000001s 3.0138898888707777A 0.048s 3.0138898888707777A 0.048000000001s 3.2530465213627417A 0.06s 3.2530465213627417A 0.060000000000999996s 3.2007792454595916A 0.07200000000000001s 3.2007792454595916A 0.07200000000100001s 1.0325474398457193A 0.084s 1.0325474398457193A 0.08400000000100001s 2.542279408476523A 0.096s 2.542279408476523A 0.09600000000100001s 2.938764008742216A 0.108s 2.938764008742216A 0.108000000001s 3.2465084758174236A 0.12s 3.2465084758174236A 0.120000000001s 3.410122992586224A 0.132s 3.410122992586224A 0.132000000001s 0.9750277112320493A 0.14400000000000002s 0.9750277112320493A 0.14400000000100002s 2.405806316143119A 0.156s 2.405806316143119A 0.156000000001s 2.853420302481235A 0.168s 2.853420302481235A 0.16800000000100002s 3.1938241439896973A 0.18s 3.1938241439896973A 0.180000000001s 3.332955822104117A 0.192s 3.332955822104117A 0.192000000001s 1.4892853525776641A 0.20400000000000001s 1.4892853525776641A 0.20400000000100002s 1.5286885634797431A 0.216s 1.5286885634797431A 0.216000000001s 2.699617571544875A 0.228s 2.699617571544875A 0.228000000001s 3.0653864371973256A 0.24s 3.0653864371973256A 0.240000000001s 3.236046462052693A 0.252s 3.236046462052693A 0.252000000001s 2.7908814750031983A 0.264s 2.7908814750031983A 0.264000000001s 1.060672548532242A 0.276s 1.060672548532242A 0.276000000001s 2.527806224675366A 0.28800000000000003s 2.527806224675366A 0.288000000001s 3.064806083771142A 0.3s 3.064806083771142A 0.30000000000099997s 3.1443851050181952A 0.312s 3.1443851050181952A 0.312000000001s 3.4493839860809747A 0.324s 3.4493839860809747A 0.324000000001s 0.8177662420227079A 0.336s 0.8177662420227079A 0.336000000001s 2.3985387397128646A 0.34800000000000003s 2.3985387397128646A 0.348000000001s 2.8557766571416168A 0.36s 2.8557766571416168A 0.36000000000099996s 3.1471169634625924A 0.372s 3.1471169634625924A 0.372000000001s 3.410319402785496A 0.384s 3.410319402785496A 0.384000000001s 1.352910064641089A 0.396s 1.352910064641089A 0.396000000001s 1.3142799378101493A 0.40800000000000003s 1.3142799378101493A 0.408000000001s 2.704764435363173A 0.42s 2.704764435363173A 0.42000000000099996s 3.024578823021196A 0.432s 3.024578823021196A 0.432000000001s 3.3138700092393214A 0.444s 3.3138700092393214A 0.444000000001s 2.7871537655881564A 0.456s 2.7871537655881564A 0.456000000001s 1.075997520359968A 0.468s 1.075997520359968A 0.468000000001s 2.5329817152946075A 0.48s 2.5329817152946075A 0.48000000000099996s 3.0167300308720635A 0.492s 3.0167300308720635A 0.49200000000099997s 3.1940351522776766A 0.504s 3.1940351522776766A 0.504000000001s 3.3668971953888813A 0.516s 3.3668971953888813A 0.516000000001s 0.9467284358774317A 0.528s 0.9467284358774317A 0.528000000001s 2.318950599391459A 0.54s 2.318950599391459A 0.540000000001s 2.8913713425498018A 0.552s 2.8913713425498018A 0.552000000001s 3.0801084862395367A 0.5640000000000001s 3.0801084862395367A 0.564000000001s 3.3728811224340935A 0.5760000000000001s 3.3728811224340935A 0.576000000001s 1.4202910975615937A 0.588s 1.4202910975615937A 0.588000000001s 1.5359091145146693A 0.6s 1.5359091145146693A 0.600000000001s 2.7624112739832714A 0.612s 2.7624112739832714A 0.612000000001s 3.0772536062738203A 0.624s 3.0772536062738203A 0.624000000001s 3.239159016961627A 0.636s 3.239159016961627A 0.636000000001s 2.4482867575744445A 0.648s 2.4482867575744445A 0.648000000001s 1.102602291013493A 0.66s 1.102602291013493A 0.660000000001s 2.577507103595443A 0.672s 2.577507103595443A 0.672000000001s 2.180474283471168A 0.684s 2.180474283471168A 0.684000000001s 2.210711511463454A 0.6960000000000001s 2.210711511463454A 0.696000000001s 2.19616952443967A 0.708s 2.19616952443967A 0.7080000000009999s 2.1757581652967524A 0.72s 2.1757581652967524A 0.720000000001s 2.185359229997845A 0.732s 2.185359229997845A 0.732000000001s 2.2068156919991306A 0.744s 2.2068156919991306A 0.744000000001s 2.192902541795574A 0.756s 2.192902541795574A 0.756000000001s 2.187945960797074A 0.768s 2.187945960797074A 0.768000000001s 2.1927588137304355A 0.78s 2.1927588137304355A 0.780000000001s 2.187549989903566A 0.792s 2.187549989903566A 0.792000000001s 2.1965734509706327A 0.804s 2.1965734509706327A 0.804000000001s 1.6854672771373371A 0.8160000000000001s 1.6854672771373371A 0.816000000001s 2.464862168176545A 0.8280000000000001s 2.464862168176545A 0.828000000001s 2.4716799075723026A 0.84s 2.4716799075723026A 0.840000000001s 2.4693892780458397A 0.852s 2.4693892780458397A 0.852000000001s 2.4638909797642885A 0.864s 2.4638909797642885A 0.864000000001s 2.463817993434741A 0.876s 2.463817993434741A 0.876000000001s 2.467918813113335A 0.888s 2.467918813113335A 0.888000000001s 2.4651765158259984A 0.9s 2.4651765158259984A 0.900000000001s 2.466939345703864A 0.912s 2.466939345703864A 0.912000000001s 2.468099319442883A 0.924s 2.468099319442883A 0.924000000001s 1.7264077880608428A 0.936s 1.7264077880608428A 0.936000000001s 2.430833518200115A 0.9480000000000001s 2.430833518200115A 0.948000000001s 2.420906480531377A 0.96s 2.420906480531377A 0.9600000000009999s 2.4437779327533606A 0.972s 2.4437779327533606A 0.972000000001s 2.433003093516164A 0.984s 2.433003093516164A 0.984000000001s 2.432736798114407A 0.996s 2.432736798114407A 0.996000000001s 2.4299139924748094A 1.008s 2.4299139924748094A 1.008000000001s 2.4438216208784946A 1.02s 2.4438216208784946A 1.020000000001s 2.440475324585373A 1.032s 2.440475324585373A 1.0320000000010001s 2.420840195894565A 1.044s 2.420840195894565A 1.0440000000010001s 0.7014105583543992A 1.056s 0.7014105583543992A 1.0560000000010001s 0.6121412539104314A 1.068s 0.6121412539104314A 1.0680000000010001s 2.778357774536089A 1.08s 2.778357774536089A 1.0800000000010002s 2.785747179430025A 1.092s 2.785747179430025A 1.0920000000010002s 2.7877893666337963A 1.104s 2.7877893666337963A 1.1040000000010002s 2.774415534433239A 1.116s 2.774415534433239A 1.1160000000010002s 2.800549573910419A 1.1280000000000001s 2.800549573910419A 1.1280000000010002s 2.8001356610756214A 1.1400000000000001s 2.8001356610756214A 1.1400000000010002s 2.787027916931632A 1.1520000000000001s 2.787027916931632A 1.1520000000010002s 2.794033465815283A 1.164s 2.794033465815283A 1.164000000001s 2.795133563694006A 1.176s 2.795133563694006A 1.176000000001s 2.2339833184486695A 1.188s 2.2339833184486695A 1.188000000001s 2.4779042826312265A 1.2s 2.4779042826312265A 1.200000000001s 2.4615383655453043A 1.212s 2.4615383655453043A 1.212000000001s 2.4657700677608605A 1.224s 2.4657700677608605A 1.224000000001s 2.473580525733862A 1.236s 2.473580525733862A 1.236000000001s 2.465055586680937A 1.248s 2.465055586680937A 1.248000000001s 2.4719960587957868A 1.26s 2.4719960587957868A 1.260000000001s 2.464594715097479A 1.272s 2.464594715097479A 1.272000000001s 2.45486672634239A 1.284s 2.45486672634239A 1.2840000000010001s 2.46512968707948A 1.296s 2.46512968707948A 1.2960000000010001s 1.7262050250353442A 1.308s 1.7262050250353442A 1.3080000000010001s 2.1841458772144717A 1.32s 2.1841458772144717A 1.3200000000010002s 2.1821807055838742A 1.332s 2.1821807055838742A 1.3320000000010002s 2.186847312689081A 1.344s 2.186847312689081A 1.3440000000010002s 2.1922235101606904A 1.356s 2.1922235101606904A 1.3560000000010002s 2.197167502344106A 1.368s 2.197167502344106A 1.3680000000010002s 2.1845891145832317A 1.3800000000000001s 2.1845891145832317A 1.3800000000010002s 2.1976231631454772A 1.3920000000000001s 2.1976231631454772A 1.3920000000010002s 2.196700552749077A 1.4040000000000001s 2.196700552749077A 1.4040000000010002s 2.2037009278765676A 1.416s 2.2037009278765676A 1.416000000001s 2.17942819078636A 1.428s 2.17942819078636A 1.428000000001s 1.1595448331519107A 1.44s 1.1595448331519107A 1.440000000001s 0.6228643794471788A 1.452s 0.6228643794471788A 1.452000000001s 0.8758128808399348A 1.464s 0.8758128808399348A 1.464000000001s 2.780417102275536A 1.476s 2.780417102275536A 1.476000000001s 2.7859603516777214A 1.488s 2.7859603516777214A 1.488000000001s 2.774527546089549A 1.5s 2.774527546089549A 1.500000000001s 2.781515884499663A 1.512s 2.781515884499663A 1.512000000001s 2.79337220415683A 1.524s 2.79337220415683A 1.524000000001s 2.7739204443111047A 1.536s 2.7739204443111047A 1.5360000000010001s 2.7788871753503166A 1.548s 2.7788871753503166A 1.5480000000010001s 2.782720128905063A 1.56s 2.782720128905063A 1.5600000000010001s 2.7882650173216037A 1.572s 2.7882650173216037A 1.5720000000010002s 2.1861872926333707A 1.584s 2.1861872926333707A 1.5840000000010002s 2.4691730523933866A 1.596s 2.4691730523933866A 1.5960000000010002s 2.4643295041439757A 1.608s 2.4643295041439757A 1.6080000000010002s 2.469926420569945A 1.62s 2.469926420569945A 1.6200000000010002s 2.473836859515735A 1.6320000000000001s 2.473836859515735A 1.6320000000010002s 2.4661574206642243A 1.6440000000000001s 2.4661574206642243A 1.6440000000010002s 2.4697153563316765A 1.6560000000000001s 2.4697153563316765A 1.6560000000010002s 2.4544043366959363A 1.668s 2.4544043366959363A 1.668000000001s 2.46482980833939A 1.68s 2.46482980833939A 1.680000000001s 2.462659286805214A 1.692s 2.462659286805214A 1.692000000001s 1.6458901472294736A 1.704s 1.6458901472294736A 1.704000000001s 2.1857608255410206A 1.716s 2.1857608255410206A 1.716000000001s 2.2025205520291284A 1.728s 2.2025205520291284A 1.728000000001s 2.1941752841654045A 1.74s 2.1941752841654045A 1.740000000001s 2.1764342842254005A 1.752s 2.1764342842254005A 1.752000000001s 2.182058202425529A 1.764s 2.182058202425529A 1.764000000001s 2.1845638373944594A 1.776s 2.1845638373944594A 1.7760000000010001s 2.198186086410958A 1.788s 2.198186086410958A 1.7880000000010001s 2.195955068626514A 1.8s 2.195955068626514A 1.8000000000010001s 2.185100167816572A 1.812s 2.185100167816572A 1.8120000000010001s 2.1829216815941592A 1.824s 2.1829216815941592A 1.8240000000010002s 0.7153360036340219A 1.836s 0.7153360036340219A 1.8360000000010002s 0.6227691973087601A 1.848s 0.6227691973087601A 1.8480000000010002s 1.6499439744246744A 1.86s 1.6499439744246744A 1.8600000000010002s 2.781522907906562A 1.872s 2.781522907906562A 1.8720000000010002s 2.802973012144831A)
R_0_6_8_1 Node0_6_8 Node0_6_9 9.88780952380953
R_0_6_8_2 Node0_6_8 Node0_7_8 13.020765027322419
R_0_6_8_3 Node0_6_8 Node1_6_8 2.5950185402029686
C_0_6_8 Node0_6_8 GND 0.0009924144753599988
R_0_6_9_2 Node0_6_9 Node0_7_9 13.020765027322408
R_0_6_9_3 Node0_6_9 Node1_6_9 2.595018540202966
C_0_6_9 Node0_6_9 GND 0.00099241447536
I_0_7_0 GND Node0_7_0 PWL(0s 0A 0.012s 0A 0.012000000001s 4.565898928133709A 0.024s 4.565898928133709A 0.024000000001s 11.417939813499046A 0.036000000000000004s 11.417939813499046A 0.036000000001s 12.605364177073078A 0.048s 12.605364177073078A 0.048000000001s 14.399044513049084A 0.06s 14.399044513049084A 0.060000000000999996s 14.84521731887724A 0.07200000000000001s 14.84521731887724A 0.07200000000100001s 4.725222489822159A 0.084s 4.725222489822159A 0.08400000000100001s 10.620294946475262A 0.096s 10.620294946475262A 0.09600000000100001s 12.300602812941944A 0.108s 12.300602812941944A 0.108000000001s 14.39709986389545A 0.12s 14.39709986389545A 0.120000000001s 14.348738656096009A 0.132s 14.348738656096009A 0.132000000001s 4.911253819927154A 0.14400000000000002s 4.911253819927154A 0.14400000000100002s 10.249796071652034A 0.156s 10.249796071652034A 0.156000000001s 11.998423498950087A 0.168s 11.998423498950087A 0.16800000000100002s 13.1216738339833A 0.18s 13.1216738339833A 0.180000000001s 14.380840680522835A 0.192s 14.380840680522835A 0.192000000001s 9.31285028189416A 0.20400000000000001s 9.31285028189416A 0.20400000000100002s 5.453918279151495A 0.216s 5.453918279151495A 0.216000000001s 11.47620833100494A 0.228s 11.47620833100494A 0.228000000001s 12.718662657124504A 0.24s 12.718662657124504A 0.240000000001s 14.505000449110792A 0.252s 14.505000449110792A 0.252000000001s 14.765623462781244A 0.264s 14.765623462781244A 0.264000000001s 4.2874305062781275A 0.276s 4.2874305062781275A 0.276000000001s 10.591454826141A 0.28800000000000003s 10.591454826141A 0.288000000001s 12.243097539147216A 0.3s 12.243097539147216A 0.30000000000099997s 14.483996540132862A 0.312s 14.483996540132862A 0.312000000001s 14.334569674908947A 0.324s 14.334569674908947A 0.324000000001s 4.895956802742666A 0.336s 4.895956802742666A 0.336000000001s 10.077431868009437A 0.34800000000000003s 10.077431868009437A 0.348000000001s 12.087774259952871A 0.36s 12.087774259952871A 0.36000000000099996s 13.352036069080793A 0.372s 13.352036069080793A 0.372000000001s 14.189188577501621A 0.384s 14.189188577501621A 0.384000000001s 8.24214853344762A 0.396s 8.24214853344762A 0.396000000001s 5.247508918105855A 0.40800000000000003s 5.247508918105855A 0.408000000001s 11.293554437711602A 0.42s 11.293554437711602A 0.42000000000099996s 13.237839102292707A 0.432s 13.237839102292707A 0.432000000001s 13.969507205828169A 0.444s 13.969507205828169A 0.444000000001s 15.10399787375189A 0.456s 15.10399787375189A 0.456000000001s 4.31079298084423A 0.468s 4.31079298084423A 0.468000000001s 10.733195581572756A 0.48s 10.733195581572756A 0.48000000000099996s 12.655830748832239A 0.492s 12.655830748832239A 0.49200000000099997s 13.861638157103076A 0.504s 13.861638157103076A 0.504000000001s 15.023912776173145A 0.516s 15.023912776173145A 0.516000000001s 4.450508426483827A 0.528s 4.450508426483827A 0.528000000001s 10.044910772144858A 0.54s 10.044910772144858A 0.540000000001s 12.2745278969788A 0.552s 12.2745278969788A 0.552000000001s 13.34244109192202A 0.5640000000000001s 13.34244109192202A 0.564000000001s 14.437904443454054A 0.5760000000000001s 14.437904443454054A 0.576000000001s 8.304160189757884A 0.588s 8.304160189757884A 0.588000000001s 5.828944156503113A 0.6s 5.828944156503113A 0.600000000001s 11.311637279280061A 0.612s 11.311637279280061A 0.612000000001s 13.290721551146364A 0.624s 13.290721551146364A 0.624000000001s 13.869460419627185A 0.636s 13.869460419627185A 0.636000000001s 14.685334287722318A 0.648s 14.685334287722318A 0.648000000001s 3.9890707464324016A 0.66s 3.9890707464324016A 0.660000000001s 10.659356225241064A 0.672s 10.659356225241064A 0.672000000001s 9.54624851064925A 0.684s 9.54624851064925A 0.684000000001s 9.746077358474404A 0.6960000000000001s 9.746077358474404A 0.696000000001s 9.660288704692531A 0.708s 9.660288704692531A 0.7080000000009999s 9.597883145489618A 0.72s 9.597883145489618A 0.720000000001s 9.597015285536756A 0.732s 9.597015285536756A 0.732000000001s 9.707355096978796A 0.744s 9.707355096978796A 0.744000000001s 9.642178571930588A 0.756s 9.642178571930588A 0.756000000001s 9.537407983372626A 0.768s 9.537407983372626A 0.768000000001s 9.594197014956084A 0.78s 9.594197014956084A 0.780000000001s 9.717219650482118A 0.792s 9.717219650482118A 0.792000000001s 9.573200686865231A 0.804s 9.573200686865231A 0.804000000001s 9.976207921662748A 0.8160000000000001s 9.976207921662748A 0.816000000001s 10.750718953674752A 0.8280000000000001s 10.750718953674752A 0.828000000001s 10.7685188765374A 0.84s 10.7685188765374A 0.840000000001s 10.765955930233567A 0.852s 10.765955930233567A 0.852000000001s 10.764996493164784A 0.864s 10.764996493164784A 0.864000000001s 10.758227367473763A 0.876s 10.758227367473763A 0.876000000001s 10.752512894793238A 0.888s 10.752512894793238A 0.888000000001s 10.744367383244066A 0.9s 10.744367383244066A 0.900000000001s 10.769676326376699A 0.912s 10.769676326376699A 0.912000000001s 10.766419274051861A 0.924s 10.766419274051861A 0.924000000001s 10.759683201028512A 0.936s 10.759683201028512A 0.936000000001s 10.676921443839735A 0.9480000000000001s 10.676921443839735A 0.948000000001s 10.693152123076933A 0.96s 10.693152123076933A 0.9600000000009999s 10.702547268052292A 0.972s 10.702547268052292A 0.972000000001s 10.685208566359554A 0.984s 10.685208566359554A 0.984000000001s 10.69534390914936A 0.996s 10.69534390914936A 0.996000000001s 10.691309967516615A 1.008s 10.691309967516615A 1.008000000001s 10.728180369916446A 1.02s 10.728180369916446A 1.020000000001s 10.723300401285636A 1.032s 10.723300401285636A 1.0320000000010001s 10.647126738204424A 1.044s 10.647126738204424A 1.0440000000010001s 3.6504510179558642A 1.056s 3.6504510179558642A 1.0560000000010001s 2.8227103324619693A 1.068s 2.8227103324619693A 1.0680000000010001s 12.355108481337059A 1.08s 12.355108481337059A 1.0800000000010002s 12.337523249196497A 1.092s 12.337523249196497A 1.0920000000010002s 12.263210239040081A 1.104s 12.263210239040081A 1.1040000000010002s 12.34895098161561A 1.116s 12.34895098161561A 1.1160000000010002s 12.271228694921804A 1.1280000000000001s 12.271228694921804A 1.1280000000010002s 12.314596827255208A 1.1400000000000001s 12.314596827255208A 1.1400000000010002s 12.376840155474623A 1.1520000000000001s 12.376840155474623A 1.1520000000010002s 12.195438927962305A 1.164s 12.195438927962305A 1.164000000001s 12.247618173730462A 1.176s 12.247618173730462A 1.176000000001s 11.37775383432613A 1.188s 11.37775383432613A 1.188000000001s 10.768062507135216A 1.2s 10.768062507135216A 1.200000000001s 10.776123112749099A 1.212s 10.776123112749099A 1.212000000001s 10.806021221684176A 1.224s 10.806021221684176A 1.224000000001s 10.789892429569326A 1.236s 10.789892429569326A 1.236000000001s 10.744166944589683A 1.248s 10.744166944589683A 1.248000000001s 10.737574301949872A 1.26s 10.737574301949872A 1.260000000001s 10.739157797643037A 1.272s 10.739157797643037A 1.272000000001s 10.772541598457265A 1.284s 10.772541598457265A 1.2840000000010001s 10.76543921697023A 1.296s 10.76543921697023A 1.2960000000010001s 10.710073269509332A 1.308s 10.710073269509332A 1.3080000000010001s 9.59977442519821A 1.32s 9.59977442519821A 1.3200000000010002s 9.621007580201423A 1.332s 9.621007580201423A 1.3320000000010002s 9.626263257595896A 1.344s 9.626263257595896A 1.3440000000010002s 9.656606516220279A 1.356s 9.656606516220279A 1.3560000000010002s 9.666830707006651A 1.368s 9.666830707006651A 1.3680000000010002s 9.624003243539757A 1.3800000000000001s 9.624003243539757A 1.3800000000010002s 9.580011962288417A 1.3920000000000001s 9.580011962288417A 1.3920000000010002s 9.706177936833093A 1.4040000000000001s 9.706177936833093A 1.4040000000010002s 9.538895656653105A 1.416s 9.538895656653105A 1.416000000001s 9.564050556160284A 1.428s 9.564050556160284A 1.428000000001s 6.901586915277487A 1.44s 6.901586915277487A 1.440000000001s 2.752458555131779A 1.452s 2.752458555131779A 1.452000000001s 4.045338819455758A 1.464s 4.045338819455758A 1.464000000001s 12.290439572487692A 1.476s 12.290439572487692A 1.476000000001s 12.33919892847655A 1.488s 12.33919892847655A 1.488000000001s 12.3126715851725A 1.5s 12.3126715851725A 1.500000000001s 12.339954894536115A 1.512s 12.339954894536115A 1.512000000001s 12.275729012727675A 1.524s 12.275729012727675A 1.524000000001s 12.36629271566318A 1.536s 12.36629271566318A 1.5360000000010001s 12.281537488407984A 1.548s 12.281537488407984A 1.5480000000010001s 12.280540146903807A 1.56s 12.280540146903807A 1.5600000000010001s 12.407450867795168A 1.572s 12.407450867795168A 1.5720000000010002s 10.671808893593326A 1.584s 10.671808893593326A 1.5840000000010002s 10.781422152817667A 1.596s 10.781422152817667A 1.5960000000010002s 10.784706193100503A 1.608s 10.784706193100503A 1.6080000000010002s 10.802245030212138A 1.62s 10.802245030212138A 1.6200000000010002s 10.772494293721888A 1.6320000000000001s 10.772494293721888A 1.6320000000010002s 10.719498434797528A 1.6440000000000001s 10.719498434797528A 1.6440000000010002s 10.79370531253483A 1.6560000000000001s 10.79370531253483A 1.6560000000010002s 10.778217560231424A 1.668s 10.778217560231424A 1.668000000001s 10.744099019841451A 1.68s 10.744099019841451A 1.680000000001s 10.751654435140356A 1.692s 10.751654435140356A 1.692000000001s 10.212227317934444A 1.704s 10.212227317934444A 1.704000000001s 9.61395705198201A 1.716s 9.61395705198201A 1.716000000001s 9.685477566573825A 1.728s 9.685477566573825A 1.728000000001s 9.716149532461975A 1.74s 9.716149532461975A 1.740000000001s 9.561299603856877A 1.752s 9.561299603856877A 1.752000000001s 9.553540414313272A 1.764s 9.553540414313272A 1.764000000001s 9.628553898435836A 1.776s 9.628553898435836A 1.7760000000010001s 9.644017998371552A 1.788s 9.644017998371552A 1.7880000000010001s 9.57631127645169A 1.8s 9.57631127645169A 1.8000000000010001s 9.581485080265706A 1.812s 9.581485080265706A 1.8120000000010001s 9.687376730404981A 1.824s 9.687376730404981A 1.8240000000010002s 4.156956465223916A 1.836s 4.156956465223916A 1.8360000000010002s 2.7516737817013097A 1.848s 2.7516737817013097A 1.8480000000010002s 7.636387744589679A 1.86s 7.636387744589679A 1.8600000000010002s 12.297247815556045A 1.872s 12.297247815556045A 1.8720000000010002s 12.270698032826239A)
R_0_7_0_1 Node0_7_0 Node0_7_1 9.887809523809521
R_0_7_0_2 Node0_7_0 Node0_8_0 13.020765027322406
R_0_7_0_3 Node0_7_0 Node1_7_0 2.5950185402029655
C_0_7_0 Node0_7_0 GND 0.0009924144753600003
I_0_7_1 GND Node0_7_1 PWL(0s 0A 0.012s 0A 0.012000000001s 4.565898928133709A 0.024s 4.565898928133709A 0.024000000001s 11.417939813499046A 0.036000000000000004s 11.417939813499046A 0.036000000001s 12.605364177073078A 0.048s 12.605364177073078A 0.048000000001s 14.399044513049084A 0.06s 14.399044513049084A 0.060000000000999996s 14.84521731887724A 0.07200000000000001s 14.84521731887724A 0.07200000000100001s 4.725222489822159A 0.084s 4.725222489822159A 0.08400000000100001s 10.620294946475262A 0.096s 10.620294946475262A 0.09600000000100001s 12.300602812941944A 0.108s 12.300602812941944A 0.108000000001s 14.39709986389545A 0.12s 14.39709986389545A 0.120000000001s 14.348738656096009A 0.132s 14.348738656096009A 0.132000000001s 4.911253819927154A 0.14400000000000002s 4.911253819927154A 0.14400000000100002s 10.249796071652034A 0.156s 10.249796071652034A 0.156000000001s 11.998423498950087A 0.168s 11.998423498950087A 0.16800000000100002s 13.1216738339833A 0.18s 13.1216738339833A 0.180000000001s 14.380840680522835A 0.192s 14.380840680522835A 0.192000000001s 9.31285028189416A 0.20400000000000001s 9.31285028189416A 0.20400000000100002s 5.453918279151495A 0.216s 5.453918279151495A 0.216000000001s 11.47620833100494A 0.228s 11.47620833100494A 0.228000000001s 12.718662657124504A 0.24s 12.718662657124504A 0.240000000001s 14.505000449110792A 0.252s 14.505000449110792A 0.252000000001s 14.765623462781244A 0.264s 14.765623462781244A 0.264000000001s 4.2874305062781275A 0.276s 4.2874305062781275A 0.276000000001s 10.591454826141A 0.28800000000000003s 10.591454826141A 0.288000000001s 12.243097539147216A 0.3s 12.243097539147216A 0.30000000000099997s 14.483996540132862A 0.312s 14.483996540132862A 0.312000000001s 14.334569674908947A 0.324s 14.334569674908947A 0.324000000001s 4.895956802742666A 0.336s 4.895956802742666A 0.336000000001s 10.077431868009437A 0.34800000000000003s 10.077431868009437A 0.348000000001s 12.087774259952871A 0.36s 12.087774259952871A 0.36000000000099996s 13.352036069080793A 0.372s 13.352036069080793A 0.372000000001s 14.189188577501621A 0.384s 14.189188577501621A 0.384000000001s 8.24214853344762A 0.396s 8.24214853344762A 0.396000000001s 5.247508918105855A 0.40800000000000003s 5.247508918105855A 0.408000000001s 11.293554437711602A 0.42s 11.293554437711602A 0.42000000000099996s 13.237839102292707A 0.432s 13.237839102292707A 0.432000000001s 13.969507205828169A 0.444s 13.969507205828169A 0.444000000001s 15.10399787375189A 0.456s 15.10399787375189A 0.456000000001s 4.31079298084423A 0.468s 4.31079298084423A 0.468000000001s 10.733195581572756A 0.48s 10.733195581572756A 0.48000000000099996s 12.655830748832239A 0.492s 12.655830748832239A 0.49200000000099997s 13.861638157103076A 0.504s 13.861638157103076A 0.504000000001s 15.023912776173145A 0.516s 15.023912776173145A 0.516000000001s 4.450508426483827A 0.528s 4.450508426483827A 0.528000000001s 10.044910772144858A 0.54s 10.044910772144858A 0.540000000001s 12.2745278969788A 0.552s 12.2745278969788A 0.552000000001s 13.34244109192202A 0.5640000000000001s 13.34244109192202A 0.564000000001s 14.437904443454054A 0.5760000000000001s 14.437904443454054A 0.576000000001s 8.304160189757884A 0.588s 8.304160189757884A 0.588000000001s 5.828944156503113A 0.6s 5.828944156503113A 0.600000000001s 11.311637279280061A 0.612s 11.311637279280061A 0.612000000001s 13.290721551146364A 0.624s 13.290721551146364A 0.624000000001s 13.869460419627185A 0.636s 13.869460419627185A 0.636000000001s 14.685334287722318A 0.648s 14.685334287722318A 0.648000000001s 3.9890707464324016A 0.66s 3.9890707464324016A 0.660000000001s 10.659356225241064A 0.672s 10.659356225241064A 0.672000000001s 9.54624851064925A 0.684s 9.54624851064925A 0.684000000001s 9.746077358474404A 0.6960000000000001s 9.746077358474404A 0.696000000001s 9.660288704692531A 0.708s 9.660288704692531A 0.7080000000009999s 9.597883145489618A 0.72s 9.597883145489618A 0.720000000001s 9.597015285536756A 0.732s 9.597015285536756A 0.732000000001s 9.707355096978796A 0.744s 9.707355096978796A 0.744000000001s 9.642178571930588A 0.756s 9.642178571930588A 0.756000000001s 9.537407983372626A 0.768s 9.537407983372626A 0.768000000001s 9.594197014956084A 0.78s 9.594197014956084A 0.780000000001s 9.717219650482118A 0.792s 9.717219650482118A 0.792000000001s 9.573200686865231A 0.804s 9.573200686865231A 0.804000000001s 9.976207921662748A 0.8160000000000001s 9.976207921662748A 0.816000000001s 10.750718953674752A 0.8280000000000001s 10.750718953674752A 0.828000000001s 10.7685188765374A 0.84s 10.7685188765374A 0.840000000001s 10.765955930233567A 0.852s 10.765955930233567A 0.852000000001s 10.764996493164784A 0.864s 10.764996493164784A 0.864000000001s 10.758227367473763A 0.876s 10.758227367473763A 0.876000000001s 10.752512894793238A 0.888s 10.752512894793238A 0.888000000001s 10.744367383244066A 0.9s 10.744367383244066A 0.900000000001s 10.769676326376699A 0.912s 10.769676326376699A 0.912000000001s 10.766419274051861A 0.924s 10.766419274051861A 0.924000000001s 10.759683201028512A 0.936s 10.759683201028512A 0.936000000001s 10.676921443839735A 0.9480000000000001s 10.676921443839735A 0.948000000001s 10.693152123076933A 0.96s 10.693152123076933A 0.9600000000009999s 10.702547268052292A 0.972s 10.702547268052292A 0.972000000001s 10.685208566359554A 0.984s 10.685208566359554A 0.984000000001s 10.69534390914936A 0.996s 10.69534390914936A 0.996000000001s 10.691309967516615A 1.008s 10.691309967516615A 1.008000000001s 10.728180369916446A 1.02s 10.728180369916446A 1.020000000001s 10.723300401285636A 1.032s 10.723300401285636A 1.0320000000010001s 10.647126738204424A 1.044s 10.647126738204424A 1.0440000000010001s 3.6504510179558642A 1.056s 3.6504510179558642A 1.0560000000010001s 2.8227103324619693A 1.068s 2.8227103324619693A 1.0680000000010001s 12.355108481337059A 1.08s 12.355108481337059A 1.0800000000010002s 12.337523249196497A 1.092s 12.337523249196497A 1.0920000000010002s 12.263210239040081A 1.104s 12.263210239040081A 1.1040000000010002s 12.34895098161561A 1.116s 12.34895098161561A 1.1160000000010002s 12.271228694921804A 1.1280000000000001s 12.271228694921804A 1.1280000000010002s 12.314596827255208A 1.1400000000000001s 12.314596827255208A 1.1400000000010002s 12.376840155474623A 1.1520000000000001s 12.376840155474623A 1.1520000000010002s 12.195438927962305A 1.164s 12.195438927962305A 1.164000000001s 12.247618173730462A 1.176s 12.247618173730462A 1.176000000001s 11.37775383432613A 1.188s 11.37775383432613A 1.188000000001s 10.768062507135216A 1.2s 10.768062507135216A 1.200000000001s 10.776123112749099A 1.212s 10.776123112749099A 1.212000000001s 10.806021221684176A 1.224s 10.806021221684176A 1.224000000001s 10.789892429569326A 1.236s 10.789892429569326A 1.236000000001s 10.744166944589683A 1.248s 10.744166944589683A 1.248000000001s 10.737574301949872A 1.26s 10.737574301949872A 1.260000000001s 10.739157797643037A 1.272s 10.739157797643037A 1.272000000001s 10.772541598457265A 1.284s 10.772541598457265A 1.2840000000010001s 10.76543921697023A 1.296s 10.76543921697023A 1.2960000000010001s 10.710073269509332A 1.308s 10.710073269509332A 1.3080000000010001s 9.59977442519821A 1.32s 9.59977442519821A 1.3200000000010002s 9.621007580201423A 1.332s 9.621007580201423A 1.3320000000010002s 9.626263257595896A 1.344s 9.626263257595896A 1.3440000000010002s 9.656606516220279A 1.356s 9.656606516220279A 1.3560000000010002s 9.666830707006651A 1.368s 9.666830707006651A 1.3680000000010002s 9.624003243539757A 1.3800000000000001s 9.624003243539757A 1.3800000000010002s 9.580011962288417A 1.3920000000000001s 9.580011962288417A 1.3920000000010002s 9.706177936833093A 1.4040000000000001s 9.706177936833093A 1.4040000000010002s 9.538895656653105A 1.416s 9.538895656653105A 1.416000000001s 9.564050556160284A 1.428s 9.564050556160284A 1.428000000001s 6.901586915277487A 1.44s 6.901586915277487A 1.440000000001s 2.752458555131779A 1.452s 2.752458555131779A 1.452000000001s 4.045338819455758A 1.464s 4.045338819455758A 1.464000000001s 12.290439572487692A 1.476s 12.290439572487692A 1.476000000001s 12.33919892847655A 1.488s 12.33919892847655A 1.488000000001s 12.3126715851725A 1.5s 12.3126715851725A 1.500000000001s 12.339954894536115A 1.512s 12.339954894536115A 1.512000000001s 12.275729012727675A 1.524s 12.275729012727675A 1.524000000001s 12.36629271566318A 1.536s 12.36629271566318A 1.5360000000010001s 12.281537488407984A 1.548s 12.281537488407984A 1.5480000000010001s 12.280540146903807A 1.56s 12.280540146903807A 1.5600000000010001s 12.407450867795168A 1.572s 12.407450867795168A 1.5720000000010002s 10.671808893593326A 1.584s 10.671808893593326A 1.5840000000010002s 10.781422152817667A 1.596s 10.781422152817667A 1.5960000000010002s 10.784706193100503A 1.608s 10.784706193100503A 1.6080000000010002s 10.802245030212138A 1.62s 10.802245030212138A 1.6200000000010002s 10.772494293721888A 1.6320000000000001s 10.772494293721888A 1.6320000000010002s 10.719498434797528A 1.6440000000000001s 10.719498434797528A 1.6440000000010002s 10.79370531253483A 1.6560000000000001s 10.79370531253483A 1.6560000000010002s 10.778217560231424A 1.668s 10.778217560231424A 1.668000000001s 10.744099019841451A 1.68s 10.744099019841451A 1.680000000001s 10.751654435140356A 1.692s 10.751654435140356A 1.692000000001s 10.212227317934444A 1.704s 10.212227317934444A 1.704000000001s 9.61395705198201A 1.716s 9.61395705198201A 1.716000000001s 9.685477566573825A 1.728s 9.685477566573825A 1.728000000001s 9.716149532461975A 1.74s 9.716149532461975A 1.740000000001s 9.561299603856877A 1.752s 9.561299603856877A 1.752000000001s 9.553540414313272A 1.764s 9.553540414313272A 1.764000000001s 9.628553898435836A 1.776s 9.628553898435836A 1.7760000000010001s 9.644017998371552A 1.788s 9.644017998371552A 1.7880000000010001s 9.57631127645169A 1.8s 9.57631127645169A 1.8000000000010001s 9.581485080265706A 1.812s 9.581485080265706A 1.8120000000010001s 9.687376730404981A 1.824s 9.687376730404981A 1.8240000000010002s 4.156956465223916A 1.836s 4.156956465223916A 1.8360000000010002s 2.7516737817013097A 1.848s 2.7516737817013097A 1.8480000000010002s 7.636387744589679A 1.86s 7.636387744589679A 1.8600000000010002s 12.297247815556045A 1.872s 12.297247815556045A 1.8720000000010002s 12.270698032826239A)
R_0_7_1_1 Node0_7_1 Node0_7_2 9.887809523809523
R_0_7_1_2 Node0_7_1 Node0_8_1 13.020765027322406
R_0_7_1_3 Node0_7_1 Node1_7_1 2.5950185402029655
C_0_7_1 Node0_7_1 GND 0.0009924144753600003
I_0_7_2 GND Node0_7_2 PWL(0s 0A 0.012s 0A 0.012000000001s 2.1203057667439236A 0.024s 2.1203057667439236A 0.024000000001s 5.218704570070078A 0.036000000000000004s 5.218704570070078A 0.036000000001s 5.755641664888184A 0.048s 5.755641664888184A 0.048000000001s 6.566719096953631A 0.06s 6.566719096953631A 0.060000000000999996s 6.768472026446379A 0.07200000000000001s 6.768472026446379A 0.07200000000100001s 2.1923497661971103A 0.084s 2.1923497661971103A 0.08400000000100001s 4.858020448447895A 0.096s 4.858020448447895A 0.09600000000100001s 5.61783275749985A 0.108s 5.61783275749985A 0.108000000001s 6.565839605764139A 0.12s 6.565839605764139A 0.120000000001s 6.543971651638587A 0.132s 6.543971651638587A 0.132000000001s 2.276470639073625A 0.14400000000000002s 2.276470639073625A 0.14400000000100002s 4.690485601522371A 0.156s 4.690485601522371A 0.156000000001s 5.481191416499632A 0.168s 5.481191416499632A 0.16800000000100002s 5.989109853138176A 0.18s 5.989109853138176A 0.180000000001s 6.558487582518947A 0.192s 6.558487582518947A 0.192000000001s 4.26681173024974A 0.20400000000000001s 4.26681173024974A 0.20400000000100002s 2.5218560944902473A 0.216s 2.5218560944902473A 0.216000000001s 5.245052617356411A 0.228s 5.245052617356411A 0.228000000001s 5.806873702097815A 0.24s 5.806873702097815A 0.240000000001s 6.614630717384737A 0.252s 6.614630717384737A 0.252000000001s 6.732480444383656A 0.264s 6.732480444383656A 0.264000000001s 1.9943865997050079A 0.276s 1.9943865997050079A 0.276000000001s 4.844979058840856A 0.28800000000000003s 4.844979058840856A 0.288000000001s 5.591829689704693A 0.3s 5.591829689704693A 0.30000000000099997s 6.605133048161111A 0.312s 6.605133048161111A 0.312000000001s 6.537564639653727A 0.324s 6.537564639653727A 0.324000000001s 2.2695536194730264A 0.336s 2.2695536194730264A 0.336000000001s 4.612544660583287A 0.34800000000000003s 4.612544660583287A 0.348000000001s 5.52159448692517A 0.36s 5.52159448692517A 0.36000000000099996s 6.093276308707632A 0.372s 6.093276308707632A 0.372000000001s 6.471825298694366A 0.384s 6.471825298694366A 0.384000000001s 3.782655314815975A 0.396s 3.782655314815975A 0.396000000001s 2.428520417075196A 0.40800000000000003s 2.428520417075196A 0.408000000001s 5.162459196127357A 0.42s 5.162459196127357A 0.42000000000099996s 6.041637914325513A 0.432s 6.041637914325513A 0.432000000001s 6.37248828087306A 0.444s 6.37248828087306A 0.444000000001s 6.885488842461518A 0.456s 6.885488842461518A 0.456000000001s 2.004950704542374A 0.468s 2.004950704542374A 0.468000000001s 4.909072288879571A 0.48s 4.909072288879571A 0.48000000000099996s 5.778461783155161A 0.492s 5.778461783155161A 0.49200000000099997s 6.323711429605293A 0.504s 6.323711429605293A 0.504000000001s 6.849275796099696A 0.516s 6.849275796099696A 0.516000000001s 2.0681282667390812A 0.528s 2.0681282667390812A 0.528000000001s 4.597838934610566A 0.54s 4.597838934610566A 0.540000000001s 5.606041902493489A 0.552s 5.606041902493489A 0.552000000001s 6.088937522122959A 0.5640000000000001s 6.088937522122959A 0.564000000001s 6.5842909311389A 0.5760000000000001s 6.5842909311389A 0.576000000001s 3.8106964759373354A 0.588s 3.8106964759373354A 0.588000000001s 2.69143746799214A 0.6s 2.69143746799214A 0.600000000001s 5.170635851698812A 0.612s 5.170635851698812A 0.612000000001s 6.065550532126241A 0.624s 6.065550532126241A 0.624000000001s 6.327248545582724A 0.636s 6.327248545582724A 0.636000000001s 6.696174597435859A 0.648s 6.696174597435859A 0.648000000001s 1.859472629529451A 0.66s 1.859472629529451A 0.660000000001s 4.875682958323459A 0.672s 4.875682958323459A 0.672000000001s 4.372347529945647A 0.684s 4.372347529945647A 0.684000000001s 4.462706850420456A 0.6960000000000001s 4.462706850420456A 0.696000000001s 4.423914440035484A 0.708s 4.423914440035484A 0.7080000000009999s 4.3956955328002865A 0.72s 4.3956955328002865A 0.720000000001s 4.395303098859853A 0.732s 4.395303098859853A 0.732000000001s 4.445197193924491A 0.744s 4.445197193924491A 0.744000000001s 4.415725295302965A 0.756s 4.415725295302965A 0.756000000001s 4.368349523700936A 0.768s 4.368349523700936A 0.768000000001s 4.394028716944276A 0.78s 4.394028716944276A 0.780000000001s 4.449657804866567A 0.792s 4.449657804866567A 0.792000000001s 4.384534475690079A 0.804s 4.384534475690079A 0.804000000001s 4.566768621479667A 0.8160000000000001s 4.566768621479667A 0.816000000001s 4.916991506173619A 0.8280000000000001s 4.916991506173619A 0.828000000001s 4.925040378397029A 0.84s 4.925040378397029A 0.840000000001s 4.923881450491881A 0.852s 4.923881450491881A 0.852000000001s 4.923447606680723A 0.864s 4.923447606680723A 0.864000000001s 4.920386704216614A 0.876s 4.920386704216614A 0.876000000001s 4.917802700859711A 0.888s 4.917802700859711A 0.888000000001s 4.914119416265754A 0.9s 4.914119416265754A 0.900000000001s 4.925563760769717A 0.912s 4.925563760769717A 0.912000000001s 4.924090967983487A 0.924s 4.924090967983487A 0.924000000001s 4.921045011466098A 0.936s 4.921045011466098A 0.936000000001s 4.883621320715435A 0.9480000000000001s 4.883621320715435A 0.948000000001s 4.890960603266682A 0.96s 4.890960603266682A 0.9600000000009999s 4.895208954341605A 0.972s 4.895208954341605A 0.972000000001s 4.887368639778359A 0.984s 4.887368639778359A 0.984000000001s 4.891951697788503A 0.996s 4.891951697788503A 0.996000000001s 4.890127606695008A 1.008s 4.890127606695008A 1.008000000001s 4.906799878818429A 1.02s 4.906799878818429A 1.020000000001s 4.9045932263364636A 1.032s 4.9045932263364636A 1.0320000000010001s 4.870148578139905A 1.044s 4.870148578139905A 1.0440000000010001s 1.7063512237652154A 1.056s 1.7063512237652154A 1.0560000000010001s 1.3320586460350528A 1.068s 1.3320586460350528A 1.0680000000010001s 5.6424737302127586A 1.08s 5.6424737302127586A 1.0800000000010002s 5.634521938083625A 1.092s 5.634521938083625A 1.0920000000010002s 5.600918650704153A 1.104s 5.600918650704153A 1.1040000000010002s 5.639689396322323A 1.116s 5.639689396322323A 1.1160000000010002s 5.604544482530451A 1.1280000000000001s 5.604544482530451A 1.1280000000010002s 5.624154935812359A 1.1400000000000001s 5.624154935812359A 1.1400000000010002s 5.6523004845017395A 1.1520000000000001s 5.6523004845017395A 1.1520000000010002s 5.570273426705869A 1.164s 5.570273426705869A 1.164000000001s 5.593868140297754A 1.176s 5.593868140297754A 1.176000000001s 5.200527770511878A 1.188s 5.200527770511878A 1.188000000001s 4.924834014637298A 1.2s 4.924834014637298A 1.200000000001s 4.928478905973631A 1.212s 4.928478905973631A 1.212000000001s 4.941998406052197A 1.224s 4.941998406052197A 1.224000000001s 4.9347051954101A 1.236s 4.9347051954101A 1.236000000001s 4.914028780754004A 1.248s 4.914028780754004A 1.248000000001s 4.911047681418243A 1.26s 4.911047681418243A 1.260000000001s 4.911763715672939A 1.272s 4.911763715672939A 1.272000000001s 4.926859396095765A 1.284s 4.926859396095765A 1.2840000000010001s 4.923647800095481A 1.296s 4.923647800095481A 1.2960000000010001s 4.898612105273681A 1.308s 4.898612105273681A 1.3080000000010001s 4.39655074261387A 1.32s 4.39655074261387A 1.3200000000010002s 4.406152073633084A 1.332s 4.406152073633084A 1.3320000000010002s 4.408528616280038A 1.344s 4.408528616280038A 1.3440000000010002s 4.422249406723577A 1.356s 4.422249406723577A 1.3560000000010002s 4.426872640535448A 1.368s 4.426872640535448A 1.3680000000010002s 4.407506670033341A 1.3800000000000001s 4.407506670033341A 1.3800000000010002s 4.387614437664224A 1.3920000000000001s 4.387614437664224A 1.3920000000010002s 4.444664898831284A 1.4040000000000001s 4.444664898831284A 1.4040000000010002s 4.369022228422027A 1.416s 4.369022228422027A 1.416000000001s 4.380396916587158A 1.428s 4.380396916587158A 1.428000000001s 3.1764686855322326A 1.44s 3.1764686855322326A 1.440000000001s 1.3002917904390239A 1.452s 1.3002917904390239A 1.452000000001s 1.8849138771756861A 1.464s 1.8849138771756861A 1.464000000001s 5.613231368424316A 1.476s 5.613231368424316A 1.476000000001s 5.6352796564466A 1.488s 5.6352796564466A 1.488000000001s 5.623284368695725A 1.5s 5.623284368695725A 1.500000000001s 5.635621493558234A 1.512s 5.635621493558234A 1.512000000001s 5.6065794623033245A 1.524s 5.6065794623033245A 1.524000000001s 5.647531082073341A 1.536s 5.647531082073341A 1.5360000000010001s 5.609205972481169A 1.548s 5.609205972481169A 1.5480000000010001s 5.608754988822859A 1.56s 5.608754988822859A 1.5600000000010001s 5.666142213706795A 1.572s 5.666142213706795A 1.5720000000010002s 4.881309498131334A 1.584s 4.881309498131334A 1.5840000000010002s 4.930875056605729A 1.596s 4.930875056605729A 1.5960000000010002s 4.932360052963132A 1.608s 4.932360052963132A 1.6080000000010002s 4.940290865919349A 1.62s 4.940290865919349A 1.6200000000010002s 4.926838005566517A 1.6320000000000001s 4.926838005566517A 1.6320000000010002s 4.902874031107552A 1.6440000000000001s 4.902874031107552A 1.6440000000010002s 4.936429326914992A 1.6560000000000001s 4.936429326914992A 1.6560000000010002s 4.929425985367961A 1.668s 4.929425985367961A 1.668000000001s 4.913998066147905A 1.68s 4.913998066147905A 1.680000000001s 4.9174145176013715A 1.692s 4.9174145176013715A 1.692000000001s 4.673493239192687A 1.704s 4.673493239192687A 1.704000000001s 4.4029639249437045A 1.716s 4.4029639249437045A 1.716000000001s 4.435304485503664A 1.728s 4.435304485503664A 1.728000000001s 4.449173912701721A 1.74s 4.449173912701721A 1.740000000001s 4.379152975040126A 1.752s 4.379152975040126A 1.752000000001s 4.375644379768359A 1.764s 4.375644379768359A 1.764000000001s 4.409564411523235A 1.776s 4.409564411523235A 1.7760000000010001s 4.416557057805642A 1.788s 4.416557057805642A 1.7880000000010001s 4.385941040106907A 1.8s 4.385941040106907A 1.8000000000010001s 4.388280560684009A 1.812s 4.388280560684009A 1.8120000000010001s 4.436163260405458A 1.824s 4.436163260405458A 1.8240000000010002s 1.9353857907675724A 1.836s 1.9353857907675724A 1.8360000000010002s 1.2999369270435523A 1.848s 1.2999369270435523A 1.8480000000010002s 3.508735180754002A 1.86s 3.508735180754002A 1.8600000000010002s 5.616309959210688A 1.872s 5.616309959210688A 1.8720000000010002s 5.6043045989058555A)
R_0_7_2_1 Node0_7_2 Node0_7_3 9.887809523809523
R_0_7_2_2 Node0_7_2 Node0_8_2 13.020765027322406
R_0_7_2_3 Node0_7_2 Node1_7_2 2.5950185402029655
C_0_7_2 Node0_7_2 GND 0.0009924144753600001
I_0_7_3 GND Node0_7_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.10162412978627196A 0.024s 0.10162412978627196A 0.024000000001s 0.10163009232696775A 0.036000000000000004s 0.10163009232696775A 0.036000000001s 0.10163131193756464A 0.048s 0.10163131193756464A 0.048000000001s 0.10163253154816151A 0.06s 0.10163253154816151A 0.060000000000999996s 0.101632396035873A 0.07200000000000001s 0.101632396035873A 0.07200000000100001s 0.10162440081084903A 0.084s 0.10162440081084903A 0.08400000000100001s 0.10162927925323653A 0.096s 0.10162927925323653A 0.09600000000100001s 0.10163104091298755A 0.108s 0.10163104091298755A 0.108000000001s 0.10163226052358441A 0.12s 0.10163226052358441A 0.120000000001s 0.10163280257273859A 0.132s 0.10163280257273859A 0.132000000001s 0.10162467183542612A 0.14400000000000002s 0.10162467183542612A 0.14400000000100002s 0.10162833066721673A 0.156s 0.10162833066721673A 0.156000000001s 0.10163076988841047A 0.168s 0.10163076988841047A 0.16800000000100002s 0.1016318539867188A 0.18s 0.1016318539867188A 0.180000000001s 0.10163253154816151A 0.192s 0.10163253154816151A 0.192000000001s 0.10162778861806256A 0.20400000000000001s 0.10162778861806256A 0.20400000000100002s 0.10162521388458028A 0.216s 0.10162521388458028A 0.216000000001s 0.10162982130239069A 0.228s 0.10162982130239069A 0.228000000001s 0.10163144744985318A 0.24s 0.10163144744985318A 0.240000000001s 0.10163226052358441A 0.252s 0.10163226052358441A 0.252000000001s 0.10163171847443025A 0.264s 0.10163171847443025A 0.264000000001s 0.10162467183542612A 0.276s 0.10162467183542612A 0.276000000001s 0.10162873720408236A 0.28800000000000003s 0.10162873720408236A 0.288000000001s 0.10163104091298755A 0.3s 0.10163104091298755A 0.30000000000099997s 0.10163226052358441A 0.312s 0.10163226052358441A 0.312000000001s 0.10163280257273859A 0.324s 0.10163280257273859A 0.324000000001s 0.10162480734771465A 0.336s 0.10162480734771465A 0.336000000001s 0.10162778861806256A 0.34800000000000003s 0.10162778861806256A 0.348000000001s 0.10163063437612192A 0.36s 0.10163063437612192A 0.36000000000099996s 0.10163171847443025A 0.372s 0.10163171847443025A 0.372000000001s 0.10163266706045004A 0.384s 0.10163266706045004A 0.384000000001s 0.1016272465689084A 0.396s 0.1016272465689084A 0.396000000001s 0.10162467183542612A 0.40800000000000003s 0.10162467183542612A 0.408000000001s 0.10162995681467922A 0.42s 0.10162995681467922A 0.42000000000099996s 0.10163144744985318A 0.432s 0.10163144744985318A 0.432000000001s 0.10163226052358441A 0.444s 0.10163226052358441A 0.444000000001s 0.10163226052358441A 0.456s 0.10163226052358441A 0.456000000001s 0.10162453632313759A 0.468s 0.10162453632313759A 0.468000000001s 0.10162887271637089A 0.48s 0.10162887271637089A 0.48000000000099996s 0.10163104091298755A 0.492s 0.10163104091298755A 0.49200000000099997s 0.10163226052358441A 0.504s 0.10163226052358441A 0.504000000001s 0.10163280257273859A 0.516s 0.10163280257273859A 0.516000000001s 0.10162494286000319A 0.528s 0.10162494286000319A 0.528000000001s 0.10162751759348547A 0.54s 0.10162751759348547A 0.540000000001s 0.10163076988841047A 0.552s 0.10163076988841047A 0.552000000001s 0.10163158296214173A 0.5640000000000001s 0.10163158296214173A 0.564000000001s 0.101632396035873A 0.5760000000000001s 0.101632396035873A 0.576000000001s 0.10162792413035111A 0.588s 0.10162792413035111A 0.588000000001s 0.10162521388458028A 0.6s 0.10162521388458028A 0.600000000001s 0.10162968579010215A 0.612s 0.10162968579010215A 0.612000000001s 0.10163131193756464A 0.624s 0.10163131193756464A 0.624000000001s 0.10163226052358441A 0.636s 0.10163226052358441A 0.636000000001s 0.10163131193756464A 0.648s 0.10163131193756464A 0.648000000001s 0.10162480734771465A 0.66s 0.10162480734771465A 0.660000000001s 0.10162846617950527A 0.672s 0.10162846617950527A 0.672000000001s 0.10162128402821256A 0.684s 0.10162128402821256A 0.684000000001s 0.10162047095448133A 0.6960000000000001s 0.10162047095448133A 0.696000000001s 0.10162047095448133A 0.708s 0.10162047095448133A 0.7080000000009999s 0.10162047095448133A 0.72s 0.10162047095448133A 0.720000000001s 0.10162047095448133A 0.732s 0.10162047095448133A 0.732000000001s 0.10162047095448133A 0.744s 0.10162047095448133A 0.744000000001s 0.10162047095448133A 0.756s 0.10162047095448133A 0.756000000001s 0.10162047095448133A 0.768s 0.10162047095448133A 0.768000000001s 0.10162047095448133A 0.78s 0.10162047095448133A 0.780000000001s 0.10162047095448133A 0.792s 0.10162047095448133A 0.792000000001s 0.10162047095448133A 0.804s 0.10162047095448133A 0.804000000001s 0.10162047095448133A 0.8160000000000001s 0.10162047095448133A 0.816000000001s 0.10162047095448133A 0.8280000000000001s 0.10162047095448133A 0.828000000001s 0.10162047095448133A 0.84s 0.10162047095448133A 0.840000000001s 0.10162047095448133A 0.852s 0.10162047095448133A 0.852000000001s 0.10162047095448133A 0.864s 0.10162047095448133A 0.864000000001s 0.10162047095448133A 0.876s 0.10162047095448133A 0.876000000001s 0.10162047095448133A 0.888s 0.10162047095448133A 0.888000000001s 0.10162047095448133A 0.9s 0.10162047095448133A 0.900000000001s 0.10162047095448133A 0.912s 0.10162047095448133A 0.912000000001s 0.10162047095448133A 0.924s 0.10162047095448133A 0.924000000001s 0.10162047095448133A 0.936s 0.10162047095448133A 0.936000000001s 0.10162047095448133A 0.9480000000000001s 0.10162047095448133A 0.948000000001s 0.10162047095448133A 0.96s 0.10162047095448133A 0.9600000000009999s 0.10162047095448133A 0.972s 0.10162047095448133A 0.972000000001s 0.10162047095448133A 0.984s 0.10162047095448133A 0.984000000001s 0.10162047095448133A 0.996s 0.10162047095448133A 0.996000000001s 0.10162047095448133A 1.008s 0.10162047095448133A 1.008000000001s 0.10162047095448133A 1.02s 0.10162047095448133A 1.020000000001s 0.10162047095448133A 1.032s 0.10162047095448133A 1.0320000000010001s 0.10162047095448133A 1.044s 0.10162047095448133A 1.0440000000010001s 0.10162047095448133A 1.056s 0.10162047095448133A 1.0560000000010001s 0.10162047095448133A 1.068s 0.10162047095448133A 1.0680000000010001s 0.10162060646676987A 1.08s 0.10162060646676987A 1.0800000000010002s 0.10162060646676987A 1.092s 0.10162060646676987A 1.0920000000010002s 0.10162060646676987A 1.104s 0.10162060646676987A 1.1040000000010002s 0.10162060646676987A 1.116s 0.10162060646676987A 1.1160000000010002s 0.10162060646676987A 1.1280000000000001s 0.10162060646676987A 1.1280000000010002s 0.10162060646676987A 1.1400000000000001s 0.10162060646676987A 1.1400000000010002s 0.10162060646676987A 1.1520000000000001s 0.10162060646676987A 1.1520000000010002s 0.10162060646676987A 1.164s 0.10162060646676987A 1.164000000001s 0.10162060646676987A 1.176s 0.10162060646676987A 1.176000000001s 0.10162047095448133A 1.188s 0.10162047095448133A 1.188000000001s 0.10162047095448133A 1.2s 0.10162047095448133A 1.200000000001s 0.10162047095448133A 1.212s 0.10162047095448133A 1.212000000001s 0.10162047095448133A 1.224s 0.10162047095448133A 1.224000000001s 0.10162047095448133A 1.236s 0.10162047095448133A 1.236000000001s 0.10162047095448133A 1.248s 0.10162047095448133A 1.248000000001s 0.10162047095448133A 1.26s 0.10162047095448133A 1.260000000001s 0.10162047095448133A 1.272s 0.10162047095448133A 1.272000000001s 0.10162047095448133A 1.284s 0.10162047095448133A 1.2840000000010001s 0.10162047095448133A 1.296s 0.10162047095448133A 1.2960000000010001s 0.10162047095448133A 1.308s 0.10162047095448133A 1.3080000000010001s 0.10162047095448133A 1.32s 0.10162047095448133A 1.3200000000010002s 0.10162047095448133A 1.332s 0.10162047095448133A 1.3320000000010002s 0.10162047095448133A 1.344s 0.10162047095448133A 1.3440000000010002s 0.10162047095448133A 1.356s 0.10162047095448133A 1.3560000000010002s 0.10162047095448133A 1.368s 0.10162047095448133A 1.3680000000010002s 0.10162047095448133A 1.3800000000000001s 0.10162047095448133A 1.3800000000010002s 0.10162047095448133A 1.3920000000000001s 0.10162047095448133A 1.3920000000010002s 0.10162047095448133A 1.4040000000000001s 0.10162047095448133A 1.4040000000010002s 0.10162047095448133A 1.416s 0.10162047095448133A 1.416000000001s 0.10162047095448133A 1.428s 0.10162047095448133A 1.428000000001s 0.10162047095448133A 1.44s 0.10162047095448133A 1.440000000001s 0.10162047095448133A 1.452s 0.10162047095448133A 1.452000000001s 0.10162047095448133A 1.464s 0.10162047095448133A 1.464000000001s 0.10162060646676987A 1.476s 0.10162060646676987A 1.476000000001s 0.10162060646676987A 1.488s 0.10162060646676987A 1.488000000001s 0.10162060646676987A 1.5s 0.10162060646676987A 1.500000000001s 0.10162060646676987A 1.512s 0.10162060646676987A 1.512000000001s 0.10162060646676987A 1.524s 0.10162060646676987A 1.524000000001s 0.10162060646676987A 1.536s 0.10162060646676987A 1.5360000000010001s 0.10162060646676987A 1.548s 0.10162060646676987A 1.5480000000010001s 0.10162060646676987A 1.56s 0.10162060646676987A 1.5600000000010001s 0.10162060646676987A 1.572s 0.10162060646676987A 1.5720000000010002s 0.10162047095448133A 1.584s 0.10162047095448133A 1.5840000000010002s 0.10162047095448133A 1.596s 0.10162047095448133A 1.5960000000010002s 0.10162047095448133A 1.608s 0.10162047095448133A 1.6080000000010002s 0.10162047095448133A 1.62s 0.10162047095448133A 1.6200000000010002s 0.10162047095448133A 1.6320000000000001s 0.10162047095448133A 1.6320000000010002s 0.10162047095448133A 1.6440000000000001s 0.10162047095448133A 1.6440000000010002s 0.10162047095448133A 1.6560000000000001s 0.10162047095448133A 1.6560000000010002s 0.10162047095448133A 1.668s 0.10162047095448133A 1.668000000001s 0.10162047095448133A 1.68s 0.10162047095448133A 1.680000000001s 0.10162047095448133A 1.692s 0.10162047095448133A 1.692000000001s 0.10162047095448133A 1.704s 0.10162047095448133A 1.704000000001s 0.10162047095448133A 1.716s 0.10162047095448133A 1.716000000001s 0.10162047095448133A 1.728s 0.10162047095448133A 1.728000000001s 0.10162047095448133A 1.74s 0.10162047095448133A 1.740000000001s 0.10162047095448133A 1.752s 0.10162047095448133A 1.752000000001s 0.10162047095448133A 1.764s 0.10162047095448133A 1.764000000001s 0.10162047095448133A 1.776s 0.10162047095448133A 1.7760000000010001s 0.10162047095448133A 1.788s 0.10162047095448133A 1.7880000000010001s 0.10162047095448133A 1.8s 0.10162047095448133A 1.8000000000010001s 0.10162047095448133A 1.812s 0.10162047095448133A 1.8120000000010001s 0.10162047095448133A 1.824s 0.10162047095448133A 1.8240000000010002s 0.10162047095448133A 1.836s 0.10162047095448133A 1.8360000000010002s 0.10162047095448133A 1.848s 0.10162047095448133A 1.8480000000010002s 0.10162047095448133A 1.86s 0.10162047095448133A 1.8600000000010002s 0.10162060646676987A 1.872s 0.10162060646676987A 1.8720000000010002s 0.1016207419790584A)
R_0_7_3_1 Node0_7_3 Node0_7_4 9.887809523809521
R_0_7_3_2 Node0_7_3 Node0_8_3 13.020765027322406
R_0_7_3_3 Node0_7_3 Node1_7_3 2.5950185402029655
C_0_7_3 Node0_7_3 GND 0.0009924144753600003
I_0_7_4 GND Node0_7_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.10162412978627194A 0.024s 0.10162412978627194A 0.024000000001s 0.10163009232696775A 0.036000000000000004s 0.10163009232696775A 0.036000000001s 0.10163131193756463A 0.048s 0.10163131193756463A 0.048000000001s 0.10163253154816151A 0.06s 0.10163253154816151A 0.060000000000999996s 0.10163239603587298A 0.07200000000000001s 0.10163239603587298A 0.07200000000100001s 0.10162440081084902A 0.084s 0.10162440081084902A 0.08400000000100001s 0.10162927925323652A 0.096s 0.10162927925323652A 0.09600000000100001s 0.10163104091298755A 0.108s 0.10163104091298755A 0.108000000001s 0.1016322605235844A 0.12s 0.1016322605235844A 0.120000000001s 0.10163280257273857A 0.132s 0.10163280257273857A 0.132000000001s 0.1016246718354261A 0.14400000000000002s 0.1016246718354261A 0.14400000000100002s 0.10162833066721672A 0.156s 0.10162833066721672A 0.156000000001s 0.10163076988841047A 0.168s 0.10163076988841047A 0.16800000000100002s 0.10163185398671878A 0.18s 0.10163185398671878A 0.180000000001s 0.10163253154816151A 0.192s 0.10163253154816151A 0.192000000001s 0.10162778861806256A 0.20400000000000001s 0.10162778861806256A 0.20400000000100002s 0.10162521388458026A 0.216s 0.10162521388458026A 0.216000000001s 0.10162982130239068A 0.228s 0.10162982130239068A 0.228000000001s 0.10163144744985317A 0.24s 0.10163144744985317A 0.240000000001s 0.1016322605235844A 0.252s 0.1016322605235844A 0.252000000001s 0.10163171847443025A 0.264s 0.10163171847443025A 0.264000000001s 0.1016246718354261A 0.276s 0.1016246718354261A 0.276000000001s 0.10162873720408236A 0.28800000000000003s 0.10162873720408236A 0.288000000001s 0.10163104091298755A 0.3s 0.10163104091298755A 0.30000000000099997s 0.1016322605235844A 0.312s 0.1016322605235844A 0.312000000001s 0.10163280257273857A 0.324s 0.10163280257273857A 0.324000000001s 0.10162480734771465A 0.336s 0.10162480734771465A 0.336000000001s 0.10162778861806256A 0.34800000000000003s 0.10162778861806256A 0.348000000001s 0.10163063437612191A 0.36s 0.10163063437612191A 0.36000000000099996s 0.10163171847443025A 0.372s 0.10163171847443025A 0.372000000001s 0.10163266706045004A 0.384s 0.10163266706045004A 0.384000000001s 0.1016272465689084A 0.396s 0.1016272465689084A 0.396000000001s 0.1016246718354261A 0.40800000000000003s 0.1016246718354261A 0.408000000001s 0.1016299568146792A 0.42s 0.1016299568146792A 0.42000000000099996s 0.10163144744985317A 0.432s 0.10163144744985317A 0.432000000001s 0.1016322605235844A 0.444s 0.1016322605235844A 0.444000000001s 0.1016322605235844A 0.456s 0.1016322605235844A 0.456000000001s 0.10162453632313757A 0.468s 0.10162453632313757A 0.468000000001s 0.10162887271637089A 0.48s 0.10162887271637089A 0.48000000000099996s 0.10163104091298755A 0.492s 0.10163104091298755A 0.49200000000099997s 0.1016322605235844A 0.504s 0.1016322605235844A 0.504000000001s 0.10163280257273857A 0.516s 0.10163280257273857A 0.516000000001s 0.10162494286000318A 0.528s 0.10162494286000318A 0.528000000001s 0.10162751759348546A 0.54s 0.10162751759348546A 0.540000000001s 0.10163076988841047A 0.552s 0.10163076988841047A 0.552000000001s 0.10163158296214171A 0.5640000000000001s 0.10163158296214171A 0.564000000001s 0.10163239603587298A 0.5760000000000001s 0.10163239603587298A 0.576000000001s 0.1016279241303511A 0.588s 0.1016279241303511A 0.588000000001s 0.10162521388458026A 0.6s 0.10162521388458026A 0.600000000001s 0.10162968579010215A 0.612s 0.10162968579010215A 0.612000000001s 0.10163131193756463A 0.624s 0.10163131193756463A 0.624000000001s 0.1016322605235844A 0.636s 0.1016322605235844A 0.636000000001s 0.10163131193756463A 0.648s 0.10163131193756463A 0.648000000001s 0.10162480734771465A 0.66s 0.10162480734771465A 0.660000000001s 0.10162846617950526A 0.672s 0.10162846617950526A 0.672000000001s 0.10162128402821255A 0.684s 0.10162128402821255A 0.684000000001s 0.10162047095448132A 0.6960000000000001s 0.10162047095448132A 0.696000000001s 0.10162047095448132A 0.708s 0.10162047095448132A 0.7080000000009999s 0.10162047095448132A 0.72s 0.10162047095448132A 0.720000000001s 0.10162047095448132A 0.732s 0.10162047095448132A 0.732000000001s 0.10162047095448132A 0.744s 0.10162047095448132A 0.744000000001s 0.10162047095448132A 0.756s 0.10162047095448132A 0.756000000001s 0.10162047095448132A 0.768s 0.10162047095448132A 0.768000000001s 0.10162047095448132A 0.78s 0.10162047095448132A 0.780000000001s 0.10162047095448132A 0.792s 0.10162047095448132A 0.792000000001s 0.10162047095448132A 0.804s 0.10162047095448132A 0.804000000001s 0.10162047095448132A 0.8160000000000001s 0.10162047095448132A 0.816000000001s 0.10162047095448132A 0.8280000000000001s 0.10162047095448132A 0.828000000001s 0.10162047095448132A 0.84s 0.10162047095448132A 0.840000000001s 0.10162047095448132A 0.852s 0.10162047095448132A 0.852000000001s 0.10162047095448132A 0.864s 0.10162047095448132A 0.864000000001s 0.10162047095448132A 0.876s 0.10162047095448132A 0.876000000001s 0.10162047095448132A 0.888s 0.10162047095448132A 0.888000000001s 0.10162047095448132A 0.9s 0.10162047095448132A 0.900000000001s 0.10162047095448132A 0.912s 0.10162047095448132A 0.912000000001s 0.10162047095448132A 0.924s 0.10162047095448132A 0.924000000001s 0.10162047095448132A 0.936s 0.10162047095448132A 0.936000000001s 0.10162047095448132A 0.9480000000000001s 0.10162047095448132A 0.948000000001s 0.10162047095448132A 0.96s 0.10162047095448132A 0.9600000000009999s 0.10162047095448132A 0.972s 0.10162047095448132A 0.972000000001s 0.10162047095448132A 0.984s 0.10162047095448132A 0.984000000001s 0.10162047095448132A 0.996s 0.10162047095448132A 0.996000000001s 0.10162047095448132A 1.008s 0.10162047095448132A 1.008000000001s 0.10162047095448132A 1.02s 0.10162047095448132A 1.020000000001s 0.10162047095448132A 1.032s 0.10162047095448132A 1.0320000000010001s 0.10162047095448132A 1.044s 0.10162047095448132A 1.0440000000010001s 0.10162047095448132A 1.056s 0.10162047095448132A 1.0560000000010001s 0.10162047095448132A 1.068s 0.10162047095448132A 1.0680000000010001s 0.10162060646676986A 1.08s 0.10162060646676986A 1.0800000000010002s 0.10162060646676986A 1.092s 0.10162060646676986A 1.0920000000010002s 0.10162060646676986A 1.104s 0.10162060646676986A 1.1040000000010002s 0.10162060646676986A 1.116s 0.10162060646676986A 1.1160000000010002s 0.10162060646676986A 1.1280000000000001s 0.10162060646676986A 1.1280000000010002s 0.10162060646676986A 1.1400000000000001s 0.10162060646676986A 1.1400000000010002s 0.10162060646676986A 1.1520000000000001s 0.10162060646676986A 1.1520000000010002s 0.10162060646676986A 1.164s 0.10162060646676986A 1.164000000001s 0.10162060646676986A 1.176s 0.10162060646676986A 1.176000000001s 0.10162047095448132A 1.188s 0.10162047095448132A 1.188000000001s 0.10162047095448132A 1.2s 0.10162047095448132A 1.200000000001s 0.10162047095448132A 1.212s 0.10162047095448132A 1.212000000001s 0.10162047095448132A 1.224s 0.10162047095448132A 1.224000000001s 0.10162047095448132A 1.236s 0.10162047095448132A 1.236000000001s 0.10162047095448132A 1.248s 0.10162047095448132A 1.248000000001s 0.10162047095448132A 1.26s 0.10162047095448132A 1.260000000001s 0.10162047095448132A 1.272s 0.10162047095448132A 1.272000000001s 0.10162047095448132A 1.284s 0.10162047095448132A 1.2840000000010001s 0.10162047095448132A 1.296s 0.10162047095448132A 1.2960000000010001s 0.10162047095448132A 1.308s 0.10162047095448132A 1.3080000000010001s 0.10162047095448132A 1.32s 0.10162047095448132A 1.3200000000010002s 0.10162047095448132A 1.332s 0.10162047095448132A 1.3320000000010002s 0.10162047095448132A 1.344s 0.10162047095448132A 1.3440000000010002s 0.10162047095448132A 1.356s 0.10162047095448132A 1.3560000000010002s 0.10162047095448132A 1.368s 0.10162047095448132A 1.3680000000010002s 0.10162047095448132A 1.3800000000000001s 0.10162047095448132A 1.3800000000010002s 0.10162047095448132A 1.3920000000000001s 0.10162047095448132A 1.3920000000010002s 0.10162047095448132A 1.4040000000000001s 0.10162047095448132A 1.4040000000010002s 0.10162047095448132A 1.416s 0.10162047095448132A 1.416000000001s 0.10162047095448132A 1.428s 0.10162047095448132A 1.428000000001s 0.10162047095448132A 1.44s 0.10162047095448132A 1.440000000001s 0.10162047095448132A 1.452s 0.10162047095448132A 1.452000000001s 0.10162047095448132A 1.464s 0.10162047095448132A 1.464000000001s 0.10162060646676986A 1.476s 0.10162060646676986A 1.476000000001s 0.10162060646676986A 1.488s 0.10162060646676986A 1.488000000001s 0.10162060646676986A 1.5s 0.10162060646676986A 1.500000000001s 0.10162060646676986A 1.512s 0.10162060646676986A 1.512000000001s 0.10162060646676986A 1.524s 0.10162060646676986A 1.524000000001s 0.10162060646676986A 1.536s 0.10162060646676986A 1.5360000000010001s 0.10162060646676986A 1.548s 0.10162060646676986A 1.5480000000010001s 0.10162060646676986A 1.56s 0.10162060646676986A 1.5600000000010001s 0.10162060646676986A 1.572s 0.10162060646676986A 1.5720000000010002s 0.10162047095448132A 1.584s 0.10162047095448132A 1.5840000000010002s 0.10162047095448132A 1.596s 0.10162047095448132A 1.5960000000010002s 0.10162047095448132A 1.608s 0.10162047095448132A 1.6080000000010002s 0.10162047095448132A 1.62s 0.10162047095448132A 1.6200000000010002s 0.10162047095448132A 1.6320000000000001s 0.10162047095448132A 1.6320000000010002s 0.10162047095448132A 1.6440000000000001s 0.10162047095448132A 1.6440000000010002s 0.10162047095448132A 1.6560000000000001s 0.10162047095448132A 1.6560000000010002s 0.10162047095448132A 1.668s 0.10162047095448132A 1.668000000001s 0.10162047095448132A 1.68s 0.10162047095448132A 1.680000000001s 0.10162047095448132A 1.692s 0.10162047095448132A 1.692000000001s 0.10162047095448132A 1.704s 0.10162047095448132A 1.704000000001s 0.10162047095448132A 1.716s 0.10162047095448132A 1.716000000001s 0.10162047095448132A 1.728s 0.10162047095448132A 1.728000000001s 0.10162047095448132A 1.74s 0.10162047095448132A 1.740000000001s 0.10162047095448132A 1.752s 0.10162047095448132A 1.752000000001s 0.10162047095448132A 1.764s 0.10162047095448132A 1.764000000001s 0.10162047095448132A 1.776s 0.10162047095448132A 1.7760000000010001s 0.10162047095448132A 1.788s 0.10162047095448132A 1.7880000000010001s 0.10162047095448132A 1.8s 0.10162047095448132A 1.8000000000010001s 0.10162047095448132A 1.812s 0.10162047095448132A 1.8120000000010001s 0.10162047095448132A 1.824s 0.10162047095448132A 1.8240000000010002s 0.10162047095448132A 1.836s 0.10162047095448132A 1.8360000000010002s 0.10162047095448132A 1.848s 0.10162047095448132A 1.8480000000010002s 0.10162047095448132A 1.86s 0.10162047095448132A 1.8600000000010002s 0.10162060646676986A 1.872s 0.10162060646676986A 1.8720000000010002s 0.1016207419790584A)
R_0_7_4_1 Node0_7_4 Node0_7_5 9.887809523809516
R_0_7_4_2 Node0_7_4 Node0_8_4 13.020765027322405
R_0_7_4_3 Node0_7_4 Node1_7_4 2.5950185402029655
C_0_7_4 Node0_7_4 GND 0.0009924144753600003
I_0_7_5 GND Node0_7_5 PWL(0s 0A 0.012s 0A 0.012000000001s 1.4165389557133936A 0.024s 1.4165389557133936A 0.024000000001s 3.01146779743656A 0.036000000000000004s 3.01146779743656A 0.036000000001s 3.4243866390132895A 0.048s 3.4243866390132895A 0.048000000001s 3.6406665167731487A 0.06s 3.6406665167731487A 0.060000000000999996s 3.8714110570193556A 0.07200000000000001s 3.8714110570193556A 0.07200000000100001s 1.221697944716016A 0.084s 1.221697944716016A 0.08400000000100001s 2.8158077070375036A 0.096s 2.8158077070375036A 0.09600000000100001s 3.4221154470394506A 0.108s 3.4221154470394506A 0.108000000001s 3.4948716267491693A 0.12s 3.4948716267491693A 0.120000000001s 4.003597459179101A 0.132s 4.003597459179101A 0.132000000001s 1.1915287437179247A 0.14400000000000002s 1.1915287437179247A 0.14400000000100002s 2.7356256934606136A 0.156s 2.7356256934606136A 0.156000000001s 3.3357280675932874A 0.168s 3.3357280675932874A 0.16800000000100002s 3.4288786701290284A 0.18s 3.4288786701290284A 0.180000000001s 3.7521009747547214A 0.192s 3.7521009747547214A 0.192000000001s 2.117710752024182A 0.20400000000000001s 2.117710752024182A 0.20400000000100002s 1.6235055502497062A 0.216s 1.6235055502497062A 0.216000000001s 3.0054216923850836A 0.228s 3.0054216923850836A 0.228000000001s 3.4709808491420566A 0.24s 3.4709808491420566A 0.240000000001s 3.550324038576896A 0.252s 3.550324038576896A 0.252000000001s 3.8577199274097342A 0.264s 3.8577199274097342A 0.264000000001s 1.1516748645664356A 0.276s 1.1516748645664356A 0.276000000001s 2.7895893585301503A 0.28800000000000003s 2.7895893585301503A 0.288000000001s 3.390209801142729A 0.3s 3.390209801142729A 0.30000000000099997s 3.5368354444907593A 0.312s 3.5368354444907593A 0.312000000001s 3.9684200411946713A 0.324s 3.9684200411946713A 0.324000000001s 1.175511686237235A 0.336s 1.175511686237235A 0.336000000001s 2.6650317814935076A 0.34800000000000003s 2.6650317814935076A 0.348000000001s 3.312312350529302A 0.36s 3.312312350529302A 0.36000000000099996s 3.437357211475156A 0.372s 3.437357211475156A 0.372000000001s 3.746202280119543A 0.384s 3.746202280119543A 0.384000000001s 2.02479341554454A 0.396s 2.02479341554454A 0.396000000001s 1.2784536121558938A 0.40800000000000003s 1.2784536121558938A 0.408000000001s 2.9780305498961797A 0.42s 2.9780305498961797A 0.42000000000099996s 3.3284581653908965A 0.432s 3.3284581653908965A 0.432000000001s 3.7410196639750826A 0.444s 3.7410196639750826A 0.444000000001s 3.8404119710674345A 0.456s 3.8404119710674345A 0.456000000001s 1.1857373699579887A 0.468s 1.1857373699579887A 0.468000000001s 2.7517366792795874A 0.48s 2.7517366792795874A 0.48000000000099996s 3.264966582529772A 0.492s 3.264966582529772A 0.49200000000099997s 3.6560630490047226A 0.504s 3.6560630490047226A 0.504000000001s 3.7553087294026555A 0.516s 3.7553087294026555A 0.516000000001s 1.4306056634112139A 0.528s 1.4306056634112139A 0.528000000001s 2.4159820573719624A 0.54s 2.4159820573719624A 0.540000000001s 3.09867855470135A 0.552s 3.09867855470135A 0.552000000001s 3.3701728762410395A 0.5640000000000001s 3.3701728762410395A 0.564000000001s 3.7507696224503966A 0.5760000000000001s 3.7507696224503966A 0.576000000001s 2.592131284701339A 0.588s 2.592131284701339A 0.588000000001s 1.3867700066313924A 0.6s 1.3867700066313924A 0.600000000001s 2.9477419577080695A 0.612s 2.9477419577080695A 0.612000000001s 3.3669086489554365A 0.624s 3.3669086489554365A 0.624000000001s 3.636673490344627A 0.636s 3.636673490344627A 0.636000000001s 3.886602086595607A 0.648s 3.886602086595607A 0.648000000001s 1.1224771399333995A 0.66s 1.1224771399333995A 0.660000000001s 2.7399310389511404A 0.672s 2.7399310389511404A 0.672000000001s 2.532709689355986A 0.684s 2.532709689355986A 0.684000000001s 2.5627298297261607A 0.6960000000000001s 2.5627298297261607A 0.696000000001s 2.5192448916645938A 0.708s 2.5192448916645938A 0.7080000000009999s 2.514096740661094A 0.72s 2.514096740661094A 0.720000000001s 2.5419694345829567A 0.732s 2.5419694345829567A 0.732000000001s 2.5550280929502165A 0.744s 2.5550280929502165A 0.744000000001s 2.5130202745801A 0.756s 2.5130202745801A 0.756000000001s 2.5222415823581157A 0.768s 2.5222415823581157A 0.768000000001s 2.5547647863721146A 0.78s 2.5547647863721146A 0.780000000001s 2.524061411170343A 0.792s 2.524061411170343A 0.792000000001s 2.512945597457037A 0.804s 2.512945597457037A 0.804000000001s 2.6790568012567664A 0.8160000000000001s 2.6790568012567664A 0.816000000001s 2.8275261544601102A 0.8280000000000001s 2.8275261544601102A 0.828000000001s 2.8363691962714093A 0.84s 2.8363691962714093A 0.840000000001s 2.8360701779155773A 0.852s 2.8360701779155773A 0.852000000001s 2.837305371616027A 0.864s 2.837305371616027A 0.864000000001s 2.838131080593957A 0.876s 2.838131080593957A 0.876000000001s 2.8363898021995566A 0.888s 2.8363898021995566A 0.888000000001s 2.841245364516534A 0.9s 2.841245364516534A 0.900000000001s 2.843238871866009A 0.912s 2.843238871866009A 0.912000000001s 2.841323062809513A 0.924s 2.841323062809513A 0.924000000001s 2.72131863029755A 0.936s 2.72131863029755A 0.936000000001s 2.8044916704946785A 0.9480000000000001s 2.8044916704946785A 0.948000000001s 2.78857978827198A 0.96s 2.78857978827198A 0.9600000000009999s 2.8253303836580237A 0.972s 2.8253303836580237A 0.972000000001s 2.8068942752371977A 0.984s 2.8068942752371977A 0.984000000001s 2.8078144926073847A 0.996s 2.8078144926073847A 0.996000000001s 2.8048910071849154A 1.008s 2.8048910071849154A 1.008000000001s 2.818975933733019A 1.02s 2.818975933733019A 1.020000000001s 2.8157397184912503A 1.032s 2.8157397184912503A 1.0320000000010001s 2.795376026197842A 1.044s 2.795376026197842A 1.0440000000010001s 0.8662684769227835A 1.056s 0.8662684769227835A 1.0560000000010001s 0.7970932141415533A 1.068s 0.7970932141415533A 1.0680000000010001s 3.1956421756738A 1.08s 3.1956421756738A 1.0800000000010002s 3.196130908007205A 1.092s 3.196130908007205A 1.0920000000010002s 3.210114741561951A 1.104s 3.210114741561951A 1.1040000000010002s 3.1886618013148254A 1.116s 3.1886618013148254A 1.1160000000010002s 3.203308665467386A 1.1280000000000001s 3.203308665467386A 1.1280000000010002s 3.225840008442888A 1.1400000000000001s 3.225840008442888A 1.1400000000010002s 3.2056970164851712A 1.1520000000000001s 3.2056970164851712A 1.1520000000010002s 3.1873311696313746A 1.164s 3.1873311696313746A 1.164000000001s 3.206564944376036A 1.176s 3.206564944376036A 1.176000000001s 2.6114037433180477A 1.188s 2.6114037433180477A 1.188000000001s 2.8295277957285907A 1.2s 2.8295277957285907A 1.200000000001s 2.838523600285408A 1.212s 2.838523600285408A 1.212000000001s 2.8343400546101A 1.224s 2.8343400546101A 1.224000000001s 2.836010064380829A 1.236s 2.836010064380829A 1.236000000001s 2.835103713405899A 1.248s 2.835103713405899A 1.248000000001s 2.843369634297264A 1.26s 2.843369634297264A 1.260000000001s 2.828939829583315A 1.272s 2.828939829583315A 1.272000000001s 2.8279939710017845A 1.284s 2.8279939710017845A 1.2840000000010001s 2.8276584662092707A 1.296s 2.8276584662092707A 1.2960000000010001s 2.7514988783084067A 1.308s 2.7514988783084067A 1.3080000000010001s 2.5133544624523942A 1.32s 2.5133544624523942A 1.3200000000010002s 2.5188333153629014A 1.332s 2.5188333153629014A 1.3320000000010002s 2.536228282150988A 1.344s 2.536228282150988A 1.3440000000010002s 2.522285815384328A 1.356s 2.522285815384328A 1.3560000000010002s 2.529338310491821A 1.368s 2.529338310491821A 1.3680000000010002s 2.541257368073422A 1.3800000000000001s 2.541257368073422A 1.3800000000010002s 2.5607549916574515A 1.3920000000000001s 2.5607549916574515A 1.3920000000010002s 2.5191647919288602A 1.4040000000000001s 2.5191647919288602A 1.4040000000010002s 2.5167728774798928A 1.416s 2.5167728774798928A 1.416000000001s 2.5449949425895277A 1.428s 2.5449949425895277A 1.428000000001s 1.852137883508031A 1.44s 1.852137883508031A 1.440000000001s 0.7786543944143908A 1.452s 0.7786543944143908A 1.452000000001s 1.106479450467531A 1.464s 1.106479450467531A 1.464000000001s 3.2002665797592225A 1.476s 3.2002665797592225A 1.476000000001s 3.197647070509883A 1.488s 3.197647070509883A 1.488000000001s 3.196293121591949A 1.5s 3.196293121591949A 1.500000000001s 3.1976641904727434A 1.512s 3.1976641904727434A 1.512000000001s 3.2034036386550158A 1.524s 3.2034036386550158A 1.524000000001s 3.199710761960494A 1.536s 3.199710761960494A 1.5360000000010001s 3.1952665435475236A 1.548s 3.1952665435475236A 1.5480000000010001s 3.1944945959009274A 1.56s 3.1944945959009274A 1.5600000000010001s 3.213277906464458A 1.572s 3.213277906464458A 1.5720000000010002s 2.507016280365401A 1.584s 2.507016280365401A 1.5840000000010002s 2.833117255452896A 1.596s 2.833117255452896A 1.5960000000010002s 2.84038959877123A 1.608s 2.84038959877123A 1.6080000000010002s 2.8333971397325897A 1.62s 2.8333971397325897A 1.6200000000010002s 2.8357558213124774A 1.6320000000000001s 2.8357558213124774A 1.6320000000010002s 2.838129763673737A 1.6440000000000001s 2.838129763673737A 1.6440000000010002s 2.8301305578598672A 1.6560000000000001s 2.8301305578598672A 1.6560000000010002s 2.829083218955503A 1.668s 2.829083218955503A 1.668000000001s 2.8271448673234767A 1.68s 2.8271448673234767A 1.680000000001s 2.8263109469606453A 1.692s 2.8263109469606453A 1.692000000001s 2.6323551693590446A 1.704s 2.6323551693590446A 1.704000000001s 2.521010571816012A 1.716s 2.521010571816012A 1.716000000001s 2.5617927247907994A 1.728s 2.5617927247907994A 1.728000000001s 2.495853289921861A 1.74s 2.495853289921861A 1.740000000001s 2.520617664795085A 1.752s 2.520617664795085A 1.752000000001s 2.548131149360473A 1.764s 2.548131149360473A 1.764000000001s 2.5175636493390456A 1.776s 2.5175636493390456A 1.7760000000010001s 2.5136602978070126A 1.788s 2.5136602978070126A 1.7880000000010001s 2.55061129746418A 1.8s 2.55061129746418A 1.8000000000010001s 2.5179530703946846A 1.812s 2.5179530703946846A 1.8120000000010001s 2.513504978686949A 1.824s 2.513504978686949A 1.8240000000010002s 1.169525611613164A 1.836s 1.169525611613164A 1.8360000000010002s 0.778580956745653A 1.848s 0.778580956745653A 1.8480000000010002s 2.018262488907646A 1.86s 2.018262488907646A 1.8600000000010002s 3.1976990501256255A 1.872s 3.1976990501256255A 1.8720000000010002s 3.1879093985016596A)
R_0_7_5_1 Node0_7_5 Node0_7_6 9.887809523809516
R_0_7_5_2 Node0_7_5 Node0_8_5 13.020765027322398
R_0_7_5_3 Node0_7_5 Node1_7_5 2.5950185402029624
C_0_7_5 Node0_7_5 GND 0.0009924144753600014
I_0_7_6 GND Node0_7_6 PWL(0s 0A 0.012s 0A 0.012000000001s 5.248777352131995A 0.024s 5.248777352131995A 0.024000000001s 11.492010841739887A 0.036000000000000004s 11.492010841739887A 0.036000000001s 13.108352699207211A 0.048s 13.108352699207211A 0.048000000001s 13.954963425583902A 0.06s 13.954963425583902A 0.060000000000999996s 14.858199133147647A 0.07200000000000001s 14.858199133147647A 0.07200000000100001s 4.486083406899511A 0.084s 4.486083406899511A 0.08400000000100001s 10.726113820098574A 0.096s 10.726113820098574A 0.09600000000100001s 13.099463047782315A 0.108s 13.099463047782315A 0.108000000001s 13.384259084465409A 0.12s 13.384259084465409A 0.120000000001s 15.375633490464983A 0.132s 15.375633490464983A 0.132000000001s 4.367987135033217A 0.14400000000000002s 4.367987135033217A 0.14400000000100002s 10.412249023526902A 0.156s 10.412249023526902A 0.156000000001s 12.761305753417627A 0.168s 12.761305753417627A 0.16800000000100002s 13.125934898992941A 0.18s 13.125934898992941A 0.180000000001s 14.391166758431554A 0.192s 14.391166758431554A 0.192000000001s 7.99346056515964A 0.20400000000000001s 7.99346056515964A 0.20400000000100002s 6.058932199014361A 0.216s 6.058932199014361A 0.216000000001s 11.468344525219639A 0.228s 11.468344525219639A 0.228000000001s 13.2907424743947A 0.24s 13.2907424743947A 0.240000000001s 13.601324140389986A 0.252s 13.601324140389986A 0.252000000001s 14.804608022969804A 0.264s 14.804608022969804A 0.264000000001s 4.211981576001719A 0.276s 4.211981576001719A 0.276000000001s 10.623485286993796A 0.28800000000000003s 10.623485286993796A 0.288000000001s 12.974570359031512A 0.3s 12.974570359031512A 0.30000000000099997s 13.548523868352275A 0.312s 13.548523868352275A 0.312000000001s 15.23793365108208A 0.324s 15.23793365108208A 0.324000000001s 4.305288953589033A 0.336s 4.305288953589033A 0.336000000001s 10.135915076237422A 0.34800000000000003s 10.135915076237422A 0.348000000001s 12.669646763916877A 0.36s 12.669646763916877A 0.36000000000099996s 13.159124022626967A 0.372s 13.159124022626967A 0.372000000001s 14.368076286093865A 0.384s 14.368076286093865A 0.384000000001s 7.629742945446761A 0.396s 7.629742945446761A 0.396000000001s 4.708249186886656A 0.40800000000000003s 4.708249186886656A 0.408000000001s 11.361123187486617A 0.42s 11.361123187486617A 0.42000000000099996s 12.732846193614758A 0.432s 12.732846193614758A 0.432000000001s 14.347790438740105A 0.444s 14.347790438740105A 0.444000000001s 14.736855512491983A 0.456s 14.736855512491983A 0.456000000001s 4.345317553546179A 0.468s 4.345317553546179A 0.468000000001s 10.475312906963799A 0.48s 10.475312906963799A 0.48000000000099996s 12.484313481894162A 0.492s 12.484313481894162A 0.49200000000099997s 14.015232994043295A 0.504s 14.015232994043295A 0.504000000001s 14.403722526848096A 0.516s 14.403722526848096A 0.516000000001s 5.303838244696813A 0.528s 5.303838244696813A 0.528000000001s 9.161026036940227A 0.54s 9.161026036940227A 0.540000000001s 11.83339001311336A 0.552s 11.83339001311336A 0.552000000001s 12.896135468952231A 0.5640000000000001s 12.896135468952231A 0.564000000001s 14.385955656653111A 0.5760000000000001s 14.385955656653111A 0.576000000001s 9.850550169787882A 0.588s 9.850550169787882A 0.588000000001s 5.132245472123425A 0.6s 5.132245472123425A 0.600000000001s 11.242561145918158A 0.612s 11.242561145918158A 0.612000000001s 12.883358641868451A 0.624s 12.883358641868451A 0.624000000001s 13.939333759074366A 0.636s 13.939333759074366A 0.636000000001s 14.917666643754032A 0.648s 14.917666643754032A 0.648000000001s 4.097688483565464A 0.66s 4.097688483565464A 0.660000000001s 10.429101638740102A 0.672s 10.429101638740102A 0.672000000001s 9.617967341247063A 0.684s 9.617967341247063A 0.684000000001s 9.735481704221137A 0.6960000000000001s 9.735481704221137A 0.696000000001s 9.565262588386553A 0.708s 9.565262588386553A 0.7080000000009999s 9.545110467880875A 0.72s 9.545110467880875A 0.720000000001s 9.654216414141855A 0.732s 9.654216414141855A 0.732000000001s 9.705333729247922A 0.744s 9.705333729247922A 0.744000000001s 9.54089670760661A 0.756s 9.54089670760661A 0.756000000001s 9.57699294981788A 0.768s 9.57699294981788A 0.768000000001s 9.704303031840592A 0.78s 9.704303031840592A 0.780000000001s 9.584116557788738A 0.792s 9.584116557788738A 0.792000000001s 9.540604388600823A 0.804s 9.540604388600823A 0.804000000001s 10.190836480479977A 0.8160000000000001s 10.190836480479977A 0.816000000001s 10.772010633126218A 0.8280000000000001s 10.772010633126218A 0.828000000001s 10.80662617647312A 0.84s 10.80662617647312A 0.840000000001s 10.805455687508045A 0.852s 10.805455687508045A 0.852000000001s 10.810290777287348A 0.864s 10.810290777287348A 0.864000000001s 10.813522964302559A 0.876s 10.813522964302559A 0.876000000001s 10.806706837111644A 0.888s 10.806706837111644A 0.888000000001s 10.825713637197353A 0.9s 10.825713637197353A 0.900000000001s 10.833517099121503A 0.912s 10.833517099121503A 0.912000000001s 10.826017782386984A 0.924s 10.826017782386984A 0.924000000001s 10.356267811270635A 0.936s 10.356267811270635A 0.936000000001s 10.68184356220271A 0.9480000000000001s 10.68184356220271A 0.948000000001s 10.619557477780168A 0.96s 10.619557477780168A 0.9600000000009999s 10.763415423355484A 0.972s 10.763415423355484A 0.972000000001s 10.691248410713534A 0.984s 10.691248410713534A 0.984000000001s 10.694850545018223A 0.996s 10.694850545018223A 0.996000000001s 10.683406741118503A 1.008s 10.683406741118503A 1.008000000001s 10.738541319905732A 1.02s 10.738541319905732A 1.020000000001s 10.725873354360413A 1.032s 10.725873354360413A 1.0320000000010001s 10.646160933190496A 1.044s 10.646160933190496A 1.0440000000010001s 3.094788066509538A 1.056s 3.094788066509538A 1.0560000000010001s 2.8240057544461137A 1.068s 2.8240057544461137A 1.0680000000010001s 12.212977765073935A 1.08s 12.212977765073935A 1.0800000000010002s 12.214890877737318A 1.092s 12.214890877737318A 1.0920000000010002s 12.269629734218995A 1.104s 12.269629734218995A 1.1040000000010002s 12.185653518920088A 1.116s 12.185653518920088A 1.1160000000010002s 12.242987767902303A 1.1280000000000001s 12.242987767902303A 1.1280000000010002s 12.331185324362556A 1.1400000000000001s 12.331185324362556A 1.1400000000010002s 12.252336821084223A 1.1520000000000001s 12.252336821084223A 1.1520000000010002s 12.18044484302551A 1.164s 12.18044484302551A 1.164000000001s 12.255734271437767A 1.176s 12.255734271437767A 1.176000000001s 9.926012745661035A 1.188s 9.926012745661035A 1.188000000001s 10.779845934776098A 1.2s 10.779845934776098A 1.200000000001s 10.815059458495833A 1.212s 10.815059458495833A 1.212000000001s 10.798683226226714A 1.224s 10.798683226226714A 1.224000000001s 10.805220376773097A 1.236s 10.805220376773097A 1.236000000001s 10.801672521619894A 1.248s 10.801672521619894A 1.248000000001s 10.83402896061711A 1.26s 10.83402896061711A 1.260000000001s 10.777544377458764A 1.272s 10.777544377458764A 1.272000000001s 10.773841872209136A 1.284s 10.773841872209136A 1.2840000000010001s 10.772528559331489A 1.296s 10.772528559331489A 1.2960000000010001s 10.474406536104578A 1.308s 10.474406536104578A 1.3080000000010001s 9.542204865481045A 1.32s 9.542204865481045A 1.3200000000010002s 9.56365149826442A 1.332s 9.56365149826442A 1.3320000000010002s 9.631743026012437A 1.344s 9.631743026012437A 1.3440000000010002s 9.577166097278775A 1.356s 9.577166097278775A 1.3560000000010002s 9.604772655667462A 1.368s 9.604772655667462A 1.3680000000010002s 9.651429073580468A 1.3800000000000001s 9.651429073580468A 1.3800000000010002s 9.727751322048434A 1.3920000000000001s 9.727751322048434A 1.3920000000010002s 9.564949042896943A 1.4040000000000001s 9.564949042896943A 1.4040000000010002s 9.555586040882803A 1.416s 9.555586040882803A 1.416000000001s 9.666059579172925A 1.428s 9.666059579172925A 1.428000000001s 6.953913230254988A 1.44s 6.953913230254988A 1.440000000001s 2.7518281285622477A 1.452s 2.7518281285622477A 1.452000000001s 4.035079150117852A 1.464s 4.035079150117852A 1.464000000001s 12.231079710477836A 1.476s 12.231079710477836A 1.476000000001s 12.220825802614112A 1.488s 12.220825802614112A 1.488000000001s 12.215525852839093A 1.5s 12.215525852839093A 1.500000000001s 12.220892817655896A 1.512s 12.220892817655896A 1.512000000001s 12.243359534604682A 1.524s 12.243359534604682A 1.524000000001s 12.22890399588602A 1.536s 12.22890399588602A 1.5360000000010001s 12.211507376215996A 1.548s 12.211507376215996A 1.5480000000010001s 12.208485634626113A 1.56s 12.208485634626113A 1.5600000000010001s 12.282011748703676A 1.572s 12.282011748703676A 1.5720000000010002s 9.517394441482761A 1.584s 9.517394441482761A 1.5840000000010002s 10.793896654124715A 1.596s 10.793896654124715A 1.5960000000010002s 10.822363794814667A 1.608s 10.822363794814667A 1.6080000000010002s 10.794992243925442A 1.62s 10.794992243925442A 1.6200000000010002s 10.804225157917303A 1.6320000000000001s 10.804225157917303A 1.6320000000010002s 10.813517809299347A 1.6440000000000001s 10.813517809299347A 1.6440000000010002s 10.782205410070722A 1.6560000000000001s 10.782205410070722A 1.6560000000010002s 10.77810566633813A 1.668s 10.77810566633813A 1.668000000001s 10.770518108078006A 1.68s 10.770518108078006A 1.680000000001s 10.767253778101574A 1.692s 10.767253778101574A 1.692000000001s 10.008025814441837A 1.704s 10.008025814441837A 1.704000000001s 9.572174234754671A 1.716s 9.572174234754671A 1.716000000001s 9.731813464581112A 1.728s 9.731813464581112A 1.728000000001s 9.47369760188559A 1.74s 9.47369760188559A 1.740000000001s 9.570636224383984A 1.752s 9.570636224383984A 1.752000000001s 9.67833606770946A 1.764s 9.67833606770946A 1.764000000001s 9.558681468695104A 1.776s 9.558681468695104A 1.7760000000010001s 9.543402039168642A 1.788s 9.543402039168642A 1.7880000000010001s 9.688044454938943A 1.8s 9.688044454938943A 1.8000000000010001s 9.560205833469047A 1.812s 9.560205833469047A 1.8120000000010001s 9.542794052024863A 1.824s 9.542794052024863A 1.8240000000010002s 4.281869470752094A 1.836s 4.281869470752094A 1.8360000000010002s 2.751540661324194A 1.848s 2.751540661324194A 1.8480000000010002s 7.60419778187273A 1.86s 7.60419778187273A 1.8600000000010002s 12.221029273623326A 1.872s 12.221029273623326A 1.8720000000010002s 12.18270788943648A)
R_0_7_6_1 Node0_7_6 Node0_7_7 9.887809523809521
R_0_7_6_2 Node0_7_6 Node0_8_6 13.020765027322406
R_0_7_6_3 Node0_7_6 Node1_7_6 2.5950185402029655
C_0_7_6 Node0_7_6 GND 0.0009924144753600003
I_0_7_7 GND Node0_7_7 PWL(0s 0A 0.012s 0A 0.012000000001s 5.248777352131995A 0.024s 5.248777352131995A 0.024000000001s 11.492010841739887A 0.036000000000000004s 11.492010841739887A 0.036000000001s 13.108352699207211A 0.048s 13.108352699207211A 0.048000000001s 13.954963425583902A 0.06s 13.954963425583902A 0.060000000000999996s 14.858199133147647A 0.07200000000000001s 14.858199133147647A 0.07200000000100001s 4.486083406899511A 0.084s 4.486083406899511A 0.08400000000100001s 10.726113820098574A 0.096s 10.726113820098574A 0.09600000000100001s 13.099463047782315A 0.108s 13.099463047782315A 0.108000000001s 13.384259084465409A 0.12s 13.384259084465409A 0.120000000001s 15.375633490464983A 0.132s 15.375633490464983A 0.132000000001s 4.367987135033217A 0.14400000000000002s 4.367987135033217A 0.14400000000100002s 10.412249023526902A 0.156s 10.412249023526902A 0.156000000001s 12.761305753417627A 0.168s 12.761305753417627A 0.16800000000100002s 13.125934898992941A 0.18s 13.125934898992941A 0.180000000001s 14.391166758431554A 0.192s 14.391166758431554A 0.192000000001s 7.99346056515964A 0.20400000000000001s 7.99346056515964A 0.20400000000100002s 6.058932199014361A 0.216s 6.058932199014361A 0.216000000001s 11.468344525219639A 0.228s 11.468344525219639A 0.228000000001s 13.2907424743947A 0.24s 13.2907424743947A 0.240000000001s 13.601324140389986A 0.252s 13.601324140389986A 0.252000000001s 14.804608022969804A 0.264s 14.804608022969804A 0.264000000001s 4.211981576001719A 0.276s 4.211981576001719A 0.276000000001s 10.623485286993796A 0.28800000000000003s 10.623485286993796A 0.288000000001s 12.974570359031512A 0.3s 12.974570359031512A 0.30000000000099997s 13.548523868352275A 0.312s 13.548523868352275A 0.312000000001s 15.23793365108208A 0.324s 15.23793365108208A 0.324000000001s 4.305288953589033A 0.336s 4.305288953589033A 0.336000000001s 10.135915076237422A 0.34800000000000003s 10.135915076237422A 0.348000000001s 12.669646763916877A 0.36s 12.669646763916877A 0.36000000000099996s 13.159124022626967A 0.372s 13.159124022626967A 0.372000000001s 14.368076286093865A 0.384s 14.368076286093865A 0.384000000001s 7.629742945446761A 0.396s 7.629742945446761A 0.396000000001s 4.708249186886656A 0.40800000000000003s 4.708249186886656A 0.408000000001s 11.361123187486617A 0.42s 11.361123187486617A 0.42000000000099996s 12.732846193614758A 0.432s 12.732846193614758A 0.432000000001s 14.347790438740105A 0.444s 14.347790438740105A 0.444000000001s 14.736855512491983A 0.456s 14.736855512491983A 0.456000000001s 4.345317553546179A 0.468s 4.345317553546179A 0.468000000001s 10.475312906963799A 0.48s 10.475312906963799A 0.48000000000099996s 12.484313481894162A 0.492s 12.484313481894162A 0.49200000000099997s 14.015232994043295A 0.504s 14.015232994043295A 0.504000000001s 14.403722526848096A 0.516s 14.403722526848096A 0.516000000001s 5.303838244696813A 0.528s 5.303838244696813A 0.528000000001s 9.161026036940227A 0.54s 9.161026036940227A 0.540000000001s 11.83339001311336A 0.552s 11.83339001311336A 0.552000000001s 12.896135468952231A 0.5640000000000001s 12.896135468952231A 0.564000000001s 14.385955656653111A 0.5760000000000001s 14.385955656653111A 0.576000000001s 9.850550169787882A 0.588s 9.850550169787882A 0.588000000001s 5.132245472123425A 0.6s 5.132245472123425A 0.600000000001s 11.242561145918158A 0.612s 11.242561145918158A 0.612000000001s 12.883358641868451A 0.624s 12.883358641868451A 0.624000000001s 13.939333759074366A 0.636s 13.939333759074366A 0.636000000001s 14.917666643754032A 0.648s 14.917666643754032A 0.648000000001s 4.097688483565464A 0.66s 4.097688483565464A 0.660000000001s 10.429101638740102A 0.672s 10.429101638740102A 0.672000000001s 9.617967341247063A 0.684s 9.617967341247063A 0.684000000001s 9.735481704221137A 0.6960000000000001s 9.735481704221137A 0.696000000001s 9.565262588386553A 0.708s 9.565262588386553A 0.7080000000009999s 9.545110467880875A 0.72s 9.545110467880875A 0.720000000001s 9.654216414141855A 0.732s 9.654216414141855A 0.732000000001s 9.705333729247922A 0.744s 9.705333729247922A 0.744000000001s 9.54089670760661A 0.756s 9.54089670760661A 0.756000000001s 9.57699294981788A 0.768s 9.57699294981788A 0.768000000001s 9.704303031840592A 0.78s 9.704303031840592A 0.780000000001s 9.584116557788738A 0.792s 9.584116557788738A 0.792000000001s 9.540604388600823A 0.804s 9.540604388600823A 0.804000000001s 10.190836480479977A 0.8160000000000001s 10.190836480479977A 0.816000000001s 10.772010633126218A 0.8280000000000001s 10.772010633126218A 0.828000000001s 10.80662617647312A 0.84s 10.80662617647312A 0.840000000001s 10.805455687508045A 0.852s 10.805455687508045A 0.852000000001s 10.810290777287348A 0.864s 10.810290777287348A 0.864000000001s 10.813522964302559A 0.876s 10.813522964302559A 0.876000000001s 10.806706837111644A 0.888s 10.806706837111644A 0.888000000001s 10.825713637197353A 0.9s 10.825713637197353A 0.900000000001s 10.833517099121503A 0.912s 10.833517099121503A 0.912000000001s 10.826017782386984A 0.924s 10.826017782386984A 0.924000000001s 10.356267811270635A 0.936s 10.356267811270635A 0.936000000001s 10.68184356220271A 0.9480000000000001s 10.68184356220271A 0.948000000001s 10.619557477780168A 0.96s 10.619557477780168A 0.9600000000009999s 10.763415423355484A 0.972s 10.763415423355484A 0.972000000001s 10.691248410713534A 0.984s 10.691248410713534A 0.984000000001s 10.694850545018223A 0.996s 10.694850545018223A 0.996000000001s 10.683406741118503A 1.008s 10.683406741118503A 1.008000000001s 10.738541319905732A 1.02s 10.738541319905732A 1.020000000001s 10.725873354360413A 1.032s 10.725873354360413A 1.0320000000010001s 10.646160933190496A 1.044s 10.646160933190496A 1.0440000000010001s 3.094788066509538A 1.056s 3.094788066509538A 1.0560000000010001s 2.8240057544461137A 1.068s 2.8240057544461137A 1.0680000000010001s 12.212977765073935A 1.08s 12.212977765073935A 1.0800000000010002s 12.214890877737318A 1.092s 12.214890877737318A 1.0920000000010002s 12.269629734218995A 1.104s 12.269629734218995A 1.1040000000010002s 12.185653518920088A 1.116s 12.185653518920088A 1.1160000000010002s 12.242987767902303A 1.1280000000000001s 12.242987767902303A 1.1280000000010002s 12.331185324362556A 1.1400000000000001s 12.331185324362556A 1.1400000000010002s 12.252336821084223A 1.1520000000000001s 12.252336821084223A 1.1520000000010002s 12.18044484302551A 1.164s 12.18044484302551A 1.164000000001s 12.255734271437767A 1.176s 12.255734271437767A 1.176000000001s 9.926012745661035A 1.188s 9.926012745661035A 1.188000000001s 10.779845934776098A 1.2s 10.779845934776098A 1.200000000001s 10.815059458495833A 1.212s 10.815059458495833A 1.212000000001s 10.798683226226714A 1.224s 10.798683226226714A 1.224000000001s 10.805220376773097A 1.236s 10.805220376773097A 1.236000000001s 10.801672521619894A 1.248s 10.801672521619894A 1.248000000001s 10.83402896061711A 1.26s 10.83402896061711A 1.260000000001s 10.777544377458764A 1.272s 10.777544377458764A 1.272000000001s 10.773841872209136A 1.284s 10.773841872209136A 1.2840000000010001s 10.772528559331489A 1.296s 10.772528559331489A 1.2960000000010001s 10.474406536104578A 1.308s 10.474406536104578A 1.3080000000010001s 9.542204865481045A 1.32s 9.542204865481045A 1.3200000000010002s 9.56365149826442A 1.332s 9.56365149826442A 1.3320000000010002s 9.631743026012437A 1.344s 9.631743026012437A 1.3440000000010002s 9.577166097278775A 1.356s 9.577166097278775A 1.3560000000010002s 9.604772655667462A 1.368s 9.604772655667462A 1.3680000000010002s 9.651429073580468A 1.3800000000000001s 9.651429073580468A 1.3800000000010002s 9.727751322048434A 1.3920000000000001s 9.727751322048434A 1.3920000000010002s 9.564949042896943A 1.4040000000000001s 9.564949042896943A 1.4040000000010002s 9.555586040882803A 1.416s 9.555586040882803A 1.416000000001s 9.666059579172925A 1.428s 9.666059579172925A 1.428000000001s 6.953913230254988A 1.44s 6.953913230254988A 1.440000000001s 2.7518281285622477A 1.452s 2.7518281285622477A 1.452000000001s 4.035079150117852A 1.464s 4.035079150117852A 1.464000000001s 12.231079710477836A 1.476s 12.231079710477836A 1.476000000001s 12.220825802614112A 1.488s 12.220825802614112A 1.488000000001s 12.215525852839093A 1.5s 12.215525852839093A 1.500000000001s 12.220892817655896A 1.512s 12.220892817655896A 1.512000000001s 12.243359534604682A 1.524s 12.243359534604682A 1.524000000001s 12.22890399588602A 1.536s 12.22890399588602A 1.5360000000010001s 12.211507376215996A 1.548s 12.211507376215996A 1.5480000000010001s 12.208485634626113A 1.56s 12.208485634626113A 1.5600000000010001s 12.282011748703676A 1.572s 12.282011748703676A 1.5720000000010002s 9.517394441482761A 1.584s 9.517394441482761A 1.5840000000010002s 10.793896654124715A 1.596s 10.793896654124715A 1.5960000000010002s 10.822363794814667A 1.608s 10.822363794814667A 1.6080000000010002s 10.794992243925442A 1.62s 10.794992243925442A 1.6200000000010002s 10.804225157917303A 1.6320000000000001s 10.804225157917303A 1.6320000000010002s 10.813517809299347A 1.6440000000000001s 10.813517809299347A 1.6440000000010002s 10.782205410070722A 1.6560000000000001s 10.782205410070722A 1.6560000000010002s 10.77810566633813A 1.668s 10.77810566633813A 1.668000000001s 10.770518108078006A 1.68s 10.770518108078006A 1.680000000001s 10.767253778101574A 1.692s 10.767253778101574A 1.692000000001s 10.008025814441837A 1.704s 10.008025814441837A 1.704000000001s 9.572174234754671A 1.716s 9.572174234754671A 1.716000000001s 9.731813464581112A 1.728s 9.731813464581112A 1.728000000001s 9.47369760188559A 1.74s 9.47369760188559A 1.740000000001s 9.570636224383984A 1.752s 9.570636224383984A 1.752000000001s 9.67833606770946A 1.764s 9.67833606770946A 1.764000000001s 9.558681468695104A 1.776s 9.558681468695104A 1.7760000000010001s 9.543402039168642A 1.788s 9.543402039168642A 1.7880000000010001s 9.688044454938943A 1.8s 9.688044454938943A 1.8000000000010001s 9.560205833469047A 1.812s 9.560205833469047A 1.8120000000010001s 9.542794052024863A 1.824s 9.542794052024863A 1.8240000000010002s 4.281869470752094A 1.836s 4.281869470752094A 1.8360000000010002s 2.751540661324194A 1.848s 2.751540661324194A 1.8480000000010002s 7.60419778187273A 1.86s 7.60419778187273A 1.8600000000010002s 12.221029273623326A 1.872s 12.221029273623326A 1.8720000000010002s 12.18270788943648A)
R_0_7_7_1 Node0_7_7 Node0_7_8 9.887809523809526
R_0_7_7_2 Node0_7_7 Node0_8_7 13.020765027322406
R_0_7_7_3 Node0_7_7 Node1_7_7 2.5950185402029655
C_0_7_7 Node0_7_7 GND 0.0009924144753600003
I_0_7_8 GND Node0_7_8 PWL(0s 0A 0.012s 0A 0.012000000001s 1.0479854254981738A 0.024s 1.0479854254981738A 0.024000000001s 2.2761625054210306A 0.036000000000000004s 2.2761625054210306A 0.036000000001s 2.5941313954146006A 0.048s 2.5941313954146006A 0.048000000001s 2.7606777678165715A 0.06s 2.7606777678165715A 0.060000000000999996s 2.9383634807799304A 0.07200000000000001s 2.9383634807799304A 0.07200000000100001s 0.8979472723376858A 0.084s 0.8979472723376858A 0.08400000000100001s 2.125494238868642A 0.096s 2.125494238868642A 0.09600000000100001s 2.5923826115277357A 0.108s 2.5923826115277357A 0.108000000001s 2.6484080613670327A 0.12s 2.6484080613670327A 0.120000000001s 3.040153846153832A 0.132s 3.040153846153832A 0.132000000001s 0.874715218855792A 0.14400000000000002s 0.874715218855792A 0.14400000000100002s 2.0637503444611003A 0.156s 2.0637503444611003A 0.156000000001s 2.5258598650953386A 0.168s 2.5258598650953386A 0.16800000000100002s 2.5975901888150723A 0.18s 2.5975901888150723A 0.180000000001s 2.846488259524306A 0.192s 2.846488259524306A 0.192000000001s 1.5879231067495103A 0.20400000000000001s 1.5879231067495103A 0.20400000000100002s 1.2073601494750317A 0.216s 1.2073601494750317A 0.216000000001s 2.271506836597375A 0.228s 2.271506836597375A 0.228000000001s 2.630011351189188A 0.24s 2.630011351189188A 0.240000000001s 2.6911093838439983A 0.252s 2.6911093838439983A 0.252000000001s 2.927820967302322A 0.264s 2.927820967302322A 0.264000000001s 0.8440256006856615A 0.276s 0.8440256006856615A 0.276000000001s 2.105305019241473A 0.28800000000000003s 2.105305019241473A 0.288000000001s 2.567813558002988A 0.3s 2.567813558002988A 0.30000000000099997s 2.6807224450824814A 0.312s 2.6807224450824814A 0.312000000001s 3.0130653531604743A 0.324s 3.0130653531604743A 0.324000000001s 0.8623811503749691A 0.336s 0.8623811503749691A 0.336000000001s 2.0093895679451372A 0.34800000000000003s 2.0093895679451372A 0.348000000001s 2.50782858847224A 0.36s 2.50782858847224A 0.36000000000099996s 2.6041191967430772A 0.372s 2.6041191967430772A 0.372000000001s 2.841945871523449A 0.384s 2.841945871523449A 0.384000000001s 1.516372099592879A 0.396s 1.516372099592879A 0.396000000001s 0.941652015941714A 0.40800000000000003s 0.941652015941714A 0.408000000001s 2.2504141144203875A 0.42s 2.2504141144203875A 0.42000000000099996s 2.5202612631669052A 0.432s 2.5202612631669052A 0.432000000001s 2.8379552130276275A 0.444s 2.8379552130276275A 0.444000000001s 2.9144926045853734A 0.456s 2.9144926045853734A 0.456000000001s 0.8702556290550634A 0.468s 0.8702556290550634A 0.468000000001s 2.076156354317539A 0.48s 2.076156354317539A 0.48000000000099996s 2.4713695821726898A 0.492s 2.4713695821726898A 0.49200000000099997s 2.77253407636596A 0.504s 2.77253407636596A 0.504000000001s 2.8489582467537895A 0.516s 2.8489582467537895A 0.516000000001s 1.0588170764945313A 0.528s 1.0588170764945313A 0.528000000001s 1.8176081175915917A 0.54s 1.8176081175915917A 0.540000000001s 2.3433190637240084A 0.552s 2.3433190637240084A 0.552000000001s 2.5523837435611623A 0.5640000000000001s 2.5523837435611623A 0.564000000001s 2.845463124748219A 0.5760000000000001s 2.845463124748219A 0.576000000001s 1.9532522092993263A 0.588s 1.9532522092993263A 0.588000000001s 1.0250611212341927A 0.6s 1.0250611212341927A 0.600000000001s 2.227090434111838A 0.612s 2.227090434111838A 0.612000000001s 2.5498702693807465A 0.624s 2.5498702693807465A 0.624000000001s 2.7576030793228923A 0.636s 2.7576030793228923A 0.636000000001s 2.950062007456596A 0.648s 2.950062007456596A 0.648000000001s 0.8215417136490213A 0.66s 0.8215417136490213A 0.660000000001s 2.0670656130276313A 0.672s 2.0670656130276313A 0.672000000001s 1.9074982102421165A 0.684s 1.9074982102421165A 0.684000000001s 1.9306157898435732A 0.6960000000000001s 1.9306157898435732A 0.696000000001s 1.8971300621384095A 0.708s 1.8971300621384095A 0.7080000000009999s 1.893165710563522A 0.72s 1.893165710563522A 0.720000000001s 1.9146291754017475A 0.732s 1.9146291754017475A 0.732000000001s 1.9246850406685145A 0.744s 1.9246850406685145A 0.744000000001s 1.8923367741161257A 0.756s 1.8923367741161257A 0.756000000001s 1.8994376742232608A 0.768s 1.8994376742232608A 0.768000000001s 1.9244822805228106A 0.78s 1.9244822805228106A 0.780000000001s 1.9008390397257247A 0.792s 1.9008390397257247A 0.792000000001s 1.8922792687379382A 0.804s 1.8922792687379382A 0.804000000001s 2.0201937786158037A 0.8160000000000001s 2.0201937786158037A 0.816000000001s 2.1345231201199817A 0.8280000000000001s 2.1345231201199817A 0.828000000001s 2.1413327352046183A 0.84s 2.1413327352046183A 0.840000000001s 2.1411024750803413A 0.852s 2.1411024750803413A 0.852000000001s 2.142053640282827A 0.864s 2.142053640282827A 0.864000000001s 2.142689480351393A 0.876s 2.142689480351393A 0.876000000001s 2.141348602871213A 0.888s 2.141348602871213A 0.888000000001s 2.145087645511025A 0.9s 2.145087645511025A 0.900000000001s 2.1466227527747916A 0.912s 2.1466227527747916A 0.912000000001s 2.1451474773516077A 0.924s 2.1451474773516077A 0.924000000001s 2.052737646968064A 0.936s 2.052737646968064A 0.936000000001s 2.116785335676013A 0.9480000000000001s 2.116785335676013A 0.948000000001s 2.1045323354617427A 0.96s 2.1045323354617427A 0.9600000000009999s 2.132832259181477A 0.972s 2.132832259181477A 0.972000000001s 2.11863546980929A 0.984s 2.11863546980929A 0.984000000001s 2.119344086393819A 0.996s 2.119344086393819A 0.996000000001s 2.1170928462823984A 1.008s 2.1170928462823984A 1.008000000001s 2.1279389929290664A 1.02s 2.1279389929290664A 1.020000000001s 2.125446934133266A 1.032s 2.125446934133266A 1.0320000000010001s 2.1097658020998398A 1.044s 2.1097658020998398A 1.0440000000010001s 0.6242498283265452A 1.056s 0.6242498283265452A 1.0560000000010001s 0.570981176773085A 1.068s 0.570981176773085A 1.0680000000010001s 2.417992064109695A 1.08s 2.417992064109695A 1.0800000000010002s 2.4183684141418356A 1.092s 2.4183684141418356A 1.0920000000010002s 2.4291367137775755A 1.104s 2.4291367137775755A 1.1040000000010002s 2.4126168025712333A 1.116s 2.4126168025712333A 1.1160000000010002s 2.4238956712234723A 1.1280000000000001s 2.4238956712234723A 1.1280000000010002s 2.4412460101992597A 1.1400000000000001s 2.4412460101992597A 1.1400000000010002s 2.4257348292264727A 1.1520000000000001s 2.4257348292264727A 1.1520000000010002s 2.4115921450182016A 1.164s 2.4115921450182016A 1.164000000001s 2.4264031801156944A 1.176s 2.4264031801156944A 1.176000000001s 1.9680973061924056A 1.188s 1.9680973061924056A 1.188000000001s 2.1360644909363518A 1.2s 2.1360644909363518A 1.200000000001s 2.142991741504168A 1.212s 2.142991741504168A 1.212000000001s 2.139770187615161A 1.224s 2.139770187615161A 1.224000000001s 2.1410561844439577A 1.236s 2.1410561844439577A 1.236000000001s 2.140358245725295A 1.248s 2.140358245725295A 1.248000000001s 2.146723446839501A 1.26s 2.146723446839501A 1.260000000001s 2.1356117255624496A 1.272s 2.1356117255624496A 1.272000000001s 2.1348833638739984A 1.284s 2.1348833638739984A 1.2840000000010001s 2.13462500724233A 1.296s 2.13462500724233A 1.2960000000010001s 2.0759780518534297A 1.308s 2.0759780518534297A 1.3080000000010001s 1.8925941166488014A 1.32s 1.8925941166488014A 1.3200000000010002s 1.8968131263766785A 1.332s 1.8968131263766785A 1.3320000000010002s 1.9102081810156326A 1.344s 1.9102081810156326A 1.3440000000010002s 1.899471736018847A 1.356s 1.899471736018847A 1.3560000000010002s 1.9049025343903918A 1.368s 1.9049025343903918A 1.3680000000010002s 1.914080846110983A 1.3800000000000001s 1.914080846110983A 1.3800000000010002s 1.9290950589243532A 1.3920000000000001s 1.9290950589243532A 1.3920000000010002s 1.8970683810584865A 1.4040000000000001s 1.8970683810584865A 1.4040000000010002s 1.8952264790229179A 1.416s 1.8952264790229179A 1.416000000001s 1.9169589783586793A 1.428s 1.9169589783586793A 1.428000000001s 1.3834219916863015A 1.44s 1.3834219916863015A 1.440000000001s 0.5567822995500294A 1.452s 0.5567822995500294A 1.452000000001s 0.8092251234626058A 1.464s 0.8092251234626058A 1.464000000001s 2.4215531025498063A 1.476s 2.4215531025498063A 1.476000000001s 2.4195359403471066A 1.488s 2.4195359403471066A 1.488000000001s 2.4184933272766114A 1.5s 2.4184933272766114A 1.500000000001s 2.419549123634015A 1.512s 2.419549123634015A 1.512000000001s 2.423968805656727A 1.524s 2.423968805656727A 1.524000000001s 2.4211250931219084A 1.536s 2.4211250931219084A 1.5360000000010001s 2.4177028072851825A 1.548s 2.4177028072851825A 1.5480000000010001s 2.417108366316681A 1.56s 2.417108366316681A 1.5600000000010001s 2.431572519905709A 1.572s 2.431572519905709A 1.5720000000010002s 1.887713377501598A 1.584s 1.887713377501598A 1.5840000000010002s 2.1388285668737845A 1.596s 2.1388285668737845A 1.5960000000010002s 2.1444286601242664A 1.608s 2.1444286601242664A 1.6080000000010002s 2.1390440927362224A 1.62s 2.1390440927362224A 1.6200000000010002s 2.140860403685441A 1.6320000000000001s 2.140860403685441A 1.6320000000010002s 2.1426884662524004A 1.6440000000000001s 2.1426884662524004A 1.6440000000010002s 2.1365286500107037A 1.6560000000000001s 2.1365286500107037A 1.6560000000010002s 2.135722143046915A 1.668s 2.135722143046915A 1.668000000001s 2.1342295086350873A 1.68s 2.1342295086350873A 1.680000000001s 2.1335873453610357A 1.692s 2.1335873453610357A 1.692000000001s 1.9842310246410877A 1.704s 1.9842310246410877A 1.704000000001s 1.8984897302764A 1.716s 1.8984897302764A 1.716000000001s 1.9298941689307816A 1.728s 1.9298941689307816A 1.728000000001s 1.879117277908712A 1.74s 1.879117277908712A 1.740000000001s 1.8981871708592155A 1.752s 1.8981871708592155A 1.752000000001s 1.9193740252838993A 1.764s 1.9193740252838993A 1.764000000001s 1.895835415641731A 1.776s 1.895835415641731A 1.7760000000010001s 1.8928296262266893A 1.788s 1.8928296262266893A 1.7880000000010001s 1.9212838719519942A 1.8s 1.9212838719519942A 1.8000000000010001s 1.8961352906792281A 1.812s 1.8961352906792281A 1.8120000000010001s 1.8927100221984052A 1.824s 1.8927100221984052A 1.8240000000010002s 0.8577740389972105A 1.836s 0.8577740389972105A 1.8360000000010002s 0.5567257486179532A 1.848s 0.5567257486179532A 1.8480000000010002s 1.5113468215127417A 1.86s 1.5113468215127417A 1.8600000000010002s 2.4195759674308865A 1.872s 2.4195759674308865A 1.8720000000010002s 2.4120373344760973A)
R_0_7_8_1 Node0_7_8 Node0_7_9 9.887809523809526
R_0_7_8_2 Node0_7_8 Node0_8_8 13.020765027322412
R_0_7_8_3 Node0_7_8 Node1_7_8 2.595018540202968
C_0_7_8 Node0_7_8 GND 0.0009924144753599992
I_0_7_9 GND Node0_7_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.01922005571030635A 0.024s 0.01922005571030635A 0.024000000001s 0.01922005571030635A 0.036000000000000004s 0.01922005571030635A 0.036000000001s 0.01922005571030635A 0.048s 0.01922005571030635A 0.048000000001s 0.01922005571030635A 0.06s 0.01922005571030635A 0.060000000000999996s 0.01922005571030635A 0.07200000000000001s 0.01922005571030635A 0.07200000000100001s 0.01922005571030635A 0.084s 0.01922005571030635A 0.08400000000100001s 0.01922005571030635A 0.096s 0.01922005571030635A 0.09600000000100001s 0.01922005571030635A 0.108s 0.01922005571030635A 0.108000000001s 0.01922005571030635A 0.12s 0.01922005571030635A 0.120000000001s 0.01922005571030635A 0.132s 0.01922005571030635A 0.132000000001s 0.01922005571030635A 0.14400000000000002s 0.01922005571030635A 0.14400000000100002s 0.01922005571030635A 0.156s 0.01922005571030635A 0.156000000001s 0.01922005571030635A 0.168s 0.01922005571030635A 0.16800000000100002s 0.01922005571030635A 0.18s 0.01922005571030635A 0.180000000001s 0.01922005571030635A 0.192s 0.01922005571030635A 0.192000000001s 0.01922005571030635A 0.20400000000000001s 0.01922005571030635A 0.20400000000100002s 0.01922005571030635A 0.216s 0.01922005571030635A 0.216000000001s 0.01922005571030635A 0.228s 0.01922005571030635A 0.228000000001s 0.01922005571030635A 0.24s 0.01922005571030635A 0.240000000001s 0.01922005571030635A 0.252s 0.01922005571030635A 0.252000000001s 0.01922005571030635A 0.264s 0.01922005571030635A 0.264000000001s 0.01922005571030635A 0.276s 0.01922005571030635A 0.276000000001s 0.01922005571030635A 0.28800000000000003s 0.01922005571030635A 0.288000000001s 0.01922005571030635A 0.3s 0.01922005571030635A 0.30000000000099997s 0.01922005571030635A 0.312s 0.01922005571030635A 0.312000000001s 0.01922005571030635A 0.324s 0.01922005571030635A 0.324000000001s 0.01922005571030635A 0.336s 0.01922005571030635A 0.336000000001s 0.01922005571030635A 0.34800000000000003s 0.01922005571030635A 0.348000000001s 0.01922005571030635A 0.36s 0.01922005571030635A 0.36000000000099996s 0.01922005571030635A 0.372s 0.01922005571030635A 0.372000000001s 0.01922005571030635A 0.384s 0.01922005571030635A 0.384000000001s 0.01922005571030635A 0.396s 0.01922005571030635A 0.396000000001s 0.01922005571030635A 0.40800000000000003s 0.01922005571030635A 0.408000000001s 0.01922005571030635A 0.42s 0.01922005571030635A 0.42000000000099996s 0.01922005571030635A 0.432s 0.01922005571030635A 0.432000000001s 0.01922005571030635A 0.444s 0.01922005571030635A 0.444000000001s 0.01922005571030635A 0.456s 0.01922005571030635A 0.456000000001s 0.01922005571030635A 0.468s 0.01922005571030635A 0.468000000001s 0.01922005571030635A 0.48s 0.01922005571030635A 0.48000000000099996s 0.01922005571030635A 0.492s 0.01922005571030635A 0.49200000000099997s 0.01922005571030635A 0.504s 0.01922005571030635A 0.504000000001s 0.01922005571030635A 0.516s 0.01922005571030635A 0.516000000001s 0.01922005571030635A 0.528s 0.01922005571030635A 0.528000000001s 0.01922005571030635A 0.54s 0.01922005571030635A 0.540000000001s 0.01922005571030635A 0.552s 0.01922005571030635A 0.552000000001s 0.01922005571030635A 0.5640000000000001s 0.01922005571030635A 0.564000000001s 0.01922005571030635A 0.5760000000000001s 0.01922005571030635A 0.576000000001s 0.01922005571030635A 0.588s 0.01922005571030635A 0.588000000001s 0.01922005571030635A 0.6s 0.01922005571030635A 0.600000000001s 0.01922005571030635A 0.612s 0.01922005571030635A 0.612000000001s 0.01922005571030635A 0.624s 0.01922005571030635A 0.624000000001s 0.01922005571030635A 0.636s 0.01922005571030635A 0.636000000001s 0.01922005571030635A 0.648s 0.01922005571030635A 0.648000000001s 0.01922005571030635A 0.66s 0.01922005571030635A 0.660000000001s 0.01922005571030635A 0.672s 0.01922005571030635A 0.672000000001s 0.01922005571030635A 0.684s 0.01922005571030635A 0.684000000001s 0.01922005571030635A 0.6960000000000001s 0.01922005571030635A 0.696000000001s 0.01922005571030635A 0.708s 0.01922005571030635A 0.7080000000009999s 0.01922005571030635A 0.72s 0.01922005571030635A 0.720000000001s 0.01922005571030635A 0.732s 0.01922005571030635A 0.732000000001s 0.01922005571030635A 0.744s 0.01922005571030635A 0.744000000001s 0.01922005571030635A 0.756s 0.01922005571030635A 0.756000000001s 0.01922005571030635A 0.768s 0.01922005571030635A 0.768000000001s 0.01922005571030635A 0.78s 0.01922005571030635A 0.780000000001s 0.01922005571030635A 0.792s 0.01922005571030635A 0.792000000001s 0.01922005571030635A 0.804s 0.01922005571030635A 0.804000000001s 0.01922005571030635A 0.8160000000000001s 0.01922005571030635A 0.816000000001s 0.01922005571030635A 0.8280000000000001s 0.01922005571030635A 0.828000000001s 0.01922005571030635A 0.84s 0.01922005571030635A 0.840000000001s 0.01922005571030635A 0.852s 0.01922005571030635A 0.852000000001s 0.01922005571030635A 0.864s 0.01922005571030635A 0.864000000001s 0.01922005571030635A 0.876s 0.01922005571030635A 0.876000000001s 0.01922005571030635A 0.888s 0.01922005571030635A 0.888000000001s 0.01922005571030635A 0.9s 0.01922005571030635A 0.900000000001s 0.01922005571030635A 0.912s 0.01922005571030635A 0.912000000001s 0.01922005571030635A 0.924s 0.01922005571030635A 0.924000000001s 0.01922005571030635A 0.936s 0.01922005571030635A 0.936000000001s 0.01922005571030635A 0.9480000000000001s 0.01922005571030635A 0.948000000001s 0.01922005571030635A 0.96s 0.01922005571030635A 0.9600000000009999s 0.01922005571030635A 0.972s 0.01922005571030635A 0.972000000001s 0.01922005571030635A 0.984s 0.01922005571030635A 0.984000000001s 0.01922005571030635A 0.996s 0.01922005571030635A 0.996000000001s 0.01922005571030635A 1.008s 0.01922005571030635A 1.008000000001s 0.01922005571030635A 1.02s 0.01922005571030635A 1.020000000001s 0.01922005571030635A 1.032s 0.01922005571030635A 1.0320000000010001s 0.01922005571030635A 1.044s 0.01922005571030635A 1.0440000000010001s 0.01922005571030635A 1.056s 0.01922005571030635A 1.0560000000010001s 0.01922005571030635A 1.068s 0.01922005571030635A 1.0680000000010001s 0.01922005571030635A 1.08s 0.01922005571030635A 1.0800000000010002s 0.01922005571030635A 1.092s 0.01922005571030635A 1.0920000000010002s 0.01922005571030635A 1.104s 0.01922005571030635A 1.1040000000010002s 0.01922005571030635A 1.116s 0.01922005571030635A 1.1160000000010002s 0.01922005571030635A 1.1280000000000001s 0.01922005571030635A 1.1280000000010002s 0.01922005571030635A 1.1400000000000001s 0.01922005571030635A 1.1400000000010002s 0.01922005571030635A 1.1520000000000001s 0.01922005571030635A 1.1520000000010002s 0.01922005571030635A 1.164s 0.01922005571030635A 1.164000000001s 0.01922005571030635A 1.176s 0.01922005571030635A 1.176000000001s 0.01922005571030635A 1.188s 0.01922005571030635A 1.188000000001s 0.01922005571030635A 1.2s 0.01922005571030635A 1.200000000001s 0.01922005571030635A 1.212s 0.01922005571030635A 1.212000000001s 0.01922005571030635A 1.224s 0.01922005571030635A 1.224000000001s 0.01922005571030635A 1.236s 0.01922005571030635A 1.236000000001s 0.01922005571030635A 1.248s 0.01922005571030635A 1.248000000001s 0.01922005571030635A 1.26s 0.01922005571030635A 1.260000000001s 0.01922005571030635A 1.272s 0.01922005571030635A 1.272000000001s 0.01922005571030635A 1.284s 0.01922005571030635A 1.2840000000010001s 0.01922005571030635A 1.296s 0.01922005571030635A 1.2960000000010001s 0.01922005571030635A 1.308s 0.01922005571030635A 1.3080000000010001s 0.01922005571030635A 1.32s 0.01922005571030635A 1.3200000000010002s 0.01922005571030635A 1.332s 0.01922005571030635A 1.3320000000010002s 0.01922005571030635A 1.344s 0.01922005571030635A 1.3440000000010002s 0.01922005571030635A 1.356s 0.01922005571030635A 1.3560000000010002s 0.01922005571030635A 1.368s 0.01922005571030635A 1.3680000000010002s 0.01922005571030635A 1.3800000000000001s 0.01922005571030635A 1.3800000000010002s 0.01922005571030635A 1.3920000000000001s 0.01922005571030635A 1.3920000000010002s 0.01922005571030635A 1.4040000000000001s 0.01922005571030635A 1.4040000000010002s 0.01922005571030635A 1.416s 0.01922005571030635A 1.416000000001s 0.01922005571030635A 1.428s 0.01922005571030635A 1.428000000001s 0.01922005571030635A 1.44s 0.01922005571030635A 1.440000000001s 0.01922005571030635A 1.452s 0.01922005571030635A 1.452000000001s 0.01922005571030635A 1.464s 0.01922005571030635A 1.464000000001s 0.01922005571030635A 1.476s 0.01922005571030635A 1.476000000001s 0.01922005571030635A 1.488s 0.01922005571030635A 1.488000000001s 0.01922005571030635A 1.5s 0.01922005571030635A 1.500000000001s 0.01922005571030635A 1.512s 0.01922005571030635A 1.512000000001s 0.01922005571030635A 1.524s 0.01922005571030635A 1.524000000001s 0.01922005571030635A 1.536s 0.01922005571030635A 1.5360000000010001s 0.01922005571030635A 1.548s 0.01922005571030635A 1.5480000000010001s 0.01922005571030635A 1.56s 0.01922005571030635A 1.5600000000010001s 0.01922005571030635A 1.572s 0.01922005571030635A 1.5720000000010002s 0.01922005571030635A 1.584s 0.01922005571030635A 1.5840000000010002s 0.01922005571030635A 1.596s 0.01922005571030635A 1.5960000000010002s 0.01922005571030635A 1.608s 0.01922005571030635A 1.6080000000010002s 0.01922005571030635A 1.62s 0.01922005571030635A 1.6200000000010002s 0.01922005571030635A 1.6320000000000001s 0.01922005571030635A 1.6320000000010002s 0.01922005571030635A 1.6440000000000001s 0.01922005571030635A 1.6440000000010002s 0.01922005571030635A 1.6560000000000001s 0.01922005571030635A 1.6560000000010002s 0.01922005571030635A 1.668s 0.01922005571030635A 1.668000000001s 0.01922005571030635A 1.68s 0.01922005571030635A 1.680000000001s 0.01922005571030635A 1.692s 0.01922005571030635A 1.692000000001s 0.01922005571030635A 1.704s 0.01922005571030635A 1.704000000001s 0.01922005571030635A 1.716s 0.01922005571030635A 1.716000000001s 0.01922005571030635A 1.728s 0.01922005571030635A 1.728000000001s 0.01922005571030635A 1.74s 0.01922005571030635A 1.740000000001s 0.01922005571030635A 1.752s 0.01922005571030635A 1.752000000001s 0.01922005571030635A 1.764s 0.01922005571030635A 1.764000000001s 0.01922005571030635A 1.776s 0.01922005571030635A 1.7760000000010001s 0.01922005571030635A 1.788s 0.01922005571030635A 1.7880000000010001s 0.01922005571030635A 1.8s 0.01922005571030635A 1.8000000000010001s 0.01922005571030635A 1.812s 0.01922005571030635A 1.8120000000010001s 0.01922005571030635A 1.824s 0.01922005571030635A 1.8240000000010002s 0.01922005571030635A 1.836s 0.01922005571030635A 1.8360000000010002s 0.01922005571030635A 1.848s 0.01922005571030635A 1.8480000000010002s 0.01922005571030635A 1.86s 0.01922005571030635A 1.8600000000010002s 0.01922005571030635A 1.872s 0.01922005571030635A 1.8720000000010002s 0.01922005571030635A)
R_0_7_9_2 Node0_7_9 Node0_8_9 13.020765027322406
R_0_7_9_3 Node0_7_9 Node1_7_9 2.5950185402029655
C_0_7_9 Node0_7_9 GND 0.0009924144753600003
I_0_8_0 GND Node0_8_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_0_1 Node0_8_0 Node0_8_1 9.887809523809523
R_0_8_0_2 Node0_8_0 Node0_9_0 13.020765027322406
R_0_8_0_3 Node0_8_0 Node1_8_0 2.595018540202966
C_0_8_0 Node0_8_0 GND 0.0009924144753600001
I_0_8_1 GND Node0_8_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_1_1 Node0_8_1 Node0_8_2 9.887809523809523
R_0_8_1_2 Node0_8_1 Node0_9_1 13.020765027322406
R_0_8_1_3 Node0_8_1 Node1_8_1 2.595018540202966
C_0_8_1 Node0_8_1 GND 0.0009924144753600001
I_0_8_2 GND Node0_8_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_2_1 Node0_8_2 Node0_8_3 9.887809523809523
R_0_8_2_2 Node0_8_2 Node0_9_2 13.020765027322406
R_0_8_2_3 Node0_8_2 Node1_8_2 2.595018540202966
C_0_8_2 Node0_8_2 GND 0.0009924144753600001
I_0_8_3 GND Node0_8_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_3_1 Node0_8_3 Node0_8_4 9.887809523809523
R_0_8_3_2 Node0_8_3 Node0_9_3 13.020765027322406
R_0_8_3_3 Node0_8_3 Node1_8_3 2.595018540202966
C_0_8_3 Node0_8_3 GND 0.0009924144753600001
I_0_8_4 GND Node0_8_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_4_1 Node0_8_4 Node0_8_5 9.887809523809523
R_0_8_4_2 Node0_8_4 Node0_9_4 13.020765027322406
R_0_8_4_3 Node0_8_4 Node1_8_4 2.595018540202966
C_0_8_4 Node0_8_4 GND 0.0009924144753600001
I_0_8_5 GND Node0_8_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_5_1 Node0_8_5 Node0_8_6 9.887809523809523
R_0_8_5_2 Node0_8_5 Node0_9_5 13.020765027322406
R_0_8_5_3 Node0_8_5 Node1_8_5 2.595018540202966
C_0_8_5 Node0_8_5 GND 0.0009924144753600001
I_0_8_6 GND Node0_8_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_6_1 Node0_8_6 Node0_8_7 9.887809523809523
R_0_8_6_2 Node0_8_6 Node0_9_6 13.020765027322406
R_0_8_6_3 Node0_8_6 Node1_8_6 2.595018540202966
C_0_8_6 Node0_8_6 GND 0.0009924144753600001
I_0_8_7 GND Node0_8_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_7_1 Node0_8_7 Node0_8_8 9.887809523809523
R_0_8_7_2 Node0_8_7 Node0_9_7 13.020765027322406
R_0_8_7_3 Node0_8_7 Node1_8_7 2.595018540202966
C_0_8_7 Node0_8_7 GND 0.0009924144753600001
I_0_8_8 GND Node0_8_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_8_1 Node0_8_8 Node0_8_9 9.887809523809523
R_0_8_8_2 Node0_8_8 Node0_9_8 13.020765027322406
R_0_8_8_3 Node0_8_8 Node1_8_8 2.595018540202966
C_0_8_8 Node0_8_8 GND 0.0009924144753600001
I_0_8_9 GND Node0_8_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_8_9_2 Node0_8_9 Node0_9_9 13.020765027322406
R_0_8_9_3 Node0_8_9 Node1_8_9 2.595018540202966
C_0_8_9 Node0_8_9 GND 0.0009924144753600001
I_0_9_0 GND Node0_9_0 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_0_1 Node0_9_0 Node0_9_1 9.887809523809523
R_0_9_0_3 Node0_9_0 Node1_9_0 2.595018540202966
C_0_9_0 Node0_9_0 GND 0.0009924144753600001
I_0_9_1 GND Node0_9_1 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_1_1 Node0_9_1 Node0_9_2 9.887809523809523
R_0_9_1_3 Node0_9_1 Node1_9_1 2.595018540202966
C_0_9_1 Node0_9_1 GND 0.0009924144753600001
I_0_9_2 GND Node0_9_2 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_2_1 Node0_9_2 Node0_9_3 9.887809523809523
R_0_9_2_3 Node0_9_2 Node1_9_2 2.595018540202966
C_0_9_2 Node0_9_2 GND 0.0009924144753600001
I_0_9_3 GND Node0_9_3 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_3_1 Node0_9_3 Node0_9_4 9.887809523809523
R_0_9_3_3 Node0_9_3 Node1_9_3 2.595018540202966
C_0_9_3 Node0_9_3 GND 0.0009924144753600001
I_0_9_4 GND Node0_9_4 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_4_1 Node0_9_4 Node0_9_5 9.887809523809523
R_0_9_4_3 Node0_9_4 Node1_9_4 2.595018540202966
C_0_9_4 Node0_9_4 GND 0.0009924144753600001
I_0_9_5 GND Node0_9_5 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_5_1 Node0_9_5 Node0_9_6 9.887809523809523
R_0_9_5_3 Node0_9_5 Node1_9_5 2.595018540202966
C_0_9_5 Node0_9_5 GND 0.0009924144753600001
I_0_9_6 GND Node0_9_6 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_6_1 Node0_9_6 Node0_9_7 9.887809523809523
R_0_9_6_3 Node0_9_6 Node1_9_6 2.595018540202966
C_0_9_6 Node0_9_6 GND 0.0009924144753600001
I_0_9_7 GND Node0_9_7 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_7_1 Node0_9_7 Node0_9_8 9.887809523809523
R_0_9_7_3 Node0_9_7 Node1_9_7 2.595018540202966
C_0_9_7 Node0_9_7 GND 0.0009924144753600001
I_0_9_8 GND Node0_9_8 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_8_1 Node0_9_8 Node0_9_9 9.887809523809523
R_0_9_8_3 Node0_9_8 Node1_9_8 2.595018540202966
C_0_9_8 Node0_9_8 GND 0.0009924144753600001
I_0_9_9 GND Node0_9_9 PWL(0s 0A 0.012s 0A 0.012000000001s 0.14038997214484683A 0.024s 0.14038997214484683A 0.024000000001s 0.14038997214484683A 0.036000000000000004s 0.14038997214484683A 0.036000000001s 0.14038997214484683A 0.048s 0.14038997214484683A 0.048000000001s 0.14038997214484683A 0.06s 0.14038997214484683A 0.060000000000999996s 0.14038997214484683A 0.07200000000000001s 0.14038997214484683A 0.07200000000100001s 0.14038997214484683A 0.084s 0.14038997214484683A 0.08400000000100001s 0.14038997214484683A 0.096s 0.14038997214484683A 0.09600000000100001s 0.14038997214484683A 0.108s 0.14038997214484683A 0.108000000001s 0.14038997214484683A 0.12s 0.14038997214484683A 0.120000000001s 0.14038997214484683A 0.132s 0.14038997214484683A 0.132000000001s 0.14038997214484683A 0.14400000000000002s 0.14038997214484683A 0.14400000000100002s 0.14038997214484683A 0.156s 0.14038997214484683A 0.156000000001s 0.14038997214484683A 0.168s 0.14038997214484683A 0.16800000000100002s 0.14038997214484683A 0.18s 0.14038997214484683A 0.180000000001s 0.14038997214484683A 0.192s 0.14038997214484683A 0.192000000001s 0.14038997214484683A 0.20400000000000001s 0.14038997214484683A 0.20400000000100002s 0.14038997214484683A 0.216s 0.14038997214484683A 0.216000000001s 0.14038997214484683A 0.228s 0.14038997214484683A 0.228000000001s 0.14038997214484683A 0.24s 0.14038997214484683A 0.240000000001s 0.14038997214484683A 0.252s 0.14038997214484683A 0.252000000001s 0.14038997214484683A 0.264s 0.14038997214484683A 0.264000000001s 0.14038997214484683A 0.276s 0.14038997214484683A 0.276000000001s 0.14038997214484683A 0.28800000000000003s 0.14038997214484683A 0.288000000001s 0.14038997214484683A 0.3s 0.14038997214484683A 0.30000000000099997s 0.14038997214484683A 0.312s 0.14038997214484683A 0.312000000001s 0.14038997214484683A 0.324s 0.14038997214484683A 0.324000000001s 0.14038997214484683A 0.336s 0.14038997214484683A 0.336000000001s 0.14038997214484683A 0.34800000000000003s 0.14038997214484683A 0.348000000001s 0.14038997214484683A 0.36s 0.14038997214484683A 0.36000000000099996s 0.14038997214484683A 0.372s 0.14038997214484683A 0.372000000001s 0.14038997214484683A 0.384s 0.14038997214484683A 0.384000000001s 0.14038997214484683A 0.396s 0.14038997214484683A 0.396000000001s 0.14038997214484683A 0.40800000000000003s 0.14038997214484683A 0.408000000001s 0.14038997214484683A 0.42s 0.14038997214484683A 0.42000000000099996s 0.14038997214484683A 0.432s 0.14038997214484683A 0.432000000001s 0.14038997214484683A 0.444s 0.14038997214484683A 0.444000000001s 0.14038997214484683A 0.456s 0.14038997214484683A 0.456000000001s 0.14038997214484683A 0.468s 0.14038997214484683A 0.468000000001s 0.14038997214484683A 0.48s 0.14038997214484683A 0.48000000000099996s 0.14038997214484683A 0.492s 0.14038997214484683A 0.49200000000099997s 0.14038997214484683A 0.504s 0.14038997214484683A 0.504000000001s 0.14038997214484683A 0.516s 0.14038997214484683A 0.516000000001s 0.14038997214484683A 0.528s 0.14038997214484683A 0.528000000001s 0.14038997214484683A 0.54s 0.14038997214484683A 0.540000000001s 0.14038997214484683A 0.552s 0.14038997214484683A 0.552000000001s 0.14038997214484683A 0.5640000000000001s 0.14038997214484683A 0.564000000001s 0.14038997214484683A 0.5760000000000001s 0.14038997214484683A 0.576000000001s 0.14038997214484683A 0.588s 0.14038997214484683A 0.588000000001s 0.14038997214484683A 0.6s 0.14038997214484683A 0.600000000001s 0.14038997214484683A 0.612s 0.14038997214484683A 0.612000000001s 0.14038997214484683A 0.624s 0.14038997214484683A 0.624000000001s 0.14038997214484683A 0.636s 0.14038997214484683A 0.636000000001s 0.14038997214484683A 0.648s 0.14038997214484683A 0.648000000001s 0.14038997214484683A 0.66s 0.14038997214484683A 0.660000000001s 0.14038997214484683A 0.672s 0.14038997214484683A 0.672000000001s 0.14038997214484683A 0.684s 0.14038997214484683A 0.684000000001s 0.14038997214484683A 0.6960000000000001s 0.14038997214484683A 0.696000000001s 0.14038997214484683A 0.708s 0.14038997214484683A 0.7080000000009999s 0.14038997214484683A 0.72s 0.14038997214484683A 0.720000000001s 0.14038997214484683A 0.732s 0.14038997214484683A 0.732000000001s 0.14038997214484683A 0.744s 0.14038997214484683A 0.744000000001s 0.14038997214484683A 0.756s 0.14038997214484683A 0.756000000001s 0.14038997214484683A 0.768s 0.14038997214484683A 0.768000000001s 0.14038997214484683A 0.78s 0.14038997214484683A 0.780000000001s 0.14038997214484683A 0.792s 0.14038997214484683A 0.792000000001s 0.14038997214484683A 0.804s 0.14038997214484683A 0.804000000001s 0.14038997214484683A 0.8160000000000001s 0.14038997214484683A 0.816000000001s 0.14038997214484683A 0.8280000000000001s 0.14038997214484683A 0.828000000001s 0.14038997214484683A 0.84s 0.14038997214484683A 0.840000000001s 0.14038997214484683A 0.852s 0.14038997214484683A 0.852000000001s 0.14038997214484683A 0.864s 0.14038997214484683A 0.864000000001s 0.14038997214484683A 0.876s 0.14038997214484683A 0.876000000001s 0.14038997214484683A 0.888s 0.14038997214484683A 0.888000000001s 0.14038997214484683A 0.9s 0.14038997214484683A 0.900000000001s 0.14038997214484683A 0.912s 0.14038997214484683A 0.912000000001s 0.14038997214484683A 0.924s 0.14038997214484683A 0.924000000001s 0.14038997214484683A 0.936s 0.14038997214484683A 0.936000000001s 0.14038997214484683A 0.9480000000000001s 0.14038997214484683A 0.948000000001s 0.14038997214484683A 0.96s 0.14038997214484683A 0.9600000000009999s 0.14038997214484683A 0.972s 0.14038997214484683A 0.972000000001s 0.14038997214484683A 0.984s 0.14038997214484683A 0.984000000001s 0.14038997214484683A 0.996s 0.14038997214484683A 0.996000000001s 0.14038997214484683A 1.008s 0.14038997214484683A 1.008000000001s 0.14038997214484683A 1.02s 0.14038997214484683A 1.020000000001s 0.14038997214484683A 1.032s 0.14038997214484683A 1.0320000000010001s 0.14038997214484683A 1.044s 0.14038997214484683A 1.0440000000010001s 0.14038997214484683A 1.056s 0.14038997214484683A 1.0560000000010001s 0.14038997214484683A 1.068s 0.14038997214484683A 1.0680000000010001s 0.14038997214484683A 1.08s 0.14038997214484683A 1.0800000000010002s 0.14038997214484683A 1.092s 0.14038997214484683A 1.0920000000010002s 0.14038997214484683A 1.104s 0.14038997214484683A 1.1040000000010002s 0.14038997214484683A 1.116s 0.14038997214484683A 1.1160000000010002s 0.14038997214484683A 1.1280000000000001s 0.14038997214484683A 1.1280000000010002s 0.14038997214484683A 1.1400000000000001s 0.14038997214484683A 1.1400000000010002s 0.14038997214484683A 1.1520000000000001s 0.14038997214484683A 1.1520000000010002s 0.14038997214484683A 1.164s 0.14038997214484683A 1.164000000001s 0.14038997214484683A 1.176s 0.14038997214484683A 1.176000000001s 0.14038997214484683A 1.188s 0.14038997214484683A 1.188000000001s 0.14038997214484683A 1.2s 0.14038997214484683A 1.200000000001s 0.14038997214484683A 1.212s 0.14038997214484683A 1.212000000001s 0.14038997214484683A 1.224s 0.14038997214484683A 1.224000000001s 0.14038997214484683A 1.236s 0.14038997214484683A 1.236000000001s 0.14038997214484683A 1.248s 0.14038997214484683A 1.248000000001s 0.14038997214484683A 1.26s 0.14038997214484683A 1.260000000001s 0.14038997214484683A 1.272s 0.14038997214484683A 1.272000000001s 0.14038997214484683A 1.284s 0.14038997214484683A 1.2840000000010001s 0.14038997214484683A 1.296s 0.14038997214484683A 1.2960000000010001s 0.14038997214484683A 1.308s 0.14038997214484683A 1.3080000000010001s 0.14038997214484683A 1.32s 0.14038997214484683A 1.3200000000010002s 0.14038997214484683A 1.332s 0.14038997214484683A 1.3320000000010002s 0.14038997214484683A 1.344s 0.14038997214484683A 1.3440000000010002s 0.14038997214484683A 1.356s 0.14038997214484683A 1.3560000000010002s 0.14038997214484683A 1.368s 0.14038997214484683A 1.3680000000010002s 0.14038997214484683A 1.3800000000000001s 0.14038997214484683A 1.3800000000010002s 0.14038997214484683A 1.3920000000000001s 0.14038997214484683A 1.3920000000010002s 0.14038997214484683A 1.4040000000000001s 0.14038997214484683A 1.4040000000010002s 0.14038997214484683A 1.416s 0.14038997214484683A 1.416000000001s 0.14038997214484683A 1.428s 0.14038997214484683A 1.428000000001s 0.14038997214484683A 1.44s 0.14038997214484683A 1.440000000001s 0.14038997214484683A 1.452s 0.14038997214484683A 1.452000000001s 0.14038997214484683A 1.464s 0.14038997214484683A 1.464000000001s 0.14038997214484683A 1.476s 0.14038997214484683A 1.476000000001s 0.14038997214484683A 1.488s 0.14038997214484683A 1.488000000001s 0.14038997214484683A 1.5s 0.14038997214484683A 1.500000000001s 0.14038997214484683A 1.512s 0.14038997214484683A 1.512000000001s 0.14038997214484683A 1.524s 0.14038997214484683A 1.524000000001s 0.14038997214484683A 1.536s 0.14038997214484683A 1.5360000000010001s 0.14038997214484683A 1.548s 0.14038997214484683A 1.5480000000010001s 0.14038997214484683A 1.56s 0.14038997214484683A 1.5600000000010001s 0.14038997214484683A 1.572s 0.14038997214484683A 1.5720000000010002s 0.14038997214484683A 1.584s 0.14038997214484683A 1.5840000000010002s 0.14038997214484683A 1.596s 0.14038997214484683A 1.5960000000010002s 0.14038997214484683A 1.608s 0.14038997214484683A 1.6080000000010002s 0.14038997214484683A 1.62s 0.14038997214484683A 1.6200000000010002s 0.14038997214484683A 1.6320000000000001s 0.14038997214484683A 1.6320000000010002s 0.14038997214484683A 1.6440000000000001s 0.14038997214484683A 1.6440000000010002s 0.14038997214484683A 1.6560000000000001s 0.14038997214484683A 1.6560000000010002s 0.14038997214484683A 1.668s 0.14038997214484683A 1.668000000001s 0.14038997214484683A 1.68s 0.14038997214484683A 1.680000000001s 0.14038997214484683A 1.692s 0.14038997214484683A 1.692000000001s 0.14038997214484683A 1.704s 0.14038997214484683A 1.704000000001s 0.14038997214484683A 1.716s 0.14038997214484683A 1.716000000001s 0.14038997214484683A 1.728s 0.14038997214484683A 1.728000000001s 0.14038997214484683A 1.74s 0.14038997214484683A 1.740000000001s 0.14038997214484683A 1.752s 0.14038997214484683A 1.752000000001s 0.14038997214484683A 1.764s 0.14038997214484683A 1.764000000001s 0.14038997214484683A 1.776s 0.14038997214484683A 1.7760000000010001s 0.14038997214484683A 1.788s 0.14038997214484683A 1.7880000000010001s 0.14038997214484683A 1.8s 0.14038997214484683A 1.8000000000010001s 0.14038997214484683A 1.812s 0.14038997214484683A 1.8120000000010001s 0.14038997214484683A 1.824s 0.14038997214484683A 1.8240000000010002s 0.14038997214484683A 1.836s 0.14038997214484683A 1.8360000000010002s 0.14038997214484683A 1.848s 0.14038997214484683A 1.8480000000010002s 0.14038997214484683A 1.86s 0.14038997214484683A 1.8600000000010002s 0.14038997214484683A 1.872s 0.14038997214484683A 1.8720000000010002s 0.14038997214484683A)
R_0_9_9_3 Node0_9_9 Node1_9_9 2.595018540202966
C_0_9_9 Node0_9_9 GND 0.0009924144753600001
R_1_0_0_1 Node1_0_0 Node1_0_1 5.81242857142857
R_1_0_0_2 Node1_0_0 Node1_1_0 7.654098360655739
R_1_0_0_3 Node1_0_0 GND 4.06583398386677
C_1_0_0 Node1_0_0 GND 8.116416000000002e-16
R_1_0_1_1 Node1_0_1 Node1_0_2 5.81242857142857
R_1_0_1_2 Node1_0_1 Node1_1_1 7.654098360655739
R_1_0_1_3 Node1_0_1 GND 4.06583398386677
C_1_0_1 Node1_0_1 GND 8.116416000000002e-16
R_1_0_2_1 Node1_0_2 Node1_0_3 5.81242857142857
R_1_0_2_2 Node1_0_2 Node1_1_2 7.654098360655739
R_1_0_2_3 Node1_0_2 GND 4.06583398386677
C_1_0_2 Node1_0_2 GND 8.116416000000002e-16
R_1_0_3_1 Node1_0_3 Node1_0_4 5.81242857142857
R_1_0_3_2 Node1_0_3 Node1_1_3 7.654098360655739
R_1_0_3_3 Node1_0_3 GND 4.06583398386677
C_1_0_3 Node1_0_3 GND 8.116416000000002e-16
R_1_0_4_1 Node1_0_4 Node1_0_5 5.81242857142857
R_1_0_4_2 Node1_0_4 Node1_1_4 7.654098360655739
R_1_0_4_3 Node1_0_4 GND 4.06583398386677
C_1_0_4 Node1_0_4 GND 8.116416000000002e-16
R_1_0_5_1 Node1_0_5 Node1_0_6 5.81242857142857
R_1_0_5_2 Node1_0_5 Node1_1_5 7.654098360655739
R_1_0_5_3 Node1_0_5 GND 4.06583398386677
C_1_0_5 Node1_0_5 GND 8.116416000000002e-16
R_1_0_6_1 Node1_0_6 Node1_0_7 5.81242857142857
R_1_0_6_2 Node1_0_6 Node1_1_6 7.654098360655739
R_1_0_6_3 Node1_0_6 GND 4.06583398386677
C_1_0_6 Node1_0_6 GND 8.116416000000002e-16
R_1_0_7_1 Node1_0_7 Node1_0_8 5.81242857142857
R_1_0_7_2 Node1_0_7 Node1_1_7 7.654098360655739
R_1_0_7_3 Node1_0_7 GND 4.06583398386677
C_1_0_7 Node1_0_7 GND 8.116416000000002e-16
R_1_0_8_1 Node1_0_8 Node1_0_9 5.81242857142857
R_1_0_8_2 Node1_0_8 Node1_1_8 7.654098360655739
R_1_0_8_3 Node1_0_8 GND 4.06583398386677
C_1_0_8 Node1_0_8 GND 8.116416000000002e-16
R_1_0_9_2 Node1_0_9 Node1_1_9 7.654098360655739
R_1_0_9_3 Node1_0_9 GND 4.06583398386677
C_1_0_9 Node1_0_9 GND 8.116416000000002e-16
R_1_1_0_1 Node1_1_0 Node1_1_1 5.81242857142857
R_1_1_0_2 Node1_1_0 Node1_2_0 7.654098360655739
R_1_1_0_3 Node1_1_0 GND 4.06583398386677
C_1_1_0 Node1_1_0 GND 8.116416000000002e-16
R_1_1_1_1 Node1_1_1 Node1_1_2 5.81242857142857
R_1_1_1_2 Node1_1_1 Node1_2_1 7.654098360655739
R_1_1_1_3 Node1_1_1 GND 4.06583398386677
C_1_1_1 Node1_1_1 GND 8.116416000000002e-16
R_1_1_2_1 Node1_1_2 Node1_1_3 5.81242857142857
R_1_1_2_2 Node1_1_2 Node1_2_2 7.654098360655739
R_1_1_2_3 Node1_1_2 GND 4.06583398386677
C_1_1_2 Node1_1_2 GND 8.116416000000002e-16
R_1_1_3_1 Node1_1_3 Node1_1_4 5.81242857142857
R_1_1_3_2 Node1_1_3 Node1_2_3 7.654098360655739
R_1_1_3_3 Node1_1_3 GND 4.06583398386677
C_1_1_3 Node1_1_3 GND 8.116416000000002e-16
R_1_1_4_1 Node1_1_4 Node1_1_5 5.81242857142857
R_1_1_4_2 Node1_1_4 Node1_2_4 7.654098360655739
R_1_1_4_3 Node1_1_4 GND 4.06583398386677
C_1_1_4 Node1_1_4 GND 8.116416000000002e-16
R_1_1_5_1 Node1_1_5 Node1_1_6 5.81242857142857
R_1_1_5_2 Node1_1_5 Node1_2_5 7.654098360655739
R_1_1_5_3 Node1_1_5 GND 4.06583398386677
C_1_1_5 Node1_1_5 GND 8.116416000000002e-16
R_1_1_6_1 Node1_1_6 Node1_1_7 5.81242857142857
R_1_1_6_2 Node1_1_6 Node1_2_6 7.654098360655739
R_1_1_6_3 Node1_1_6 GND 4.06583398386677
C_1_1_6 Node1_1_6 GND 8.116416000000002e-16
R_1_1_7_1 Node1_1_7 Node1_1_8 5.81242857142857
R_1_1_7_2 Node1_1_7 Node1_2_7 7.654098360655739
R_1_1_7_3 Node1_1_7 GND 4.06583398386677
C_1_1_7 Node1_1_7 GND 8.116416000000002e-16
R_1_1_8_1 Node1_1_8 Node1_1_9 5.81242857142857
R_1_1_8_2 Node1_1_8 Node1_2_8 7.654098360655739
R_1_1_8_3 Node1_1_8 GND 4.06583398386677
C_1_1_8 Node1_1_8 GND 8.116416000000002e-16
R_1_1_9_2 Node1_1_9 Node1_2_9 7.654098360655739
R_1_1_9_3 Node1_1_9 GND 4.06583398386677
C_1_1_9 Node1_1_9 GND 8.116416000000002e-16
R_1_2_0_1 Node1_2_0 Node1_2_1 5.81242857142857
R_1_2_0_2 Node1_2_0 Node1_3_0 7.654098360655739
R_1_2_0_3 Node1_2_0 GND 4.06583398386677
C_1_2_0 Node1_2_0 GND 8.116416000000002e-16
R_1_2_1_1 Node1_2_1 Node1_2_2 5.81242857142857
R_1_2_1_2 Node1_2_1 Node1_3_1 7.654098360655739
R_1_2_1_3 Node1_2_1 GND 4.06583398386677
C_1_2_1 Node1_2_1 GND 8.116416000000002e-16
R_1_2_2_1 Node1_2_2 Node1_2_3 5.81242857142857
R_1_2_2_2 Node1_2_2 Node1_3_2 7.654098360655739
R_1_2_2_3 Node1_2_2 GND 4.06583398386677
C_1_2_2 Node1_2_2 GND 8.116416000000002e-16
R_1_2_3_1 Node1_2_3 Node1_2_4 5.81242857142857
R_1_2_3_2 Node1_2_3 Node1_3_3 7.654098360655739
R_1_2_3_3 Node1_2_3 GND 4.06583398386677
C_1_2_3 Node1_2_3 GND 8.116416000000002e-16
R_1_2_4_1 Node1_2_4 Node1_2_5 5.81242857142857
R_1_2_4_2 Node1_2_4 Node1_3_4 7.654098360655739
R_1_2_4_3 Node1_2_4 GND 4.06583398386677
C_1_2_4 Node1_2_4 GND 8.116416000000002e-16
R_1_2_5_1 Node1_2_5 Node1_2_6 5.81242857142857
R_1_2_5_2 Node1_2_5 Node1_3_5 7.654098360655739
R_1_2_5_3 Node1_2_5 GND 4.06583398386677
C_1_2_5 Node1_2_5 GND 8.116416000000002e-16
R_1_2_6_1 Node1_2_6 Node1_2_7 5.81242857142857
R_1_2_6_2 Node1_2_6 Node1_3_6 7.654098360655739
R_1_2_6_3 Node1_2_6 GND 4.06583398386677
C_1_2_6 Node1_2_6 GND 8.116416000000002e-16
R_1_2_7_1 Node1_2_7 Node1_2_8 5.81242857142857
R_1_2_7_2 Node1_2_7 Node1_3_7 7.654098360655739
R_1_2_7_3 Node1_2_7 GND 4.06583398386677
C_1_2_7 Node1_2_7 GND 8.116416000000002e-16
R_1_2_8_1 Node1_2_8 Node1_2_9 5.81242857142857
R_1_2_8_2 Node1_2_8 Node1_3_8 7.654098360655739
R_1_2_8_3 Node1_2_8 GND 4.06583398386677
C_1_2_8 Node1_2_8 GND 8.116416000000002e-16
R_1_2_9_2 Node1_2_9 Node1_3_9 7.654098360655739
R_1_2_9_3 Node1_2_9 GND 4.06583398386677
C_1_2_9 Node1_2_9 GND 8.116416000000002e-16
R_1_3_0_1 Node1_3_0 Node1_3_1 5.81242857142857
R_1_3_0_2 Node1_3_0 Node1_4_0 7.654098360655739
R_1_3_0_3 Node1_3_0 GND 4.06583398386677
C_1_3_0 Node1_3_0 GND 8.116416000000002e-16
R_1_3_1_1 Node1_3_1 Node1_3_2 5.81242857142857
R_1_3_1_2 Node1_3_1 Node1_4_1 7.654098360655739
R_1_3_1_3 Node1_3_1 GND 4.06583398386677
C_1_3_1 Node1_3_1 GND 8.116416000000002e-16
R_1_3_2_1 Node1_3_2 Node1_3_3 5.81242857142857
R_1_3_2_2 Node1_3_2 Node1_4_2 7.654098360655739
R_1_3_2_3 Node1_3_2 GND 4.06583398386677
C_1_3_2 Node1_3_2 GND 8.116416000000002e-16
R_1_3_3_1 Node1_3_3 Node1_3_4 5.81242857142857
R_1_3_3_2 Node1_3_3 Node1_4_3 7.654098360655739
R_1_3_3_3 Node1_3_3 GND 4.06583398386677
C_1_3_3 Node1_3_3 GND 8.116416000000002e-16
R_1_3_4_1 Node1_3_4 Node1_3_5 5.81242857142857
R_1_3_4_2 Node1_3_4 Node1_4_4 7.654098360655739
R_1_3_4_3 Node1_3_4 GND 4.06583398386677
C_1_3_4 Node1_3_4 GND 8.116416000000002e-16
R_1_3_5_1 Node1_3_5 Node1_3_6 5.81242857142857
R_1_3_5_2 Node1_3_5 Node1_4_5 7.654098360655739
R_1_3_5_3 Node1_3_5 GND 4.06583398386677
C_1_3_5 Node1_3_5 GND 8.116416000000002e-16
R_1_3_6_1 Node1_3_6 Node1_3_7 5.81242857142857
R_1_3_6_2 Node1_3_6 Node1_4_6 7.654098360655739
R_1_3_6_3 Node1_3_6 GND 4.06583398386677
C_1_3_6 Node1_3_6 GND 8.116416000000002e-16
R_1_3_7_1 Node1_3_7 Node1_3_8 5.81242857142857
R_1_3_7_2 Node1_3_7 Node1_4_7 7.654098360655739
R_1_3_7_3 Node1_3_7 GND 4.06583398386677
C_1_3_7 Node1_3_7 GND 8.116416000000002e-16
R_1_3_8_1 Node1_3_8 Node1_3_9 5.81242857142857
R_1_3_8_2 Node1_3_8 Node1_4_8 7.654098360655739
R_1_3_8_3 Node1_3_8 GND 4.06583398386677
C_1_3_8 Node1_3_8 GND 8.116416000000002e-16
R_1_3_9_2 Node1_3_9 Node1_4_9 7.654098360655739
R_1_3_9_3 Node1_3_9 GND 4.06583398386677
C_1_3_9 Node1_3_9 GND 8.116416000000002e-16
R_1_4_0_1 Node1_4_0 Node1_4_1 5.81242857142857
R_1_4_0_2 Node1_4_0 Node1_5_0 7.654098360655739
R_1_4_0_3 Node1_4_0 GND 4.06583398386677
C_1_4_0 Node1_4_0 GND 8.116416000000002e-16
R_1_4_1_1 Node1_4_1 Node1_4_2 5.81242857142857
R_1_4_1_2 Node1_4_1 Node1_5_1 7.654098360655739
R_1_4_1_3 Node1_4_1 GND 4.06583398386677
C_1_4_1 Node1_4_1 GND 8.116416000000002e-16
R_1_4_2_1 Node1_4_2 Node1_4_3 5.81242857142857
R_1_4_2_2 Node1_4_2 Node1_5_2 7.654098360655739
R_1_4_2_3 Node1_4_2 GND 4.06583398386677
C_1_4_2 Node1_4_2 GND 8.116416000000002e-16
R_1_4_3_1 Node1_4_3 Node1_4_4 5.81242857142857
R_1_4_3_2 Node1_4_3 Node1_5_3 7.654098360655739
R_1_4_3_3 Node1_4_3 GND 4.06583398386677
C_1_4_3 Node1_4_3 GND 8.116416000000002e-16
R_1_4_4_1 Node1_4_4 Node1_4_5 5.81242857142857
R_1_4_4_2 Node1_4_4 Node1_5_4 7.654098360655739
R_1_4_4_3 Node1_4_4 GND 4.06583398386677
C_1_4_4 Node1_4_4 GND 8.116416000000002e-16
R_1_4_5_1 Node1_4_5 Node1_4_6 5.81242857142857
R_1_4_5_2 Node1_4_5 Node1_5_5 7.654098360655739
R_1_4_5_3 Node1_4_5 GND 4.06583398386677
C_1_4_5 Node1_4_5 GND 8.116416000000002e-16
R_1_4_6_1 Node1_4_6 Node1_4_7 5.81242857142857
R_1_4_6_2 Node1_4_6 Node1_5_6 7.654098360655739
R_1_4_6_3 Node1_4_6 GND 4.06583398386677
C_1_4_6 Node1_4_6 GND 8.116416000000002e-16
R_1_4_7_1 Node1_4_7 Node1_4_8 5.81242857142857
R_1_4_7_2 Node1_4_7 Node1_5_7 7.654098360655739
R_1_4_7_3 Node1_4_7 GND 4.06583398386677
C_1_4_7 Node1_4_7 GND 8.116416000000002e-16
R_1_4_8_1 Node1_4_8 Node1_4_9 5.81242857142857
R_1_4_8_2 Node1_4_8 Node1_5_8 7.654098360655739
R_1_4_8_3 Node1_4_8 GND 4.06583398386677
C_1_4_8 Node1_4_8 GND 8.116416000000002e-16
R_1_4_9_2 Node1_4_9 Node1_5_9 7.654098360655739
R_1_4_9_3 Node1_4_9 GND 4.06583398386677
C_1_4_9 Node1_4_9 GND 8.116416000000002e-16
R_1_5_0_1 Node1_5_0 Node1_5_1 5.81242857142857
R_1_5_0_2 Node1_5_0 Node1_6_0 7.654098360655739
R_1_5_0_3 Node1_5_0 GND 4.06583398386677
C_1_5_0 Node1_5_0 GND 8.116416000000002e-16
R_1_5_1_1 Node1_5_1 Node1_5_2 5.81242857142857
R_1_5_1_2 Node1_5_1 Node1_6_1 7.654098360655739
R_1_5_1_3 Node1_5_1 GND 4.06583398386677
C_1_5_1 Node1_5_1 GND 8.116416000000002e-16
R_1_5_2_1 Node1_5_2 Node1_5_3 5.81242857142857
R_1_5_2_2 Node1_5_2 Node1_6_2 7.654098360655739
R_1_5_2_3 Node1_5_2 GND 4.06583398386677
C_1_5_2 Node1_5_2 GND 8.116416000000002e-16
R_1_5_3_1 Node1_5_3 Node1_5_4 5.81242857142857
R_1_5_3_2 Node1_5_3 Node1_6_3 7.654098360655739
R_1_5_3_3 Node1_5_3 GND 4.06583398386677
C_1_5_3 Node1_5_3 GND 8.116416000000002e-16
R_1_5_4_1 Node1_5_4 Node1_5_5 5.81242857142857
R_1_5_4_2 Node1_5_4 Node1_6_4 7.654098360655739
R_1_5_4_3 Node1_5_4 GND 4.06583398386677
C_1_5_4 Node1_5_4 GND 8.116416000000002e-16
R_1_5_5_1 Node1_5_5 Node1_5_6 5.81242857142857
R_1_5_5_2 Node1_5_5 Node1_6_5 7.654098360655739
R_1_5_5_3 Node1_5_5 GND 4.06583398386677
C_1_5_5 Node1_5_5 GND 8.116416000000002e-16
R_1_5_6_1 Node1_5_6 Node1_5_7 5.81242857142857
R_1_5_6_2 Node1_5_6 Node1_6_6 7.654098360655739
R_1_5_6_3 Node1_5_6 GND 4.06583398386677
C_1_5_6 Node1_5_6 GND 8.116416000000002e-16
R_1_5_7_1 Node1_5_7 Node1_5_8 5.81242857142857
R_1_5_7_2 Node1_5_7 Node1_6_7 7.654098360655739
R_1_5_7_3 Node1_5_7 GND 4.06583398386677
C_1_5_7 Node1_5_7 GND 8.116416000000002e-16
R_1_5_8_1 Node1_5_8 Node1_5_9 5.81242857142857
R_1_5_8_2 Node1_5_8 Node1_6_8 7.654098360655739
R_1_5_8_3 Node1_5_8 GND 4.06583398386677
C_1_5_8 Node1_5_8 GND 8.116416000000002e-16
R_1_5_9_2 Node1_5_9 Node1_6_9 7.654098360655739
R_1_5_9_3 Node1_5_9 GND 4.06583398386677
C_1_5_9 Node1_5_9 GND 8.116416000000002e-16
R_1_6_0_1 Node1_6_0 Node1_6_1 5.81242857142857
R_1_6_0_2 Node1_6_0 Node1_7_0 7.654098360655739
R_1_6_0_3 Node1_6_0 GND 4.06583398386677
C_1_6_0 Node1_6_0 GND 8.116416000000002e-16
R_1_6_1_1 Node1_6_1 Node1_6_2 5.81242857142857
R_1_6_1_2 Node1_6_1 Node1_7_1 7.654098360655739
R_1_6_1_3 Node1_6_1 GND 4.06583398386677
C_1_6_1 Node1_6_1 GND 8.116416000000002e-16
R_1_6_2_1 Node1_6_2 Node1_6_3 5.81242857142857
R_1_6_2_2 Node1_6_2 Node1_7_2 7.654098360655739
R_1_6_2_3 Node1_6_2 GND 4.06583398386677
C_1_6_2 Node1_6_2 GND 8.116416000000002e-16
R_1_6_3_1 Node1_6_3 Node1_6_4 5.81242857142857
R_1_6_3_2 Node1_6_3 Node1_7_3 7.654098360655739
R_1_6_3_3 Node1_6_3 GND 4.06583398386677
C_1_6_3 Node1_6_3 GND 8.116416000000002e-16
R_1_6_4_1 Node1_6_4 Node1_6_5 5.81242857142857
R_1_6_4_2 Node1_6_4 Node1_7_4 7.654098360655739
R_1_6_4_3 Node1_6_4 GND 4.06583398386677
C_1_6_4 Node1_6_4 GND 8.116416000000002e-16
R_1_6_5_1 Node1_6_5 Node1_6_6 5.81242857142857
R_1_6_5_2 Node1_6_5 Node1_7_5 7.654098360655739
R_1_6_5_3 Node1_6_5 GND 4.06583398386677
C_1_6_5 Node1_6_5 GND 8.116416000000002e-16
R_1_6_6_1 Node1_6_6 Node1_6_7 5.81242857142857
R_1_6_6_2 Node1_6_6 Node1_7_6 7.654098360655739
R_1_6_6_3 Node1_6_6 GND 4.06583398386677
C_1_6_6 Node1_6_6 GND 8.116416000000002e-16
R_1_6_7_1 Node1_6_7 Node1_6_8 5.81242857142857
R_1_6_7_2 Node1_6_7 Node1_7_7 7.654098360655739
R_1_6_7_3 Node1_6_7 GND 4.06583398386677
C_1_6_7 Node1_6_7 GND 8.116416000000002e-16
R_1_6_8_1 Node1_6_8 Node1_6_9 5.81242857142857
R_1_6_8_2 Node1_6_8 Node1_7_8 7.654098360655739
R_1_6_8_3 Node1_6_8 GND 4.06583398386677
C_1_6_8 Node1_6_8 GND 8.116416000000002e-16
R_1_6_9_2 Node1_6_9 Node1_7_9 7.654098360655739
R_1_6_9_3 Node1_6_9 GND 4.06583398386677
C_1_6_9 Node1_6_9 GND 8.116416000000002e-16
R_1_7_0_1 Node1_7_0 Node1_7_1 5.81242857142857
R_1_7_0_2 Node1_7_0 Node1_8_0 7.654098360655739
R_1_7_0_3 Node1_7_0 GND 4.06583398386677
C_1_7_0 Node1_7_0 GND 8.116416000000002e-16
R_1_7_1_1 Node1_7_1 Node1_7_2 5.81242857142857
R_1_7_1_2 Node1_7_1 Node1_8_1 7.654098360655739
R_1_7_1_3 Node1_7_1 GND 4.06583398386677
C_1_7_1 Node1_7_1 GND 8.116416000000002e-16
R_1_7_2_1 Node1_7_2 Node1_7_3 5.81242857142857
R_1_7_2_2 Node1_7_2 Node1_8_2 7.654098360655739
R_1_7_2_3 Node1_7_2 GND 4.06583398386677
C_1_7_2 Node1_7_2 GND 8.116416000000002e-16
R_1_7_3_1 Node1_7_3 Node1_7_4 5.81242857142857
R_1_7_3_2 Node1_7_3 Node1_8_3 7.654098360655739
R_1_7_3_3 Node1_7_3 GND 4.06583398386677
C_1_7_3 Node1_7_3 GND 8.116416000000002e-16
R_1_7_4_1 Node1_7_4 Node1_7_5 5.81242857142857
R_1_7_4_2 Node1_7_4 Node1_8_4 7.654098360655739
R_1_7_4_3 Node1_7_4 GND 4.06583398386677
C_1_7_4 Node1_7_4 GND 8.116416000000002e-16
R_1_7_5_1 Node1_7_5 Node1_7_6 5.81242857142857
R_1_7_5_2 Node1_7_5 Node1_8_5 7.654098360655739
R_1_7_5_3 Node1_7_5 GND 4.06583398386677
C_1_7_5 Node1_7_5 GND 8.116416000000002e-16
R_1_7_6_1 Node1_7_6 Node1_7_7 5.81242857142857
R_1_7_6_2 Node1_7_6 Node1_8_6 7.654098360655739
R_1_7_6_3 Node1_7_6 GND 4.06583398386677
C_1_7_6 Node1_7_6 GND 8.116416000000002e-16
R_1_7_7_1 Node1_7_7 Node1_7_8 5.81242857142857
R_1_7_7_2 Node1_7_7 Node1_8_7 7.654098360655739
R_1_7_7_3 Node1_7_7 GND 4.06583398386677
C_1_7_7 Node1_7_7 GND 8.116416000000002e-16
R_1_7_8_1 Node1_7_8 Node1_7_9 5.81242857142857
R_1_7_8_2 Node1_7_8 Node1_8_8 7.654098360655739
R_1_7_8_3 Node1_7_8 GND 4.06583398386677
C_1_7_8 Node1_7_8 GND 8.116416000000002e-16
R_1_7_9_2 Node1_7_9 Node1_8_9 7.654098360655739
R_1_7_9_3 Node1_7_9 GND 4.06583398386677
C_1_7_9 Node1_7_9 GND 8.116416000000002e-16
R_1_8_0_1 Node1_8_0 Node1_8_1 5.81242857142857
R_1_8_0_2 Node1_8_0 Node1_9_0 7.654098360655739
R_1_8_0_3 Node1_8_0 GND 4.06583398386677
C_1_8_0 Node1_8_0 GND 8.116416000000002e-16
R_1_8_1_1 Node1_8_1 Node1_8_2 5.81242857142857
R_1_8_1_2 Node1_8_1 Node1_9_1 7.654098360655739
R_1_8_1_3 Node1_8_1 GND 4.06583398386677
C_1_8_1 Node1_8_1 GND 8.116416000000002e-16
R_1_8_2_1 Node1_8_2 Node1_8_3 5.81242857142857
R_1_8_2_2 Node1_8_2 Node1_9_2 7.654098360655739
R_1_8_2_3 Node1_8_2 GND 4.06583398386677
C_1_8_2 Node1_8_2 GND 8.116416000000002e-16
R_1_8_3_1 Node1_8_3 Node1_8_4 5.81242857142857
R_1_8_3_2 Node1_8_3 Node1_9_3 7.654098360655739
R_1_8_3_3 Node1_8_3 GND 4.06583398386677
C_1_8_3 Node1_8_3 GND 8.116416000000002e-16
R_1_8_4_1 Node1_8_4 Node1_8_5 5.81242857142857
R_1_8_4_2 Node1_8_4 Node1_9_4 7.654098360655739
R_1_8_4_3 Node1_8_4 GND 4.06583398386677
C_1_8_4 Node1_8_4 GND 8.116416000000002e-16
R_1_8_5_1 Node1_8_5 Node1_8_6 5.81242857142857
R_1_8_5_2 Node1_8_5 Node1_9_5 7.654098360655739
R_1_8_5_3 Node1_8_5 GND 4.06583398386677
C_1_8_5 Node1_8_5 GND 8.116416000000002e-16
R_1_8_6_1 Node1_8_6 Node1_8_7 5.81242857142857
R_1_8_6_2 Node1_8_6 Node1_9_6 7.654098360655739
R_1_8_6_3 Node1_8_6 GND 4.06583398386677
C_1_8_6 Node1_8_6 GND 8.116416000000002e-16
R_1_8_7_1 Node1_8_7 Node1_8_8 5.81242857142857
R_1_8_7_2 Node1_8_7 Node1_9_7 7.654098360655739
R_1_8_7_3 Node1_8_7 GND 4.06583398386677
C_1_8_7 Node1_8_7 GND 8.116416000000002e-16
R_1_8_8_1 Node1_8_8 Node1_8_9 5.81242857142857
R_1_8_8_2 Node1_8_8 Node1_9_8 7.654098360655739
R_1_8_8_3 Node1_8_8 GND 4.06583398386677
C_1_8_8 Node1_8_8 GND 8.116416000000002e-16
R_1_8_9_2 Node1_8_9 Node1_9_9 7.654098360655739
R_1_8_9_3 Node1_8_9 GND 4.06583398386677
C_1_8_9 Node1_8_9 GND 8.116416000000002e-16
R_1_9_0_1 Node1_9_0 Node1_9_1 5.81242857142857
R_1_9_0_3 Node1_9_0 GND 4.06583398386677
C_1_9_0 Node1_9_0 GND 8.116416000000002e-16
R_1_9_1_1 Node1_9_1 Node1_9_2 5.81242857142857
R_1_9_1_3 Node1_9_1 GND 4.06583398386677
C_1_9_1 Node1_9_1 GND 8.116416000000002e-16
R_1_9_2_1 Node1_9_2 Node1_9_3 5.81242857142857
R_1_9_2_3 Node1_9_2 GND 4.06583398386677
C_1_9_2 Node1_9_2 GND 8.116416000000002e-16
R_1_9_3_1 Node1_9_3 Node1_9_4 5.81242857142857
R_1_9_3_3 Node1_9_3 GND 4.06583398386677
C_1_9_3 Node1_9_3 GND 8.116416000000002e-16
R_1_9_4_1 Node1_9_4 Node1_9_5 5.81242857142857
R_1_9_4_3 Node1_9_4 GND 4.06583398386677
C_1_9_4 Node1_9_4 GND 8.116416000000002e-16
R_1_9_5_1 Node1_9_5 Node1_9_6 5.81242857142857
R_1_9_5_3 Node1_9_5 GND 4.06583398386677
C_1_9_5 Node1_9_5 GND 8.116416000000002e-16
R_1_9_6_1 Node1_9_6 Node1_9_7 5.81242857142857
R_1_9_6_3 Node1_9_6 GND 4.06583398386677
C_1_9_6 Node1_9_6 GND 8.116416000000002e-16
R_1_9_7_1 Node1_9_7 Node1_9_8 5.81242857142857
R_1_9_7_3 Node1_9_7 GND 4.06583398386677
C_1_9_7 Node1_9_7 GND 8.116416000000002e-16
R_1_9_8_1 Node1_9_8 Node1_9_9 5.81242857142857
R_1_9_8_3 Node1_9_8 GND 4.06583398386677
C_1_9_8 Node1_9_8 GND 8.116416000000002e-16
R_1_9_9_3 Node1_9_9 GND 4.06583398386677
C_1_9_9 Node1_9_9 GND 8.116416000000002e-16
.TRAN 0.012s 3.408s
.OPTIONS LINSOL TYPE=KLU TR_PARTITION=0
.OPTIONS DIST STRATEGY=2
.OPTIONS TIMEINT METHOD=TRAP
.OPTIONS OUTPUT INITIAL_INTERVAL=0.012s 3.408s
.PRINT TRAN FORMAT=CSV PRECISION=4 V(Node0_0_0) V(Node0_0_1) V(Node0_0_2) V(Node0_0_3) V(Node0_0_4) V(Node0_0_5) V(Node0_0_6) V(Node0_0_7) V(Node0_0_8) V(Node0_0_9) V(Node0_1_0) V(Node0_1_1) V(Node0_1_2) V(Node0_1_3) V(Node0_1_4) V(Node0_1_5) V(Node0_1_6) V(Node0_1_7) V(Node0_1_8) V(Node0_1_9) V(Node0_2_0) V(Node0_2_1) V(Node0_2_2) V(Node0_2_3) V(Node0_2_4) V(Node0_2_5) V(Node0_2_6) V(Node0_2_7) V(Node0_2_8) V(Node0_2_9) V(Node0_3_0) V(Node0_3_1) V(Node0_3_2) V(Node0_3_3) V(Node0_3_4) V(Node0_3_5) V(Node0_3_6) V(Node0_3_7) V(Node0_3_8) V(Node0_3_9) V(Node0_4_0) V(Node0_4_1) V(Node0_4_2) V(Node0_4_3) V(Node0_4_4) V(Node0_4_5) V(Node0_4_6) V(Node0_4_7) V(Node0_4_8) V(Node0_4_9) V(Node0_5_0) V(Node0_5_1) V(Node0_5_2) V(Node0_5_3) V(Node0_5_4) V(Node0_5_5) V(Node0_5_6) V(Node0_5_7) V(Node0_5_8) V(Node0_5_9) V(Node0_6_0) V(Node0_6_1) V(Node0_6_2) V(Node0_6_3) V(Node0_6_4) V(Node0_6_5) V(Node0_6_6) V(Node0_6_7) V(Node0_6_8) V(Node0_6_9) V(Node0_7_0) V(Node0_7_1) V(Node0_7_2) V(Node0_7_3) V(Node0_7_4) V(Node0_7_5) V(Node0_7_6) V(Node0_7_7) V(Node0_7_8) V(Node0_7_9) V(Node0_8_0) V(Node0_8_1) V(Node0_8_2) V(Node0_8_3) V(Node0_8_4) V(Node0_8_5) V(Node0_8_6) V(Node0_8_7) V(Node0_8_8) V(Node0_8_9) V(Node0_9_0) V(Node0_9_1) V(Node0_9_2) V(Node0_9_3) V(Node0_9_4) V(Node0_9_5) V(Node0_9_6) V(Node0_9_7) V(Node0_9_8) V(Node0_9_9) V(Node1_0_0) V(Node1_0_1) V(Node1_0_2) V(Node1_0_3) V(Node1_0_4) V(Node1_0_5) V(Node1_0_6) V(Node1_0_7) V(Node1_0_8) V(Node1_0_9) V(Node1_1_0) V(Node1_1_1) V(Node1_1_2) V(Node1_1_3) V(Node1_1_4) V(Node1_1_5) V(Node1_1_6) V(Node1_1_7) V(Node1_1_8) V(Node1_1_9) V(Node1_2_0) V(Node1_2_1) V(Node1_2_2) V(Node1_2_3) V(Node1_2_4) V(Node1_2_5) V(Node1_2_6) V(Node1_2_7) V(Node1_2_8) V(Node1_2_9) V(Node1_3_0) V(Node1_3_1) V(Node1_3_2) V(Node1_3_3) V(Node1_3_4) V(Node1_3_5) V(Node1_3_6) V(Node1_3_7) V(Node1_3_8) V(Node1_3_9) V(Node1_4_0) V(Node1_4_1) V(Node1_4_2) V(Node1_4_3) V(Node1_4_4) V(Node1_4_5) V(Node1_4_6) V(Node1_4_7) V(Node1_4_8) V(Node1_4_9) V(Node1_5_0) V(Node1_5_1) V(Node1_5_2) V(Node1_5_3) V(Node1_5_4) V(Node1_5_5) V(Node1_5_6) V(Node1_5_7) V(Node1_5_8) V(Node1_5_9) V(Node1_6_0) V(Node1_6_1) V(Node1_6_2) V(Node1_6_3) V(Node1_6_4) V(Node1_6_5) V(Node1_6_6) V(Node1_6_7) V(Node1_6_8) V(Node1_6_9) V(Node1_7_0) V(Node1_7_1) V(Node1_7_2) V(Node1_7_3) V(Node1_7_4) V(Node1_7_5) V(Node1_7_6) V(Node1_7_7) V(Node1_7_8) V(Node1_7_9) V(Node1_8_0) V(Node1_8_1) V(Node1_8_2) V(Node1_8_3) V(Node1_8_4) V(Node1_8_5) V(Node1_8_6) V(Node1_8_7) V(Node1_8_8) V(Node1_8_9) V(Node1_9_0) V(Node1_9_1) V(Node1_9_2) V(Node1_9_3) V(Node1_9_4) V(Node1_9_5) V(Node1_9_6) V(Node1_9_7) V(Node1_9_8) V(Node1_9_9)
.SAVE TYPE=IC
.end
