.title spice solver
Vg GND 0 318.15
I_0_0_0 GND Node0_0_0 0.049999999999999996A
R_0_0_0_1 Node0_0_0 Node0_0_1 3.8499999999999996
R_0_0_0_2 Node0_0_0 Node0_1_0 1540.0000000000002
R_0_0_0_3 Node0_0_0 Node1_0_0 23.099999999999998
I_0_0_1 GND Node0_0_1 0.049999999999999996A
R_0_0_1_1 Node0_0_1 Node0_0_2 3.8499999999999996
R_0_0_1_2 Node0_0_1 Node0_1_1 1540.0000000000002
R_0_0_1_3 Node0_0_1 Node1_0_1 1662.4
I_0_0_2 GND Node0_0_2 0.049999999999999996A
R_0_0_2_1 Node0_0_2 Node0_0_3 3.8499999999999996
R_0_0_2_2 Node0_0_2 Node0_1_2 1540.0000000000002
R_0_0_2_3 Node0_0_2 Node1_0_2 23.099999999999994
I_0_0_3 GND Node0_0_3 0.049999999999999996A
R_0_0_3_1 Node0_0_3 Node0_0_4 3.85
R_0_0_3_2 Node0_0_3 Node0_1_3 1540.0000000000002
R_0_0_3_3 Node0_0_3 Node1_0_3 1662.4000000000012
I_0_0_4 GND Node0_0_4 0.04999999999999999A
R_0_0_4_2 Node0_0_4 Node0_1_4 1540.0000000000005
R_0_0_4_3 Node0_0_4 Node1_0_4 23.1
I_0_1_0 GND Node0_1_0 0.049999999999999996A
R_0_1_0_1 Node0_1_0 Node0_1_1 3.8499999999999996
R_0_1_0_2 Node0_1_0 Node0_2_0 1540.0000000000002
R_0_1_0_3 Node0_1_0 Node1_1_0 23.099999999999998
I_0_1_1 GND Node0_1_1 0.049999999999999996A
R_0_1_1_1 Node0_1_1 Node0_1_2 3.8499999999999996
R_0_1_1_2 Node0_1_1 Node0_2_1 1540.0000000000002
R_0_1_1_3 Node0_1_1 Node1_1_1 1662.4
I_0_1_2 GND Node0_1_2 0.049999999999999996A
R_0_1_2_1 Node0_1_2 Node0_1_3 3.8499999999999996
R_0_1_2_2 Node0_1_2 Node0_2_2 1540.0000000000002
R_0_1_2_3 Node0_1_2 Node1_1_2 23.099999999999994
I_0_1_3 GND Node0_1_3 0.049999999999999996A
R_0_1_3_1 Node0_1_3 Node0_1_4 3.85
R_0_1_3_2 Node0_1_3 Node0_2_3 1540.0000000000002
R_0_1_3_3 Node0_1_3 Node1_1_3 1662.4000000000012
I_0_1_4 GND Node0_1_4 0.04999999999999999A
R_0_1_4_2 Node0_1_4 Node0_2_4 1540.0000000000005
R_0_1_4_3 Node0_1_4 Node1_1_4 23.1
I_0_2_0 GND Node0_2_0 0.049999999999999996A
R_0_2_0_1 Node0_2_0 Node0_2_1 3.8499999999999996
R_0_2_0_2 Node0_2_0 Node0_3_0 1540.0000000000002
R_0_2_0_3 Node0_2_0 Node1_2_0 23.099999999999998
I_0_2_1 GND Node0_2_1 0.049999999999999996A
R_0_2_1_1 Node0_2_1 Node0_2_2 3.8499999999999996
R_0_2_1_2 Node0_2_1 Node0_3_1 1540.0000000000002
R_0_2_1_3 Node0_2_1 Node1_2_1 1662.4
I_0_2_2 GND Node0_2_2 0.049999999999999996A
R_0_2_2_1 Node0_2_2 Node0_2_3 3.8499999999999996
R_0_2_2_2 Node0_2_2 Node0_3_2 1540.0000000000002
R_0_2_2_3 Node0_2_2 Node1_2_2 23.099999999999994
I_0_2_3 GND Node0_2_3 0.049999999999999996A
R_0_2_3_1 Node0_2_3 Node0_2_4 3.85
R_0_2_3_2 Node0_2_3 Node0_3_3 1540.0000000000002
R_0_2_3_3 Node0_2_3 Node1_2_3 1662.4000000000012
I_0_2_4 GND Node0_2_4 0.04999999999999999A
R_0_2_4_2 Node0_2_4 Node0_3_4 1540.0000000000005
R_0_2_4_3 Node0_2_4 Node1_2_4 23.1
I_0_3_0 GND Node0_3_0 0.049999999999999996A
R_0_3_0_1 Node0_3_0 Node0_3_1 3.8499999999999996
R_0_3_0_2 Node0_3_0 Node0_4_0 1540.0000000000002
R_0_3_0_3 Node0_3_0 Node1_3_0 23.099999999999998
I_0_3_1 GND Node0_3_1 0.049999999999999996A
R_0_3_1_1 Node0_3_1 Node0_3_2 3.8499999999999996
R_0_3_1_2 Node0_3_1 Node0_4_1 1540.0000000000002
R_0_3_1_3 Node0_3_1 Node1_3_1 1662.4
I_0_3_2 GND Node0_3_2 0.049999999999999996A
R_0_3_2_1 Node0_3_2 Node0_3_3 3.8499999999999996
R_0_3_2_2 Node0_3_2 Node0_4_2 1540.0000000000002
R_0_3_2_3 Node0_3_2 Node1_3_2 23.099999999999994
I_0_3_3 GND Node0_3_3 0.049999999999999996A
R_0_3_3_1 Node0_3_3 Node0_3_4 3.85
R_0_3_3_2 Node0_3_3 Node0_4_3 1540.0000000000002
R_0_3_3_3 Node0_3_3 Node1_3_3 1662.4000000000012
I_0_3_4 GND Node0_3_4 0.04999999999999999A
R_0_3_4_2 Node0_3_4 Node0_4_4 1540.0000000000005
R_0_3_4_3 Node0_3_4 Node1_3_4 23.1
I_0_4_0 GND Node0_4_0 0.049999999999999996A
R_0_4_0_1 Node0_4_0 Node0_4_1 3.8499999999999996
R_0_4_0_3 Node0_4_0 Node1_4_0 23.099999999999998
I_0_4_1 GND Node0_4_1 0.049999999999999996A
R_0_4_1_1 Node0_4_1 Node0_4_2 3.8499999999999996
R_0_4_1_3 Node0_4_1 Node1_4_1 1662.4
I_0_4_2 GND Node0_4_2 0.049999999999999996A
R_0_4_2_1 Node0_4_2 Node0_4_3 3.8499999999999996
R_0_4_2_3 Node0_4_2 Node1_4_2 23.099999999999994
I_0_4_3 GND Node0_4_3 0.049999999999999996A
R_0_4_3_1 Node0_4_3 Node0_4_4 3.85
R_0_4_3_3 Node0_4_3 Node1_4_3 1662.4000000000012
I_0_4_4 GND Node0_4_4 0.04999999999999999A
R_0_4_4_3 Node0_4_4 Node1_4_4 23.1
R_1_0_0_1 Node1_0_0 Node1_0_1 413.675
R_1_0_0_2 Node1_0_0 Node1_1_0 1540.0000000000002
R_1_0_0_3 Node1_0_0 Node2_0_0 1000000007.6999998
R_1_0_1_1 Node1_0_1 Node1_0_2 413.675
R_1_0_1_2 Node1_0_1 Node1_1_1 329400.0
R_1_0_1_3 Node1_0_1 Node2_0_1 1000001646.9999998
R_1_0_2_1 Node1_0_2 Node1_0_3 413.6750000000003
R_1_0_2_2 Node1_0_2 Node1_1_2 1540.0
R_1_0_2_3 Node1_0_2 Node2_0_2 1000000007.6999998
R_1_0_3_1 Node1_0_3 Node1_0_4 413.6750000000003
R_1_0_3_2 Node1_0_3 Node1_1_3 329400.00000000023
R_1_0_3_3 Node1_0_3 Node2_0_3 1000001646.9999998
R_1_0_4_2 Node1_0_4 Node1_1_4 1540.0000000000005
R_1_0_4_3 Node1_0_4 Node2_0_4 1000000007.6999998
R_1_1_0_1 Node1_1_0 Node1_1_1 413.675
R_1_1_0_2 Node1_1_0 Node1_2_0 1540.0000000000002
R_1_1_0_3 Node1_1_0 Node2_1_0 1000000007.6999998
R_1_1_1_1 Node1_1_1 Node1_1_2 413.675
R_1_1_1_2 Node1_1_1 Node1_2_1 329400.0
R_1_1_1_3 Node1_1_1 Node2_1_1 1000001646.9999998
R_1_1_2_1 Node1_1_2 Node1_1_3 413.6750000000003
R_1_1_2_2 Node1_1_2 Node1_2_2 1540.0
R_1_1_2_3 Node1_1_2 Node2_1_2 1000000007.6999998
R_1_1_3_1 Node1_1_3 Node1_1_4 413.6750000000003
R_1_1_3_2 Node1_1_3 Node1_2_3 329400.00000000023
R_1_1_3_3 Node1_1_3 Node2_1_3 1000001646.9999998
R_1_1_4_2 Node1_1_4 Node1_2_4 1540.0000000000005
R_1_1_4_3 Node1_1_4 Node2_1_4 1000000007.6999998
R_1_2_0_1 Node1_2_0 Node1_2_1 413.675
R_1_2_0_2 Node1_2_0 Node1_3_0 1540.0000000000002
R_1_2_0_3 Node1_2_0 Node2_2_0 1000000007.6999998
R_1_2_1_1 Node1_2_1 Node1_2_2 413.675
R_1_2_1_2 Node1_2_1 Node1_3_1 329400.0
R_1_2_1_3 Node1_2_1 Node2_2_1 1000001646.9999998
R_1_2_2_1 Node1_2_2 Node1_2_3 413.6750000000003
R_1_2_2_2 Node1_2_2 Node1_3_2 1540.0
R_1_2_2_3 Node1_2_2 Node2_2_2 1000000007.6999998
R_1_2_3_1 Node1_2_3 Node1_2_4 413.6750000000003
R_1_2_3_2 Node1_2_3 Node1_3_3 329400.00000000023
R_1_2_3_3 Node1_2_3 Node2_2_3 1000001646.9999998
R_1_2_4_2 Node1_2_4 Node1_3_4 1540.0000000000005
R_1_2_4_3 Node1_2_4 Node2_2_4 1000000007.6999998
R_1_3_0_1 Node1_3_0 Node1_3_1 413.675
R_1_3_0_2 Node1_3_0 Node1_4_0 1540.0000000000002
R_1_3_0_3 Node1_3_0 Node2_3_0 1000000007.6999998
R_1_3_1_1 Node1_3_1 Node1_3_2 413.675
R_1_3_1_2 Node1_3_1 Node1_4_1 329400.0
R_1_3_1_3 Node1_3_1 Node2_3_1 1000001646.9999998
R_1_3_2_1 Node1_3_2 Node1_3_3 413.6750000000003
R_1_3_2_2 Node1_3_2 Node1_4_2 1540.0
R_1_3_2_3 Node1_3_2 Node2_3_2 1000000007.6999998
R_1_3_3_1 Node1_3_3 Node1_3_4 413.6750000000003
R_1_3_3_2 Node1_3_3 Node1_4_3 329400.00000000023
R_1_3_3_3 Node1_3_3 Node2_3_3 1000001646.9999998
R_1_3_4_2 Node1_3_4 Node1_4_4 1540.0000000000005
R_1_3_4_3 Node1_3_4 Node2_3_4 1000000007.6999998
R_1_4_0_1 Node1_4_0 Node1_4_1 413.675
R_1_4_0_3 Node1_4_0 Node2_4_0 1000000007.6999998
R_1_4_1_1 Node1_4_1 Node1_4_2 413.675
R_1_4_1_3 Node1_4_1 Node2_4_1 1000001646.9999998
R_1_4_2_1 Node1_4_2 Node1_4_3 413.6750000000003
R_1_4_2_3 Node1_4_2 Node2_4_2 1000000007.6999998
R_1_4_3_1 Node1_4_3 Node1_4_4 413.6750000000003
R_1_4_3_3 Node1_4_3 Node2_4_3 1000001646.9999998
R_1_4_4_3 Node1_4_4 Node2_4_4 1000000007.6999998
R_2_0_0_1 Node2_0_0 Node2_0_1 31.250000000000004
R_2_0_0_2 Node2_0_0 Node2_1_0 12500.0
R_2_0_0_3 Node2_0_0 GND 1999999999.9999995
R_2_0_1_1 Node2_0_1 Node2_0_2 31.250000000000004
R_2_0_1_2 Node2_0_1 Node2_1_1 12500.0
R_2_0_1_3 Node2_0_1 GND 1999999999.9999995
R_2_0_2_1 Node2_0_2 Node2_0_3 31.250000000000004
R_2_0_2_2 Node2_0_2 Node2_1_2 12500.0
R_2_0_2_3 Node2_0_2 GND 1999999999.9999995
R_2_0_3_1 Node2_0_3 Node2_0_4 31.250000000000004
R_2_0_3_2 Node2_0_3 Node2_1_3 12500.0
R_2_0_3_3 Node2_0_3 GND 1999999999.9999995
R_2_0_4_2 Node2_0_4 Node2_1_4 12500.0
R_2_0_4_3 Node2_0_4 GND 1999999999.9999995
R_2_1_0_1 Node2_1_0 Node2_1_1 31.250000000000004
R_2_1_0_2 Node2_1_0 Node2_2_0 12500.0
R_2_1_0_3 Node2_1_0 GND 1999999999.9999995
R_2_1_1_1 Node2_1_1 Node2_1_2 31.250000000000004
R_2_1_1_2 Node2_1_1 Node2_2_1 12500.0
R_2_1_1_3 Node2_1_1 GND 1999999999.9999995
R_2_1_2_1 Node2_1_2 Node2_1_3 31.250000000000004
R_2_1_2_2 Node2_1_2 Node2_2_2 12500.0
R_2_1_2_3 Node2_1_2 GND 1999999999.9999995
R_2_1_3_1 Node2_1_3 Node2_1_4 31.250000000000004
R_2_1_3_2 Node2_1_3 Node2_2_3 12500.0
R_2_1_3_3 Node2_1_3 GND 1999999999.9999995
R_2_1_4_2 Node2_1_4 Node2_2_4 12500.0
R_2_1_4_3 Node2_1_4 GND 1999999999.9999995
R_2_2_0_1 Node2_2_0 Node2_2_1 31.250000000000004
R_2_2_0_2 Node2_2_0 Node2_3_0 12500.0
R_2_2_0_3 Node2_2_0 GND 1999999999.9999995
R_2_2_1_1 Node2_2_1 Node2_2_2 31.250000000000004
R_2_2_1_2 Node2_2_1 Node2_3_1 12500.0
R_2_2_1_3 Node2_2_1 GND 1999999999.9999995
R_2_2_2_1 Node2_2_2 Node2_2_3 31.250000000000004
R_2_2_2_2 Node2_2_2 Node2_3_2 12500.0
R_2_2_2_3 Node2_2_2 GND 1999999999.9999995
R_2_2_3_1 Node2_2_3 Node2_2_4 31.250000000000004
R_2_2_3_2 Node2_2_3 Node2_3_3 12500.0
R_2_2_3_3 Node2_2_3 GND 1999999999.9999995
R_2_2_4_2 Node2_2_4 Node2_3_4 12500.0
R_2_2_4_3 Node2_2_4 GND 1999999999.9999995
R_2_3_0_1 Node2_3_0 Node2_3_1 31.250000000000004
R_2_3_0_2 Node2_3_0 Node2_4_0 12500.0
R_2_3_0_3 Node2_3_0 GND 1999999999.9999995
R_2_3_1_1 Node2_3_1 Node2_3_2 31.250000000000004
R_2_3_1_2 Node2_3_1 Node2_4_1 12500.0
R_2_3_1_3 Node2_3_1 GND 1999999999.9999995
R_2_3_2_1 Node2_3_2 Node2_3_3 31.250000000000004
R_2_3_2_2 Node2_3_2 Node2_4_2 12500.0
R_2_3_2_3 Node2_3_2 GND 1999999999.9999995
R_2_3_3_1 Node2_3_3 Node2_3_4 31.250000000000004
R_2_3_3_2 Node2_3_3 Node2_4_3 12500.0
R_2_3_3_3 Node2_3_3 GND 1999999999.9999995
R_2_3_4_2 Node2_3_4 Node2_4_4 12500.0
R_2_3_4_3 Node2_3_4 GND 1999999999.9999995
R_2_4_0_1 Node2_4_0 Node2_4_1 31.250000000000004
R_2_4_0_3 Node2_4_0 GND 1999999999.9999995
R_2_4_1_1 Node2_4_1 Node2_4_2 31.250000000000004
R_2_4_1_3 Node2_4_1 GND 1999999999.9999995
R_2_4_2_1 Node2_4_2 Node2_4_3 31.250000000000004
R_2_4_2_3 Node2_4_2 GND 1999999999.9999995
R_2_4_3_1 Node2_4_3 Node2_4_4 31.250000000000004
R_2_4_3_3 Node2_4_3 GND 1999999999.9999995
R_2_4_4_3 Node2_4_4 GND 1999999999.9999995
.OP
.OPTIONS LINSOL TR_PARTITION = 0
.PRINT DC FORMAT=CSV PRECISION=4 V(Node0_0_0) V(Node0_0_1) V(Node0_0_2) V(Node0_0_3) V(Node0_0_4) V(Node0_1_0) V(Node0_1_1) V(Node0_1_2) V(Node0_1_3) V(Node0_1_4) V(Node0_2_0) V(Node0_2_1) V(Node0_2_2) V(Node0_2_3) V(Node0_2_4) V(Node0_3_0) V(Node0_3_1) V(Node0_3_2) V(Node0_3_3) V(Node0_3_4) V(Node0_4_0) V(Node0_4_1) V(Node0_4_2) V(Node0_4_3) V(Node0_4_4) V(Node1_0_0) V(Node1_0_1) V(Node1_0_2) V(Node1_0_3) V(Node1_0_4) V(Node1_1_0) V(Node1_1_1) V(Node1_1_2) V(Node1_1_3) V(Node1_1_4) V(Node1_2_0) V(Node1_2_1) V(Node1_2_2) V(Node1_2_3) V(Node1_2_4) V(Node1_3_0) V(Node1_3_1) V(Node1_3_2) V(Node1_3_3) V(Node1_3_4) V(Node1_4_0) V(Node1_4_1) V(Node1_4_2) V(Node1_4_3) V(Node1_4_4) V(Node2_0_0) V(Node2_0_1) V(Node2_0_2) V(Node2_0_3) V(Node2_0_4) V(Node2_1_0) V(Node2_1_1) V(Node2_1_2) V(Node2_1_3) V(Node2_1_4) V(Node2_2_0) V(Node2_2_1) V(Node2_2_2) V(Node2_2_3) V(Node2_2_4) V(Node2_3_0) V(Node2_3_1) V(Node2_3_2) V(Node2_3_3) V(Node2_3_4) V(Node2_4_0) V(Node2_4_1) V(Node2_4_2) V(Node2_4_3) V(Node2_4_4)
.SAVE TYPE=IC
.end
