.title spice transient solver
Vg GND 0 318.15
I_0_0_0 GND Node0_0_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_0_1 Node0_0_0 Node0_0_1 77.0
R_0_0_0_2 Node0_0_0 Node0_1_0 77.0
R_0_0_0_3 Node0_0_0 Node1_0_0 12.320000000000002
C_0_0_0 Node0_0_0 GND 3.609375e-06
I_0_0_1 GND Node0_0_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_1_1 Node0_0_1 Node0_0_2 77.0
R_0_0_1_2 Node0_0_1 Node0_1_1 77.0
R_0_0_1_3 Node0_0_1 Node1_0_1 12.320000000000002
C_0_0_1 Node0_0_1 GND 3.609375e-06
I_0_0_2 GND Node0_0_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_2_1 Node0_0_2 Node0_0_3 77.0
R_0_0_2_2 Node0_0_2 Node0_1_2 77.0
R_0_0_2_3 Node0_0_2 Node1_0_2 12.320000000000002
C_0_0_2 Node0_0_2 GND 3.609375e-06
I_0_0_3 GND Node0_0_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_3_1 Node0_0_3 Node0_0_4 77.0
R_0_0_3_2 Node0_0_3 Node0_1_3 77.0
R_0_0_3_3 Node0_0_3 Node1_0_3 12.320000000000002
C_0_0_3 Node0_0_3 GND 3.609375e-06
I_0_0_4 GND Node0_0_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_4_1 Node0_0_4 Node0_0_5 77.0
R_0_0_4_2 Node0_0_4 Node0_1_4 77.0
R_0_0_4_3 Node0_0_4 Node1_0_4 12.320000000000002
C_0_0_4 Node0_0_4 GND 3.609375e-06
I_0_0_5 GND Node0_0_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_5_1 Node0_0_5 Node0_0_6 77.0
R_0_0_5_2 Node0_0_5 Node0_1_5 77.0
R_0_0_5_3 Node0_0_5 Node1_0_5 12.320000000000002
C_0_0_5 Node0_0_5 GND 3.609375e-06
I_0_0_6 GND Node0_0_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_6_1 Node0_0_6 Node0_0_7 77.0
R_0_0_6_2 Node0_0_6 Node0_1_6 77.0
R_0_0_6_3 Node0_0_6 Node1_0_6 12.320000000000002
C_0_0_6 Node0_0_6 GND 3.609375e-06
I_0_0_7 GND Node0_0_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_7_1 Node0_0_7 Node0_0_8 77.0
R_0_0_7_2 Node0_0_7 Node0_1_7 77.0
R_0_0_7_3 Node0_0_7 Node1_0_7 12.320000000000002
C_0_0_7 Node0_0_7 GND 3.609375e-06
I_0_0_8 GND Node0_0_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_8_1 Node0_0_8 Node0_0_9 77.0
R_0_0_8_2 Node0_0_8 Node0_1_8 77.0
R_0_0_8_3 Node0_0_8 Node1_0_8 12.320000000000002
C_0_0_8 Node0_0_8 GND 3.609375e-06
I_0_0_9 GND Node0_0_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_9_1 Node0_0_9 Node0_0_10 77.0
R_0_0_9_2 Node0_0_9 Node0_1_9 77.0
R_0_0_9_3 Node0_0_9 Node1_0_9 12.320000000000002
C_0_0_9 Node0_0_9 GND 3.609375e-06
I_0_0_10 GND Node0_0_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_10_1 Node0_0_10 Node0_0_11 77.0
R_0_0_10_2 Node0_0_10 Node0_1_10 77.0
R_0_0_10_3 Node0_0_10 Node1_0_10 12.320000000000002
C_0_0_10 Node0_0_10 GND 3.609375e-06
I_0_0_11 GND Node0_0_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_11_1 Node0_0_11 Node0_0_12 77.0
R_0_0_11_2 Node0_0_11 Node0_1_11 77.0
R_0_0_11_3 Node0_0_11 Node1_0_11 12.320000000000002
C_0_0_11 Node0_0_11 GND 3.609375e-06
I_0_0_12 GND Node0_0_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_12_1 Node0_0_12 Node0_0_13 77.0
R_0_0_12_2 Node0_0_12 Node0_1_12 77.0
R_0_0_12_3 Node0_0_12 Node1_0_12 12.320000000000002
C_0_0_12 Node0_0_12 GND 3.609375e-06
I_0_0_13 GND Node0_0_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_13_1 Node0_0_13 Node0_0_14 77.0
R_0_0_13_2 Node0_0_13 Node0_1_13 77.0
R_0_0_13_3 Node0_0_13 Node1_0_13 12.320000000000002
C_0_0_13 Node0_0_13 GND 3.609375e-06
I_0_0_14 GND Node0_0_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_14_1 Node0_0_14 Node0_0_15 77.0
R_0_0_14_2 Node0_0_14 Node0_1_14 77.0
R_0_0_14_3 Node0_0_14 Node1_0_14 12.320000000000002
C_0_0_14 Node0_0_14 GND 3.609375e-06
I_0_0_15 GND Node0_0_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_15_1 Node0_0_15 Node0_0_16 77.0
R_0_0_15_2 Node0_0_15 Node0_1_15 77.0
R_0_0_15_3 Node0_0_15 Node1_0_15 12.320000000000002
C_0_0_15 Node0_0_15 GND 3.609375e-06
I_0_0_16 GND Node0_0_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_16_1 Node0_0_16 Node0_0_17 77.0
R_0_0_16_2 Node0_0_16 Node0_1_16 77.0
R_0_0_16_3 Node0_0_16 Node1_0_16 12.320000000000002
C_0_0_16 Node0_0_16 GND 3.609375e-06
I_0_0_17 GND Node0_0_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_17_1 Node0_0_17 Node0_0_18 77.0
R_0_0_17_2 Node0_0_17 Node0_1_17 77.0
R_0_0_17_3 Node0_0_17 Node1_0_17 12.320000000000002
C_0_0_17 Node0_0_17 GND 3.609375e-06
I_0_0_18 GND Node0_0_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_18_1 Node0_0_18 Node0_0_19 77.0
R_0_0_18_2 Node0_0_18 Node0_1_18 77.0
R_0_0_18_3 Node0_0_18 Node1_0_18 12.320000000000002
C_0_0_18 Node0_0_18 GND 3.609375e-06
I_0_0_19 GND Node0_0_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_19_1 Node0_0_19 Node0_0_20 77.0
R_0_0_19_2 Node0_0_19 Node0_1_19 77.0
R_0_0_19_3 Node0_0_19 Node1_0_19 12.320000000000002
C_0_0_19 Node0_0_19 GND 3.609375e-06
I_0_0_20 GND Node0_0_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_20_1 Node0_0_20 Node0_0_21 77.0
R_0_0_20_2 Node0_0_20 Node0_1_20 77.0
R_0_0_20_3 Node0_0_20 Node1_0_20 12.320000000000002
C_0_0_20 Node0_0_20 GND 3.609375e-06
I_0_0_21 GND Node0_0_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_21_1 Node0_0_21 Node0_0_22 77.0
R_0_0_21_2 Node0_0_21 Node0_1_21 77.0
R_0_0_21_3 Node0_0_21 Node1_0_21 12.320000000000002
C_0_0_21 Node0_0_21 GND 3.609375e-06
I_0_0_22 GND Node0_0_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_22_1 Node0_0_22 Node0_0_23 77.0
R_0_0_22_2 Node0_0_22 Node0_1_22 77.0
R_0_0_22_3 Node0_0_22 Node1_0_22 12.320000000000002
C_0_0_22 Node0_0_22 GND 3.609375e-06
I_0_0_23 GND Node0_0_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_23_1 Node0_0_23 Node0_0_24 77.0
R_0_0_23_2 Node0_0_23 Node0_1_23 77.0
R_0_0_23_3 Node0_0_23 Node1_0_23 12.320000000000002
C_0_0_23 Node0_0_23 GND 3.609375e-06
I_0_0_24 GND Node0_0_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_24_1 Node0_0_24 Node0_0_25 77.0
R_0_0_24_2 Node0_0_24 Node0_1_24 77.0
R_0_0_24_3 Node0_0_24 Node1_0_24 12.320000000000002
C_0_0_24 Node0_0_24 GND 3.609375e-06
I_0_0_25 GND Node0_0_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_25_1 Node0_0_25 Node0_0_26 77.0
R_0_0_25_2 Node0_0_25 Node0_1_25 77.0
R_0_0_25_3 Node0_0_25 Node1_0_25 12.320000000000002
C_0_0_25 Node0_0_25 GND 3.609375e-06
I_0_0_26 GND Node0_0_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_26_1 Node0_0_26 Node0_0_27 77.0
R_0_0_26_2 Node0_0_26 Node0_1_26 77.0
R_0_0_26_3 Node0_0_26 Node1_0_26 12.320000000000002
C_0_0_26 Node0_0_26 GND 3.609375e-06
I_0_0_27 GND Node0_0_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_27_1 Node0_0_27 Node0_0_28 77.0
R_0_0_27_2 Node0_0_27 Node0_1_27 77.0
R_0_0_27_3 Node0_0_27 Node1_0_27 12.320000000000002
C_0_0_27 Node0_0_27 GND 3.609375e-06
I_0_0_28 GND Node0_0_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_28_1 Node0_0_28 Node0_0_29 77.0
R_0_0_28_2 Node0_0_28 Node0_1_28 77.0
R_0_0_28_3 Node0_0_28 Node1_0_28 12.320000000000002
C_0_0_28 Node0_0_28 GND 3.609375e-06
I_0_0_29 GND Node0_0_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_29_1 Node0_0_29 Node0_0_30 77.0
R_0_0_29_2 Node0_0_29 Node0_1_29 77.0
R_0_0_29_3 Node0_0_29 Node1_0_29 12.320000000000002
C_0_0_29 Node0_0_29 GND 3.609375e-06
I_0_0_30 GND Node0_0_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_30_1 Node0_0_30 Node0_0_31 77.0
R_0_0_30_2 Node0_0_30 Node0_1_30 77.0
R_0_0_30_3 Node0_0_30 Node1_0_30 12.320000000000002
C_0_0_30 Node0_0_30 GND 3.609375e-06
I_0_0_31 GND Node0_0_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_31_1 Node0_0_31 Node0_0_32 77.0
R_0_0_31_2 Node0_0_31 Node0_1_31 77.0
R_0_0_31_3 Node0_0_31 Node1_0_31 12.320000000000002
C_0_0_31 Node0_0_31 GND 3.609375e-06
I_0_0_32 GND Node0_0_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_32_1 Node0_0_32 Node0_0_33 77.0
R_0_0_32_2 Node0_0_32 Node0_1_32 77.0
R_0_0_32_3 Node0_0_32 Node1_0_32 12.320000000000002
C_0_0_32 Node0_0_32 GND 3.609375e-06
I_0_0_33 GND Node0_0_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_33_1 Node0_0_33 Node0_0_34 77.0
R_0_0_33_2 Node0_0_33 Node0_1_33 77.0
R_0_0_33_3 Node0_0_33 Node1_0_33 12.320000000000002
C_0_0_33 Node0_0_33 GND 3.609375e-06
I_0_0_34 GND Node0_0_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_34_1 Node0_0_34 Node0_0_35 77.0
R_0_0_34_2 Node0_0_34 Node0_1_34 77.0
R_0_0_34_3 Node0_0_34 Node1_0_34 12.320000000000002
C_0_0_34 Node0_0_34 GND 3.609375e-06
I_0_0_35 GND Node0_0_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_35_1 Node0_0_35 Node0_0_36 77.0
R_0_0_35_2 Node0_0_35 Node0_1_35 77.0
R_0_0_35_3 Node0_0_35 Node1_0_35 12.320000000000002
C_0_0_35 Node0_0_35 GND 3.609375e-06
I_0_0_36 GND Node0_0_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_36_1 Node0_0_36 Node0_0_37 77.0
R_0_0_36_2 Node0_0_36 Node0_1_36 77.0
R_0_0_36_3 Node0_0_36 Node1_0_36 12.320000000000002
C_0_0_36 Node0_0_36 GND 3.609375e-06
I_0_0_37 GND Node0_0_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_37_1 Node0_0_37 Node0_0_38 77.0
R_0_0_37_2 Node0_0_37 Node0_1_37 77.0
R_0_0_37_3 Node0_0_37 Node1_0_37 12.320000000000002
C_0_0_37 Node0_0_37 GND 3.609375e-06
I_0_0_38 GND Node0_0_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_38_1 Node0_0_38 Node0_0_39 77.0
R_0_0_38_2 Node0_0_38 Node0_1_38 77.0
R_0_0_38_3 Node0_0_38 Node1_0_38 12.320000000000002
C_0_0_38 Node0_0_38 GND 3.609375e-06
I_0_0_39 GND Node0_0_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_0_39_2 Node0_0_39 Node0_1_39 77.0
R_0_0_39_3 Node0_0_39 Node1_0_39 12.320000000000002
C_0_0_39 Node0_0_39 GND 3.609375e-06
I_0_1_0 GND Node0_1_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_0_1 Node0_1_0 Node0_1_1 77.0
R_0_1_0_2 Node0_1_0 Node0_2_0 77.0
R_0_1_0_3 Node0_1_0 Node1_1_0 12.320000000000002
C_0_1_0 Node0_1_0 GND 3.609375e-06
I_0_1_1 GND Node0_1_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_1_1 Node0_1_1 Node0_1_2 77.0
R_0_1_1_2 Node0_1_1 Node0_2_1 77.0
R_0_1_1_3 Node0_1_1 Node1_1_1 12.320000000000002
C_0_1_1 Node0_1_1 GND 3.609375e-06
I_0_1_2 GND Node0_1_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_2_1 Node0_1_2 Node0_1_3 77.0
R_0_1_2_2 Node0_1_2 Node0_2_2 77.0
R_0_1_2_3 Node0_1_2 Node1_1_2 12.320000000000002
C_0_1_2 Node0_1_2 GND 3.609375e-06
I_0_1_3 GND Node0_1_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_3_1 Node0_1_3 Node0_1_4 77.0
R_0_1_3_2 Node0_1_3 Node0_2_3 77.0
R_0_1_3_3 Node0_1_3 Node1_1_3 12.320000000000002
C_0_1_3 Node0_1_3 GND 3.609375e-06
I_0_1_4 GND Node0_1_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_4_1 Node0_1_4 Node0_1_5 77.0
R_0_1_4_2 Node0_1_4 Node0_2_4 77.0
R_0_1_4_3 Node0_1_4 Node1_1_4 12.320000000000002
C_0_1_4 Node0_1_4 GND 3.609375e-06
I_0_1_5 GND Node0_1_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_5_1 Node0_1_5 Node0_1_6 77.0
R_0_1_5_2 Node0_1_5 Node0_2_5 77.0
R_0_1_5_3 Node0_1_5 Node1_1_5 12.320000000000002
C_0_1_5 Node0_1_5 GND 3.609375e-06
I_0_1_6 GND Node0_1_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_6_1 Node0_1_6 Node0_1_7 77.0
R_0_1_6_2 Node0_1_6 Node0_2_6 77.0
R_0_1_6_3 Node0_1_6 Node1_1_6 12.320000000000002
C_0_1_6 Node0_1_6 GND 3.609375e-06
I_0_1_7 GND Node0_1_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_7_1 Node0_1_7 Node0_1_8 77.0
R_0_1_7_2 Node0_1_7 Node0_2_7 77.0
R_0_1_7_3 Node0_1_7 Node1_1_7 12.320000000000002
C_0_1_7 Node0_1_7 GND 3.609375e-06
I_0_1_8 GND Node0_1_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_8_1 Node0_1_8 Node0_1_9 77.0
R_0_1_8_2 Node0_1_8 Node0_2_8 77.0
R_0_1_8_3 Node0_1_8 Node1_1_8 12.320000000000002
C_0_1_8 Node0_1_8 GND 3.609375e-06
I_0_1_9 GND Node0_1_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_9_1 Node0_1_9 Node0_1_10 77.0
R_0_1_9_2 Node0_1_9 Node0_2_9 77.0
R_0_1_9_3 Node0_1_9 Node1_1_9 12.320000000000002
C_0_1_9 Node0_1_9 GND 3.609375e-06
I_0_1_10 GND Node0_1_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_10_1 Node0_1_10 Node0_1_11 77.0
R_0_1_10_2 Node0_1_10 Node0_2_10 77.0
R_0_1_10_3 Node0_1_10 Node1_1_10 12.320000000000002
C_0_1_10 Node0_1_10 GND 3.609375e-06
I_0_1_11 GND Node0_1_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_11_1 Node0_1_11 Node0_1_12 77.0
R_0_1_11_2 Node0_1_11 Node0_2_11 77.0
R_0_1_11_3 Node0_1_11 Node1_1_11 12.320000000000002
C_0_1_11 Node0_1_11 GND 3.609375e-06
I_0_1_12 GND Node0_1_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_12_1 Node0_1_12 Node0_1_13 77.0
R_0_1_12_2 Node0_1_12 Node0_2_12 77.0
R_0_1_12_3 Node0_1_12 Node1_1_12 12.320000000000002
C_0_1_12 Node0_1_12 GND 3.609375e-06
I_0_1_13 GND Node0_1_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_13_1 Node0_1_13 Node0_1_14 77.0
R_0_1_13_2 Node0_1_13 Node0_2_13 77.0
R_0_1_13_3 Node0_1_13 Node1_1_13 12.320000000000002
C_0_1_13 Node0_1_13 GND 3.609375e-06
I_0_1_14 GND Node0_1_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_14_1 Node0_1_14 Node0_1_15 77.0
R_0_1_14_2 Node0_1_14 Node0_2_14 77.0
R_0_1_14_3 Node0_1_14 Node1_1_14 12.320000000000002
C_0_1_14 Node0_1_14 GND 3.609375e-06
I_0_1_15 GND Node0_1_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_15_1 Node0_1_15 Node0_1_16 77.0
R_0_1_15_2 Node0_1_15 Node0_2_15 77.0
R_0_1_15_3 Node0_1_15 Node1_1_15 12.320000000000002
C_0_1_15 Node0_1_15 GND 3.609375e-06
I_0_1_16 GND Node0_1_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_16_1 Node0_1_16 Node0_1_17 77.0
R_0_1_16_2 Node0_1_16 Node0_2_16 77.0
R_0_1_16_3 Node0_1_16 Node1_1_16 12.320000000000002
C_0_1_16 Node0_1_16 GND 3.609375e-06
I_0_1_17 GND Node0_1_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_17_1 Node0_1_17 Node0_1_18 77.0
R_0_1_17_2 Node0_1_17 Node0_2_17 77.0
R_0_1_17_3 Node0_1_17 Node1_1_17 12.320000000000002
C_0_1_17 Node0_1_17 GND 3.609375e-06
I_0_1_18 GND Node0_1_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_18_1 Node0_1_18 Node0_1_19 77.0
R_0_1_18_2 Node0_1_18 Node0_2_18 77.0
R_0_1_18_3 Node0_1_18 Node1_1_18 12.320000000000002
C_0_1_18 Node0_1_18 GND 3.609375e-06
I_0_1_19 GND Node0_1_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_19_1 Node0_1_19 Node0_1_20 77.0
R_0_1_19_2 Node0_1_19 Node0_2_19 77.0
R_0_1_19_3 Node0_1_19 Node1_1_19 12.320000000000002
C_0_1_19 Node0_1_19 GND 3.609375e-06
I_0_1_20 GND Node0_1_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_20_1 Node0_1_20 Node0_1_21 77.0
R_0_1_20_2 Node0_1_20 Node0_2_20 77.0
R_0_1_20_3 Node0_1_20 Node1_1_20 12.320000000000002
C_0_1_20 Node0_1_20 GND 3.609375e-06
I_0_1_21 GND Node0_1_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_21_1 Node0_1_21 Node0_1_22 77.0
R_0_1_21_2 Node0_1_21 Node0_2_21 77.0
R_0_1_21_3 Node0_1_21 Node1_1_21 12.320000000000002
C_0_1_21 Node0_1_21 GND 3.609375e-06
I_0_1_22 GND Node0_1_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_22_1 Node0_1_22 Node0_1_23 77.0
R_0_1_22_2 Node0_1_22 Node0_2_22 77.0
R_0_1_22_3 Node0_1_22 Node1_1_22 12.320000000000002
C_0_1_22 Node0_1_22 GND 3.609375e-06
I_0_1_23 GND Node0_1_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_23_1 Node0_1_23 Node0_1_24 77.0
R_0_1_23_2 Node0_1_23 Node0_2_23 77.0
R_0_1_23_3 Node0_1_23 Node1_1_23 12.320000000000002
C_0_1_23 Node0_1_23 GND 3.609375e-06
I_0_1_24 GND Node0_1_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_24_1 Node0_1_24 Node0_1_25 77.0
R_0_1_24_2 Node0_1_24 Node0_2_24 77.0
R_0_1_24_3 Node0_1_24 Node1_1_24 12.320000000000002
C_0_1_24 Node0_1_24 GND 3.609375e-06
I_0_1_25 GND Node0_1_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_25_1 Node0_1_25 Node0_1_26 77.0
R_0_1_25_2 Node0_1_25 Node0_2_25 77.0
R_0_1_25_3 Node0_1_25 Node1_1_25 12.320000000000002
C_0_1_25 Node0_1_25 GND 3.609375e-06
I_0_1_26 GND Node0_1_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_26_1 Node0_1_26 Node0_1_27 77.0
R_0_1_26_2 Node0_1_26 Node0_2_26 77.0
R_0_1_26_3 Node0_1_26 Node1_1_26 12.320000000000002
C_0_1_26 Node0_1_26 GND 3.609375e-06
I_0_1_27 GND Node0_1_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_27_1 Node0_1_27 Node0_1_28 77.0
R_0_1_27_2 Node0_1_27 Node0_2_27 77.0
R_0_1_27_3 Node0_1_27 Node1_1_27 12.320000000000002
C_0_1_27 Node0_1_27 GND 3.609375e-06
I_0_1_28 GND Node0_1_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_28_1 Node0_1_28 Node0_1_29 77.0
R_0_1_28_2 Node0_1_28 Node0_2_28 77.0
R_0_1_28_3 Node0_1_28 Node1_1_28 12.320000000000002
C_0_1_28 Node0_1_28 GND 3.609375e-06
I_0_1_29 GND Node0_1_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_29_1 Node0_1_29 Node0_1_30 77.0
R_0_1_29_2 Node0_1_29 Node0_2_29 77.0
R_0_1_29_3 Node0_1_29 Node1_1_29 12.320000000000002
C_0_1_29 Node0_1_29 GND 3.609375e-06
I_0_1_30 GND Node0_1_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_30_1 Node0_1_30 Node0_1_31 77.0
R_0_1_30_2 Node0_1_30 Node0_2_30 77.0
R_0_1_30_3 Node0_1_30 Node1_1_30 12.320000000000002
C_0_1_30 Node0_1_30 GND 3.609375e-06
I_0_1_31 GND Node0_1_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_31_1 Node0_1_31 Node0_1_32 77.0
R_0_1_31_2 Node0_1_31 Node0_2_31 77.0
R_0_1_31_3 Node0_1_31 Node1_1_31 12.320000000000002
C_0_1_31 Node0_1_31 GND 3.609375e-06
I_0_1_32 GND Node0_1_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_32_1 Node0_1_32 Node0_1_33 77.0
R_0_1_32_2 Node0_1_32 Node0_2_32 77.0
R_0_1_32_3 Node0_1_32 Node1_1_32 12.320000000000002
C_0_1_32 Node0_1_32 GND 3.609375e-06
I_0_1_33 GND Node0_1_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_33_1 Node0_1_33 Node0_1_34 77.0
R_0_1_33_2 Node0_1_33 Node0_2_33 77.0
R_0_1_33_3 Node0_1_33 Node1_1_33 12.320000000000002
C_0_1_33 Node0_1_33 GND 3.609375e-06
I_0_1_34 GND Node0_1_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_34_1 Node0_1_34 Node0_1_35 77.0
R_0_1_34_2 Node0_1_34 Node0_2_34 77.0
R_0_1_34_3 Node0_1_34 Node1_1_34 12.320000000000002
C_0_1_34 Node0_1_34 GND 3.609375e-06
I_0_1_35 GND Node0_1_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_35_1 Node0_1_35 Node0_1_36 77.0
R_0_1_35_2 Node0_1_35 Node0_2_35 77.0
R_0_1_35_3 Node0_1_35 Node1_1_35 12.320000000000002
C_0_1_35 Node0_1_35 GND 3.609375e-06
I_0_1_36 GND Node0_1_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_36_1 Node0_1_36 Node0_1_37 77.0
R_0_1_36_2 Node0_1_36 Node0_2_36 77.0
R_0_1_36_3 Node0_1_36 Node1_1_36 12.320000000000002
C_0_1_36 Node0_1_36 GND 3.609375e-06
I_0_1_37 GND Node0_1_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_37_1 Node0_1_37 Node0_1_38 77.0
R_0_1_37_2 Node0_1_37 Node0_2_37 77.0
R_0_1_37_3 Node0_1_37 Node1_1_37 12.320000000000002
C_0_1_37 Node0_1_37 GND 3.609375e-06
I_0_1_38 GND Node0_1_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_38_1 Node0_1_38 Node0_1_39 77.0
R_0_1_38_2 Node0_1_38 Node0_2_38 77.0
R_0_1_38_3 Node0_1_38 Node1_1_38 12.320000000000002
C_0_1_38 Node0_1_38 GND 3.609375e-06
I_0_1_39 GND Node0_1_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_1_39_2 Node0_1_39 Node0_2_39 77.0
R_0_1_39_3 Node0_1_39 Node1_1_39 12.320000000000002
C_0_1_39 Node0_1_39 GND 3.609375e-06
I_0_2_0 GND Node0_2_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_0_1 Node0_2_0 Node0_2_1 77.0
R_0_2_0_2 Node0_2_0 Node0_3_0 77.0
R_0_2_0_3 Node0_2_0 Node1_2_0 12.320000000000002
C_0_2_0 Node0_2_0 GND 3.609375e-06
I_0_2_1 GND Node0_2_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_1_1 Node0_2_1 Node0_2_2 77.0
R_0_2_1_2 Node0_2_1 Node0_3_1 77.0
R_0_2_1_3 Node0_2_1 Node1_2_1 12.320000000000002
C_0_2_1 Node0_2_1 GND 3.609375e-06
I_0_2_2 GND Node0_2_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_2_1 Node0_2_2 Node0_2_3 77.0
R_0_2_2_2 Node0_2_2 Node0_3_2 77.0
R_0_2_2_3 Node0_2_2 Node1_2_2 12.320000000000002
C_0_2_2 Node0_2_2 GND 3.609375e-06
I_0_2_3 GND Node0_2_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_3_1 Node0_2_3 Node0_2_4 77.0
R_0_2_3_2 Node0_2_3 Node0_3_3 77.0
R_0_2_3_3 Node0_2_3 Node1_2_3 12.320000000000002
C_0_2_3 Node0_2_3 GND 3.609375e-06
I_0_2_4 GND Node0_2_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_4_1 Node0_2_4 Node0_2_5 77.0
R_0_2_4_2 Node0_2_4 Node0_3_4 77.0
R_0_2_4_3 Node0_2_4 Node1_2_4 12.320000000000002
C_0_2_4 Node0_2_4 GND 3.609375e-06
I_0_2_5 GND Node0_2_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_5_1 Node0_2_5 Node0_2_6 77.0
R_0_2_5_2 Node0_2_5 Node0_3_5 77.0
R_0_2_5_3 Node0_2_5 Node1_2_5 12.320000000000002
C_0_2_5 Node0_2_5 GND 3.609375e-06
I_0_2_6 GND Node0_2_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_6_1 Node0_2_6 Node0_2_7 77.0
R_0_2_6_2 Node0_2_6 Node0_3_6 77.0
R_0_2_6_3 Node0_2_6 Node1_2_6 12.320000000000002
C_0_2_6 Node0_2_6 GND 3.609375e-06
I_0_2_7 GND Node0_2_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_7_1 Node0_2_7 Node0_2_8 77.0
R_0_2_7_2 Node0_2_7 Node0_3_7 77.0
R_0_2_7_3 Node0_2_7 Node1_2_7 12.320000000000002
C_0_2_7 Node0_2_7 GND 3.609375e-06
I_0_2_8 GND Node0_2_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_8_1 Node0_2_8 Node0_2_9 77.0
R_0_2_8_2 Node0_2_8 Node0_3_8 77.0
R_0_2_8_3 Node0_2_8 Node1_2_8 12.320000000000002
C_0_2_8 Node0_2_8 GND 3.609375e-06
I_0_2_9 GND Node0_2_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_9_1 Node0_2_9 Node0_2_10 77.0
R_0_2_9_2 Node0_2_9 Node0_3_9 77.0
R_0_2_9_3 Node0_2_9 Node1_2_9 12.320000000000002
C_0_2_9 Node0_2_9 GND 3.609375e-06
I_0_2_10 GND Node0_2_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_10_1 Node0_2_10 Node0_2_11 77.0
R_0_2_10_2 Node0_2_10 Node0_3_10 77.0
R_0_2_10_3 Node0_2_10 Node1_2_10 12.320000000000002
C_0_2_10 Node0_2_10 GND 3.609375e-06
I_0_2_11 GND Node0_2_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_11_1 Node0_2_11 Node0_2_12 77.0
R_0_2_11_2 Node0_2_11 Node0_3_11 77.0
R_0_2_11_3 Node0_2_11 Node1_2_11 12.320000000000002
C_0_2_11 Node0_2_11 GND 3.609375e-06
I_0_2_12 GND Node0_2_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_12_1 Node0_2_12 Node0_2_13 77.0
R_0_2_12_2 Node0_2_12 Node0_3_12 77.0
R_0_2_12_3 Node0_2_12 Node1_2_12 12.320000000000002
C_0_2_12 Node0_2_12 GND 3.609375e-06
I_0_2_13 GND Node0_2_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_13_1 Node0_2_13 Node0_2_14 77.0
R_0_2_13_2 Node0_2_13 Node0_3_13 77.0
R_0_2_13_3 Node0_2_13 Node1_2_13 12.320000000000002
C_0_2_13 Node0_2_13 GND 3.609375e-06
I_0_2_14 GND Node0_2_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_14_1 Node0_2_14 Node0_2_15 77.0
R_0_2_14_2 Node0_2_14 Node0_3_14 77.0
R_0_2_14_3 Node0_2_14 Node1_2_14 12.320000000000002
C_0_2_14 Node0_2_14 GND 3.609375e-06
I_0_2_15 GND Node0_2_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_15_1 Node0_2_15 Node0_2_16 77.0
R_0_2_15_2 Node0_2_15 Node0_3_15 77.0
R_0_2_15_3 Node0_2_15 Node1_2_15 12.320000000000002
C_0_2_15 Node0_2_15 GND 3.609375e-06
I_0_2_16 GND Node0_2_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_16_1 Node0_2_16 Node0_2_17 77.0
R_0_2_16_2 Node0_2_16 Node0_3_16 77.0
R_0_2_16_3 Node0_2_16 Node1_2_16 12.320000000000002
C_0_2_16 Node0_2_16 GND 3.609375e-06
I_0_2_17 GND Node0_2_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_17_1 Node0_2_17 Node0_2_18 77.0
R_0_2_17_2 Node0_2_17 Node0_3_17 77.0
R_0_2_17_3 Node0_2_17 Node1_2_17 12.320000000000002
C_0_2_17 Node0_2_17 GND 3.609375e-06
I_0_2_18 GND Node0_2_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_18_1 Node0_2_18 Node0_2_19 77.0
R_0_2_18_2 Node0_2_18 Node0_3_18 77.0
R_0_2_18_3 Node0_2_18 Node1_2_18 12.320000000000002
C_0_2_18 Node0_2_18 GND 3.609375e-06
I_0_2_19 GND Node0_2_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_19_1 Node0_2_19 Node0_2_20 77.0
R_0_2_19_2 Node0_2_19 Node0_3_19 77.0
R_0_2_19_3 Node0_2_19 Node1_2_19 12.320000000000002
C_0_2_19 Node0_2_19 GND 3.609375e-06
I_0_2_20 GND Node0_2_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_20_1 Node0_2_20 Node0_2_21 77.0
R_0_2_20_2 Node0_2_20 Node0_3_20 77.0
R_0_2_20_3 Node0_2_20 Node1_2_20 12.320000000000002
C_0_2_20 Node0_2_20 GND 3.609375e-06
I_0_2_21 GND Node0_2_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_21_1 Node0_2_21 Node0_2_22 77.0
R_0_2_21_2 Node0_2_21 Node0_3_21 77.0
R_0_2_21_3 Node0_2_21 Node1_2_21 12.320000000000002
C_0_2_21 Node0_2_21 GND 3.609375e-06
I_0_2_22 GND Node0_2_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_22_1 Node0_2_22 Node0_2_23 77.0
R_0_2_22_2 Node0_2_22 Node0_3_22 77.0
R_0_2_22_3 Node0_2_22 Node1_2_22 12.320000000000002
C_0_2_22 Node0_2_22 GND 3.609375e-06
I_0_2_23 GND Node0_2_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_23_1 Node0_2_23 Node0_2_24 77.0
R_0_2_23_2 Node0_2_23 Node0_3_23 77.0
R_0_2_23_3 Node0_2_23 Node1_2_23 12.320000000000002
C_0_2_23 Node0_2_23 GND 3.609375e-06
I_0_2_24 GND Node0_2_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_24_1 Node0_2_24 Node0_2_25 77.0
R_0_2_24_2 Node0_2_24 Node0_3_24 77.0
R_0_2_24_3 Node0_2_24 Node1_2_24 12.320000000000002
C_0_2_24 Node0_2_24 GND 3.609375e-06
I_0_2_25 GND Node0_2_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_25_1 Node0_2_25 Node0_2_26 77.0
R_0_2_25_2 Node0_2_25 Node0_3_25 77.0
R_0_2_25_3 Node0_2_25 Node1_2_25 12.320000000000002
C_0_2_25 Node0_2_25 GND 3.609375e-06
I_0_2_26 GND Node0_2_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_26_1 Node0_2_26 Node0_2_27 77.0
R_0_2_26_2 Node0_2_26 Node0_3_26 77.0
R_0_2_26_3 Node0_2_26 Node1_2_26 12.320000000000002
C_0_2_26 Node0_2_26 GND 3.609375e-06
I_0_2_27 GND Node0_2_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_27_1 Node0_2_27 Node0_2_28 77.0
R_0_2_27_2 Node0_2_27 Node0_3_27 77.0
R_0_2_27_3 Node0_2_27 Node1_2_27 12.320000000000002
C_0_2_27 Node0_2_27 GND 3.609375e-06
I_0_2_28 GND Node0_2_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_28_1 Node0_2_28 Node0_2_29 77.0
R_0_2_28_2 Node0_2_28 Node0_3_28 77.0
R_0_2_28_3 Node0_2_28 Node1_2_28 12.320000000000002
C_0_2_28 Node0_2_28 GND 3.609375e-06
I_0_2_29 GND Node0_2_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_29_1 Node0_2_29 Node0_2_30 77.0
R_0_2_29_2 Node0_2_29 Node0_3_29 77.0
R_0_2_29_3 Node0_2_29 Node1_2_29 12.320000000000002
C_0_2_29 Node0_2_29 GND 3.609375e-06
I_0_2_30 GND Node0_2_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_30_1 Node0_2_30 Node0_2_31 77.0
R_0_2_30_2 Node0_2_30 Node0_3_30 77.0
R_0_2_30_3 Node0_2_30 Node1_2_30 12.320000000000002
C_0_2_30 Node0_2_30 GND 3.609375e-06
I_0_2_31 GND Node0_2_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_31_1 Node0_2_31 Node0_2_32 77.0
R_0_2_31_2 Node0_2_31 Node0_3_31 77.0
R_0_2_31_3 Node0_2_31 Node1_2_31 12.320000000000002
C_0_2_31 Node0_2_31 GND 3.609375e-06
I_0_2_32 GND Node0_2_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_32_1 Node0_2_32 Node0_2_33 77.0
R_0_2_32_2 Node0_2_32 Node0_3_32 77.0
R_0_2_32_3 Node0_2_32 Node1_2_32 12.320000000000002
C_0_2_32 Node0_2_32 GND 3.609375e-06
I_0_2_33 GND Node0_2_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_33_1 Node0_2_33 Node0_2_34 77.0
R_0_2_33_2 Node0_2_33 Node0_3_33 77.0
R_0_2_33_3 Node0_2_33 Node1_2_33 12.320000000000002
C_0_2_33 Node0_2_33 GND 3.609375e-06
I_0_2_34 GND Node0_2_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_34_1 Node0_2_34 Node0_2_35 77.0
R_0_2_34_2 Node0_2_34 Node0_3_34 77.0
R_0_2_34_3 Node0_2_34 Node1_2_34 12.320000000000002
C_0_2_34 Node0_2_34 GND 3.609375e-06
I_0_2_35 GND Node0_2_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_35_1 Node0_2_35 Node0_2_36 77.0
R_0_2_35_2 Node0_2_35 Node0_3_35 77.0
R_0_2_35_3 Node0_2_35 Node1_2_35 12.320000000000002
C_0_2_35 Node0_2_35 GND 3.609375e-06
I_0_2_36 GND Node0_2_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_36_1 Node0_2_36 Node0_2_37 77.0
R_0_2_36_2 Node0_2_36 Node0_3_36 77.0
R_0_2_36_3 Node0_2_36 Node1_2_36 12.320000000000002
C_0_2_36 Node0_2_36 GND 3.609375e-06
I_0_2_37 GND Node0_2_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_37_1 Node0_2_37 Node0_2_38 77.0
R_0_2_37_2 Node0_2_37 Node0_3_37 77.0
R_0_2_37_3 Node0_2_37 Node1_2_37 12.320000000000002
C_0_2_37 Node0_2_37 GND 3.609375e-06
I_0_2_38 GND Node0_2_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_38_1 Node0_2_38 Node0_2_39 77.0
R_0_2_38_2 Node0_2_38 Node0_3_38 77.0
R_0_2_38_3 Node0_2_38 Node1_2_38 12.320000000000002
C_0_2_38 Node0_2_38 GND 3.609375e-06
I_0_2_39 GND Node0_2_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_2_39_2 Node0_2_39 Node0_3_39 77.0
R_0_2_39_3 Node0_2_39 Node1_2_39 12.320000000000002
C_0_2_39 Node0_2_39 GND 3.609375e-06
I_0_3_0 GND Node0_3_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_0_1 Node0_3_0 Node0_3_1 77.0
R_0_3_0_2 Node0_3_0 Node0_4_0 77.0
R_0_3_0_3 Node0_3_0 Node1_3_0 12.320000000000002
C_0_3_0 Node0_3_0 GND 3.609375e-06
I_0_3_1 GND Node0_3_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_1_1 Node0_3_1 Node0_3_2 77.0
R_0_3_1_2 Node0_3_1 Node0_4_1 77.0
R_0_3_1_3 Node0_3_1 Node1_3_1 12.320000000000002
C_0_3_1 Node0_3_1 GND 3.609375e-06
I_0_3_2 GND Node0_3_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_2_1 Node0_3_2 Node0_3_3 77.0
R_0_3_2_2 Node0_3_2 Node0_4_2 77.0
R_0_3_2_3 Node0_3_2 Node1_3_2 12.320000000000002
C_0_3_2 Node0_3_2 GND 3.609375e-06
I_0_3_3 GND Node0_3_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_3_1 Node0_3_3 Node0_3_4 77.0
R_0_3_3_2 Node0_3_3 Node0_4_3 77.0
R_0_3_3_3 Node0_3_3 Node1_3_3 12.320000000000002
C_0_3_3 Node0_3_3 GND 3.609375e-06
I_0_3_4 GND Node0_3_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_4_1 Node0_3_4 Node0_3_5 77.0
R_0_3_4_2 Node0_3_4 Node0_4_4 77.0
R_0_3_4_3 Node0_3_4 Node1_3_4 12.320000000000002
C_0_3_4 Node0_3_4 GND 3.609375e-06
I_0_3_5 GND Node0_3_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_5_1 Node0_3_5 Node0_3_6 77.0
R_0_3_5_2 Node0_3_5 Node0_4_5 77.0
R_0_3_5_3 Node0_3_5 Node1_3_5 12.320000000000002
C_0_3_5 Node0_3_5 GND 3.609375e-06
I_0_3_6 GND Node0_3_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_6_1 Node0_3_6 Node0_3_7 77.0
R_0_3_6_2 Node0_3_6 Node0_4_6 77.0
R_0_3_6_3 Node0_3_6 Node1_3_6 12.320000000000002
C_0_3_6 Node0_3_6 GND 3.609375e-06
I_0_3_7 GND Node0_3_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_7_1 Node0_3_7 Node0_3_8 77.0
R_0_3_7_2 Node0_3_7 Node0_4_7 77.0
R_0_3_7_3 Node0_3_7 Node1_3_7 12.320000000000002
C_0_3_7 Node0_3_7 GND 3.609375e-06
I_0_3_8 GND Node0_3_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_8_1 Node0_3_8 Node0_3_9 77.0
R_0_3_8_2 Node0_3_8 Node0_4_8 77.0
R_0_3_8_3 Node0_3_8 Node1_3_8 12.320000000000002
C_0_3_8 Node0_3_8 GND 3.609375e-06
I_0_3_9 GND Node0_3_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_9_1 Node0_3_9 Node0_3_10 77.0
R_0_3_9_2 Node0_3_9 Node0_4_9 77.0
R_0_3_9_3 Node0_3_9 Node1_3_9 12.320000000000002
C_0_3_9 Node0_3_9 GND 3.609375e-06
I_0_3_10 GND Node0_3_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_10_1 Node0_3_10 Node0_3_11 77.0
R_0_3_10_2 Node0_3_10 Node0_4_10 77.0
R_0_3_10_3 Node0_3_10 Node1_3_10 12.320000000000002
C_0_3_10 Node0_3_10 GND 3.609375e-06
I_0_3_11 GND Node0_3_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_11_1 Node0_3_11 Node0_3_12 77.0
R_0_3_11_2 Node0_3_11 Node0_4_11 77.0
R_0_3_11_3 Node0_3_11 Node1_3_11 12.320000000000002
C_0_3_11 Node0_3_11 GND 3.609375e-06
I_0_3_12 GND Node0_3_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_12_1 Node0_3_12 Node0_3_13 77.0
R_0_3_12_2 Node0_3_12 Node0_4_12 77.0
R_0_3_12_3 Node0_3_12 Node1_3_12 12.320000000000002
C_0_3_12 Node0_3_12 GND 3.609375e-06
I_0_3_13 GND Node0_3_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_13_1 Node0_3_13 Node0_3_14 77.0
R_0_3_13_2 Node0_3_13 Node0_4_13 77.0
R_0_3_13_3 Node0_3_13 Node1_3_13 12.320000000000002
C_0_3_13 Node0_3_13 GND 3.609375e-06
I_0_3_14 GND Node0_3_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_14_1 Node0_3_14 Node0_3_15 77.0
R_0_3_14_2 Node0_3_14 Node0_4_14 77.0
R_0_3_14_3 Node0_3_14 Node1_3_14 12.320000000000002
C_0_3_14 Node0_3_14 GND 3.609375e-06
I_0_3_15 GND Node0_3_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_15_1 Node0_3_15 Node0_3_16 77.0
R_0_3_15_2 Node0_3_15 Node0_4_15 77.0
R_0_3_15_3 Node0_3_15 Node1_3_15 12.320000000000002
C_0_3_15 Node0_3_15 GND 3.609375e-06
I_0_3_16 GND Node0_3_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_16_1 Node0_3_16 Node0_3_17 77.0
R_0_3_16_2 Node0_3_16 Node0_4_16 77.0
R_0_3_16_3 Node0_3_16 Node1_3_16 12.320000000000002
C_0_3_16 Node0_3_16 GND 3.609375e-06
I_0_3_17 GND Node0_3_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_17_1 Node0_3_17 Node0_3_18 77.0
R_0_3_17_2 Node0_3_17 Node0_4_17 77.0
R_0_3_17_3 Node0_3_17 Node1_3_17 12.320000000000002
C_0_3_17 Node0_3_17 GND 3.609375e-06
I_0_3_18 GND Node0_3_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_18_1 Node0_3_18 Node0_3_19 77.0
R_0_3_18_2 Node0_3_18 Node0_4_18 77.0
R_0_3_18_3 Node0_3_18 Node1_3_18 12.320000000000002
C_0_3_18 Node0_3_18 GND 3.609375e-06
I_0_3_19 GND Node0_3_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_19_1 Node0_3_19 Node0_3_20 77.0
R_0_3_19_2 Node0_3_19 Node0_4_19 77.0
R_0_3_19_3 Node0_3_19 Node1_3_19 12.320000000000002
C_0_3_19 Node0_3_19 GND 3.609375e-06
I_0_3_20 GND Node0_3_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_20_1 Node0_3_20 Node0_3_21 77.0
R_0_3_20_2 Node0_3_20 Node0_4_20 77.0
R_0_3_20_3 Node0_3_20 Node1_3_20 12.320000000000002
C_0_3_20 Node0_3_20 GND 3.609375e-06
I_0_3_21 GND Node0_3_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_21_1 Node0_3_21 Node0_3_22 77.0
R_0_3_21_2 Node0_3_21 Node0_4_21 77.0
R_0_3_21_3 Node0_3_21 Node1_3_21 12.320000000000002
C_0_3_21 Node0_3_21 GND 3.609375e-06
I_0_3_22 GND Node0_3_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_22_1 Node0_3_22 Node0_3_23 77.0
R_0_3_22_2 Node0_3_22 Node0_4_22 77.0
R_0_3_22_3 Node0_3_22 Node1_3_22 12.320000000000002
C_0_3_22 Node0_3_22 GND 3.609375e-06
I_0_3_23 GND Node0_3_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_23_1 Node0_3_23 Node0_3_24 77.0
R_0_3_23_2 Node0_3_23 Node0_4_23 77.0
R_0_3_23_3 Node0_3_23 Node1_3_23 12.320000000000002
C_0_3_23 Node0_3_23 GND 3.609375e-06
I_0_3_24 GND Node0_3_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_24_1 Node0_3_24 Node0_3_25 77.0
R_0_3_24_2 Node0_3_24 Node0_4_24 77.0
R_0_3_24_3 Node0_3_24 Node1_3_24 12.320000000000002
C_0_3_24 Node0_3_24 GND 3.609375e-06
I_0_3_25 GND Node0_3_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_25_1 Node0_3_25 Node0_3_26 77.0
R_0_3_25_2 Node0_3_25 Node0_4_25 77.0
R_0_3_25_3 Node0_3_25 Node1_3_25 12.320000000000002
C_0_3_25 Node0_3_25 GND 3.609375e-06
I_0_3_26 GND Node0_3_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_26_1 Node0_3_26 Node0_3_27 77.0
R_0_3_26_2 Node0_3_26 Node0_4_26 77.0
R_0_3_26_3 Node0_3_26 Node1_3_26 12.320000000000002
C_0_3_26 Node0_3_26 GND 3.609375e-06
I_0_3_27 GND Node0_3_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_27_1 Node0_3_27 Node0_3_28 77.0
R_0_3_27_2 Node0_3_27 Node0_4_27 77.0
R_0_3_27_3 Node0_3_27 Node1_3_27 12.320000000000002
C_0_3_27 Node0_3_27 GND 3.609375e-06
I_0_3_28 GND Node0_3_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_28_1 Node0_3_28 Node0_3_29 77.0
R_0_3_28_2 Node0_3_28 Node0_4_28 77.0
R_0_3_28_3 Node0_3_28 Node1_3_28 12.320000000000002
C_0_3_28 Node0_3_28 GND 3.609375e-06
I_0_3_29 GND Node0_3_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_29_1 Node0_3_29 Node0_3_30 77.0
R_0_3_29_2 Node0_3_29 Node0_4_29 77.0
R_0_3_29_3 Node0_3_29 Node1_3_29 12.320000000000002
C_0_3_29 Node0_3_29 GND 3.609375e-06
I_0_3_30 GND Node0_3_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_30_1 Node0_3_30 Node0_3_31 77.0
R_0_3_30_2 Node0_3_30 Node0_4_30 77.0
R_0_3_30_3 Node0_3_30 Node1_3_30 12.320000000000002
C_0_3_30 Node0_3_30 GND 3.609375e-06
I_0_3_31 GND Node0_3_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_31_1 Node0_3_31 Node0_3_32 77.0
R_0_3_31_2 Node0_3_31 Node0_4_31 77.0
R_0_3_31_3 Node0_3_31 Node1_3_31 12.320000000000002
C_0_3_31 Node0_3_31 GND 3.609375e-06
I_0_3_32 GND Node0_3_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_32_1 Node0_3_32 Node0_3_33 77.0
R_0_3_32_2 Node0_3_32 Node0_4_32 77.0
R_0_3_32_3 Node0_3_32 Node1_3_32 12.320000000000002
C_0_3_32 Node0_3_32 GND 3.609375e-06
I_0_3_33 GND Node0_3_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_33_1 Node0_3_33 Node0_3_34 77.0
R_0_3_33_2 Node0_3_33 Node0_4_33 77.0
R_0_3_33_3 Node0_3_33 Node1_3_33 12.320000000000002
C_0_3_33 Node0_3_33 GND 3.609375e-06
I_0_3_34 GND Node0_3_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_34_1 Node0_3_34 Node0_3_35 77.0
R_0_3_34_2 Node0_3_34 Node0_4_34 77.0
R_0_3_34_3 Node0_3_34 Node1_3_34 12.320000000000002
C_0_3_34 Node0_3_34 GND 3.609375e-06
I_0_3_35 GND Node0_3_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_35_1 Node0_3_35 Node0_3_36 77.0
R_0_3_35_2 Node0_3_35 Node0_4_35 77.0
R_0_3_35_3 Node0_3_35 Node1_3_35 12.320000000000002
C_0_3_35 Node0_3_35 GND 3.609375e-06
I_0_3_36 GND Node0_3_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_36_1 Node0_3_36 Node0_3_37 77.0
R_0_3_36_2 Node0_3_36 Node0_4_36 77.0
R_0_3_36_3 Node0_3_36 Node1_3_36 12.320000000000002
C_0_3_36 Node0_3_36 GND 3.609375e-06
I_0_3_37 GND Node0_3_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_37_1 Node0_3_37 Node0_3_38 77.0
R_0_3_37_2 Node0_3_37 Node0_4_37 77.0
R_0_3_37_3 Node0_3_37 Node1_3_37 12.320000000000002
C_0_3_37 Node0_3_37 GND 3.609375e-06
I_0_3_38 GND Node0_3_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_38_1 Node0_3_38 Node0_3_39 77.0
R_0_3_38_2 Node0_3_38 Node0_4_38 77.0
R_0_3_38_3 Node0_3_38 Node1_3_38 12.320000000000002
C_0_3_38 Node0_3_38 GND 3.609375e-06
I_0_3_39 GND Node0_3_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_3_39_2 Node0_3_39 Node0_4_39 77.0
R_0_3_39_3 Node0_3_39 Node1_3_39 12.320000000000002
C_0_3_39 Node0_3_39 GND 3.609375e-06
I_0_4_0 GND Node0_4_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_0_1 Node0_4_0 Node0_4_1 77.0
R_0_4_0_2 Node0_4_0 Node0_5_0 77.0
R_0_4_0_3 Node0_4_0 Node1_4_0 12.320000000000002
C_0_4_0 Node0_4_0 GND 3.609375e-06
I_0_4_1 GND Node0_4_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_1_1 Node0_4_1 Node0_4_2 77.0
R_0_4_1_2 Node0_4_1 Node0_5_1 77.0
R_0_4_1_3 Node0_4_1 Node1_4_1 12.320000000000002
C_0_4_1 Node0_4_1 GND 3.609375e-06
I_0_4_2 GND Node0_4_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_2_1 Node0_4_2 Node0_4_3 77.0
R_0_4_2_2 Node0_4_2 Node0_5_2 77.0
R_0_4_2_3 Node0_4_2 Node1_4_2 12.320000000000002
C_0_4_2 Node0_4_2 GND 3.609375e-06
I_0_4_3 GND Node0_4_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_3_1 Node0_4_3 Node0_4_4 77.0
R_0_4_3_2 Node0_4_3 Node0_5_3 77.0
R_0_4_3_3 Node0_4_3 Node1_4_3 12.320000000000002
C_0_4_3 Node0_4_3 GND 3.609375e-06
I_0_4_4 GND Node0_4_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_4_1 Node0_4_4 Node0_4_5 77.0
R_0_4_4_2 Node0_4_4 Node0_5_4 77.0
R_0_4_4_3 Node0_4_4 Node1_4_4 12.320000000000002
C_0_4_4 Node0_4_4 GND 3.609375e-06
I_0_4_5 GND Node0_4_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_5_1 Node0_4_5 Node0_4_6 77.0
R_0_4_5_2 Node0_4_5 Node0_5_5 77.0
R_0_4_5_3 Node0_4_5 Node1_4_5 12.320000000000002
C_0_4_5 Node0_4_5 GND 3.609375e-06
I_0_4_6 GND Node0_4_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_6_1 Node0_4_6 Node0_4_7 77.0
R_0_4_6_2 Node0_4_6 Node0_5_6 77.0
R_0_4_6_3 Node0_4_6 Node1_4_6 12.320000000000002
C_0_4_6 Node0_4_6 GND 3.609375e-06
I_0_4_7 GND Node0_4_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_7_1 Node0_4_7 Node0_4_8 77.0
R_0_4_7_2 Node0_4_7 Node0_5_7 77.0
R_0_4_7_3 Node0_4_7 Node1_4_7 12.320000000000002
C_0_4_7 Node0_4_7 GND 3.609375e-06
I_0_4_8 GND Node0_4_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_8_1 Node0_4_8 Node0_4_9 77.0
R_0_4_8_2 Node0_4_8 Node0_5_8 77.0
R_0_4_8_3 Node0_4_8 Node1_4_8 12.320000000000002
C_0_4_8 Node0_4_8 GND 3.609375e-06
I_0_4_9 GND Node0_4_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_9_1 Node0_4_9 Node0_4_10 77.0
R_0_4_9_2 Node0_4_9 Node0_5_9 77.0
R_0_4_9_3 Node0_4_9 Node1_4_9 12.320000000000002
C_0_4_9 Node0_4_9 GND 3.609375e-06
I_0_4_10 GND Node0_4_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_10_1 Node0_4_10 Node0_4_11 77.0
R_0_4_10_2 Node0_4_10 Node0_5_10 77.0
R_0_4_10_3 Node0_4_10 Node1_4_10 12.320000000000002
C_0_4_10 Node0_4_10 GND 3.609375e-06
I_0_4_11 GND Node0_4_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_11_1 Node0_4_11 Node0_4_12 77.0
R_0_4_11_2 Node0_4_11 Node0_5_11 77.0
R_0_4_11_3 Node0_4_11 Node1_4_11 12.320000000000002
C_0_4_11 Node0_4_11 GND 3.609375e-06
I_0_4_12 GND Node0_4_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_12_1 Node0_4_12 Node0_4_13 77.0
R_0_4_12_2 Node0_4_12 Node0_5_12 77.0
R_0_4_12_3 Node0_4_12 Node1_4_12 12.320000000000002
C_0_4_12 Node0_4_12 GND 3.609375e-06
I_0_4_13 GND Node0_4_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_13_1 Node0_4_13 Node0_4_14 77.0
R_0_4_13_2 Node0_4_13 Node0_5_13 77.0
R_0_4_13_3 Node0_4_13 Node1_4_13 12.320000000000002
C_0_4_13 Node0_4_13 GND 3.609375e-06
I_0_4_14 GND Node0_4_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_14_1 Node0_4_14 Node0_4_15 77.0
R_0_4_14_2 Node0_4_14 Node0_5_14 77.0
R_0_4_14_3 Node0_4_14 Node1_4_14 12.320000000000002
C_0_4_14 Node0_4_14 GND 3.609375e-06
I_0_4_15 GND Node0_4_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_15_1 Node0_4_15 Node0_4_16 77.0
R_0_4_15_2 Node0_4_15 Node0_5_15 77.0
R_0_4_15_3 Node0_4_15 Node1_4_15 12.320000000000002
C_0_4_15 Node0_4_15 GND 3.609375e-06
I_0_4_16 GND Node0_4_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_16_1 Node0_4_16 Node0_4_17 77.0
R_0_4_16_2 Node0_4_16 Node0_5_16 77.0
R_0_4_16_3 Node0_4_16 Node1_4_16 12.320000000000002
C_0_4_16 Node0_4_16 GND 3.609375e-06
I_0_4_17 GND Node0_4_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_17_1 Node0_4_17 Node0_4_18 77.0
R_0_4_17_2 Node0_4_17 Node0_5_17 77.0
R_0_4_17_3 Node0_4_17 Node1_4_17 12.320000000000002
C_0_4_17 Node0_4_17 GND 3.609375e-06
I_0_4_18 GND Node0_4_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_18_1 Node0_4_18 Node0_4_19 77.0
R_0_4_18_2 Node0_4_18 Node0_5_18 77.0
R_0_4_18_3 Node0_4_18 Node1_4_18 12.320000000000002
C_0_4_18 Node0_4_18 GND 3.609375e-06
I_0_4_19 GND Node0_4_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_19_1 Node0_4_19 Node0_4_20 77.0
R_0_4_19_2 Node0_4_19 Node0_5_19 77.0
R_0_4_19_3 Node0_4_19 Node1_4_19 12.320000000000002
C_0_4_19 Node0_4_19 GND 3.609375e-06
I_0_4_20 GND Node0_4_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_20_1 Node0_4_20 Node0_4_21 77.0
R_0_4_20_2 Node0_4_20 Node0_5_20 77.0
R_0_4_20_3 Node0_4_20 Node1_4_20 12.320000000000002
C_0_4_20 Node0_4_20 GND 3.609375e-06
I_0_4_21 GND Node0_4_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_21_1 Node0_4_21 Node0_4_22 77.0
R_0_4_21_2 Node0_4_21 Node0_5_21 77.0
R_0_4_21_3 Node0_4_21 Node1_4_21 12.320000000000002
C_0_4_21 Node0_4_21 GND 3.609375e-06
I_0_4_22 GND Node0_4_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_22_1 Node0_4_22 Node0_4_23 77.0
R_0_4_22_2 Node0_4_22 Node0_5_22 77.0
R_0_4_22_3 Node0_4_22 Node1_4_22 12.320000000000002
C_0_4_22 Node0_4_22 GND 3.609375e-06
I_0_4_23 GND Node0_4_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_23_1 Node0_4_23 Node0_4_24 77.0
R_0_4_23_2 Node0_4_23 Node0_5_23 77.0
R_0_4_23_3 Node0_4_23 Node1_4_23 12.320000000000002
C_0_4_23 Node0_4_23 GND 3.609375e-06
I_0_4_24 GND Node0_4_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_24_1 Node0_4_24 Node0_4_25 77.0
R_0_4_24_2 Node0_4_24 Node0_5_24 77.0
R_0_4_24_3 Node0_4_24 Node1_4_24 12.320000000000002
C_0_4_24 Node0_4_24 GND 3.609375e-06
I_0_4_25 GND Node0_4_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_25_1 Node0_4_25 Node0_4_26 77.0
R_0_4_25_2 Node0_4_25 Node0_5_25 77.0
R_0_4_25_3 Node0_4_25 Node1_4_25 12.320000000000002
C_0_4_25 Node0_4_25 GND 3.609375e-06
I_0_4_26 GND Node0_4_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_26_1 Node0_4_26 Node0_4_27 77.0
R_0_4_26_2 Node0_4_26 Node0_5_26 77.0
R_0_4_26_3 Node0_4_26 Node1_4_26 12.320000000000002
C_0_4_26 Node0_4_26 GND 3.609375e-06
I_0_4_27 GND Node0_4_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_27_1 Node0_4_27 Node0_4_28 77.0
R_0_4_27_2 Node0_4_27 Node0_5_27 77.0
R_0_4_27_3 Node0_4_27 Node1_4_27 12.320000000000002
C_0_4_27 Node0_4_27 GND 3.609375e-06
I_0_4_28 GND Node0_4_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_28_1 Node0_4_28 Node0_4_29 77.0
R_0_4_28_2 Node0_4_28 Node0_5_28 77.0
R_0_4_28_3 Node0_4_28 Node1_4_28 12.320000000000002
C_0_4_28 Node0_4_28 GND 3.609375e-06
I_0_4_29 GND Node0_4_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_29_1 Node0_4_29 Node0_4_30 77.0
R_0_4_29_2 Node0_4_29 Node0_5_29 77.0
R_0_4_29_3 Node0_4_29 Node1_4_29 12.320000000000002
C_0_4_29 Node0_4_29 GND 3.609375e-06
I_0_4_30 GND Node0_4_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_30_1 Node0_4_30 Node0_4_31 77.0
R_0_4_30_2 Node0_4_30 Node0_5_30 77.0
R_0_4_30_3 Node0_4_30 Node1_4_30 12.320000000000002
C_0_4_30 Node0_4_30 GND 3.609375e-06
I_0_4_31 GND Node0_4_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_31_1 Node0_4_31 Node0_4_32 77.0
R_0_4_31_2 Node0_4_31 Node0_5_31 77.0
R_0_4_31_3 Node0_4_31 Node1_4_31 12.320000000000002
C_0_4_31 Node0_4_31 GND 3.609375e-06
I_0_4_32 GND Node0_4_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_32_1 Node0_4_32 Node0_4_33 77.0
R_0_4_32_2 Node0_4_32 Node0_5_32 77.0
R_0_4_32_3 Node0_4_32 Node1_4_32 12.320000000000002
C_0_4_32 Node0_4_32 GND 3.609375e-06
I_0_4_33 GND Node0_4_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_33_1 Node0_4_33 Node0_4_34 77.0
R_0_4_33_2 Node0_4_33 Node0_5_33 77.0
R_0_4_33_3 Node0_4_33 Node1_4_33 12.320000000000002
C_0_4_33 Node0_4_33 GND 3.609375e-06
I_0_4_34 GND Node0_4_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_34_1 Node0_4_34 Node0_4_35 77.0
R_0_4_34_2 Node0_4_34 Node0_5_34 77.0
R_0_4_34_3 Node0_4_34 Node1_4_34 12.320000000000002
C_0_4_34 Node0_4_34 GND 3.609375e-06
I_0_4_35 GND Node0_4_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_35_1 Node0_4_35 Node0_4_36 77.0
R_0_4_35_2 Node0_4_35 Node0_5_35 77.0
R_0_4_35_3 Node0_4_35 Node1_4_35 12.320000000000002
C_0_4_35 Node0_4_35 GND 3.609375e-06
I_0_4_36 GND Node0_4_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_36_1 Node0_4_36 Node0_4_37 77.0
R_0_4_36_2 Node0_4_36 Node0_5_36 77.0
R_0_4_36_3 Node0_4_36 Node1_4_36 12.320000000000002
C_0_4_36 Node0_4_36 GND 3.609375e-06
I_0_4_37 GND Node0_4_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_37_1 Node0_4_37 Node0_4_38 77.0
R_0_4_37_2 Node0_4_37 Node0_5_37 77.0
R_0_4_37_3 Node0_4_37 Node1_4_37 12.320000000000002
C_0_4_37 Node0_4_37 GND 3.609375e-06
I_0_4_38 GND Node0_4_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_38_1 Node0_4_38 Node0_4_39 77.0
R_0_4_38_2 Node0_4_38 Node0_5_38 77.0
R_0_4_38_3 Node0_4_38 Node1_4_38 12.320000000000002
C_0_4_38 Node0_4_38 GND 3.609375e-06
I_0_4_39 GND Node0_4_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_4_39_2 Node0_4_39 Node0_5_39 77.0
R_0_4_39_3 Node0_4_39 Node1_4_39 12.320000000000002
C_0_4_39 Node0_4_39 GND 3.609375e-06
I_0_5_0 GND Node0_5_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_0_1 Node0_5_0 Node0_5_1 77.0
R_0_5_0_2 Node0_5_0 Node0_6_0 77.0
R_0_5_0_3 Node0_5_0 Node1_5_0 12.320000000000002
C_0_5_0 Node0_5_0 GND 3.609375e-06
I_0_5_1 GND Node0_5_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_1_1 Node0_5_1 Node0_5_2 77.0
R_0_5_1_2 Node0_5_1 Node0_6_1 77.0
R_0_5_1_3 Node0_5_1 Node1_5_1 12.320000000000002
C_0_5_1 Node0_5_1 GND 3.609375e-06
I_0_5_2 GND Node0_5_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_2_1 Node0_5_2 Node0_5_3 77.0
R_0_5_2_2 Node0_5_2 Node0_6_2 77.0
R_0_5_2_3 Node0_5_2 Node1_5_2 12.320000000000002
C_0_5_2 Node0_5_2 GND 3.609375e-06
I_0_5_3 GND Node0_5_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_3_1 Node0_5_3 Node0_5_4 77.0
R_0_5_3_2 Node0_5_3 Node0_6_3 77.0
R_0_5_3_3 Node0_5_3 Node1_5_3 12.320000000000002
C_0_5_3 Node0_5_3 GND 3.609375e-06
I_0_5_4 GND Node0_5_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_4_1 Node0_5_4 Node0_5_5 77.0
R_0_5_4_2 Node0_5_4 Node0_6_4 77.0
R_0_5_4_3 Node0_5_4 Node1_5_4 12.320000000000002
C_0_5_4 Node0_5_4 GND 3.609375e-06
I_0_5_5 GND Node0_5_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_5_1 Node0_5_5 Node0_5_6 77.0
R_0_5_5_2 Node0_5_5 Node0_6_5 77.0
R_0_5_5_3 Node0_5_5 Node1_5_5 12.320000000000002
C_0_5_5 Node0_5_5 GND 3.609375e-06
I_0_5_6 GND Node0_5_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_6_1 Node0_5_6 Node0_5_7 77.0
R_0_5_6_2 Node0_5_6 Node0_6_6 77.0
R_0_5_6_3 Node0_5_6 Node1_5_6 12.320000000000002
C_0_5_6 Node0_5_6 GND 3.609375e-06
I_0_5_7 GND Node0_5_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_7_1 Node0_5_7 Node0_5_8 77.0
R_0_5_7_2 Node0_5_7 Node0_6_7 77.0
R_0_5_7_3 Node0_5_7 Node1_5_7 12.320000000000002
C_0_5_7 Node0_5_7 GND 3.609375e-06
I_0_5_8 GND Node0_5_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_8_1 Node0_5_8 Node0_5_9 77.0
R_0_5_8_2 Node0_5_8 Node0_6_8 77.0
R_0_5_8_3 Node0_5_8 Node1_5_8 12.320000000000002
C_0_5_8 Node0_5_8 GND 3.609375e-06
I_0_5_9 GND Node0_5_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_9_1 Node0_5_9 Node0_5_10 77.0
R_0_5_9_2 Node0_5_9 Node0_6_9 77.0
R_0_5_9_3 Node0_5_9 Node1_5_9 12.320000000000002
C_0_5_9 Node0_5_9 GND 3.609375e-06
I_0_5_10 GND Node0_5_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_10_1 Node0_5_10 Node0_5_11 77.0
R_0_5_10_2 Node0_5_10 Node0_6_10 77.0
R_0_5_10_3 Node0_5_10 Node1_5_10 12.320000000000002
C_0_5_10 Node0_5_10 GND 3.609375e-06
I_0_5_11 GND Node0_5_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_11_1 Node0_5_11 Node0_5_12 77.0
R_0_5_11_2 Node0_5_11 Node0_6_11 77.0
R_0_5_11_3 Node0_5_11 Node1_5_11 12.320000000000002
C_0_5_11 Node0_5_11 GND 3.609375e-06
I_0_5_12 GND Node0_5_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_12_1 Node0_5_12 Node0_5_13 77.0
R_0_5_12_2 Node0_5_12 Node0_6_12 77.0
R_0_5_12_3 Node0_5_12 Node1_5_12 12.320000000000002
C_0_5_12 Node0_5_12 GND 3.609375e-06
I_0_5_13 GND Node0_5_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_13_1 Node0_5_13 Node0_5_14 77.0
R_0_5_13_2 Node0_5_13 Node0_6_13 77.0
R_0_5_13_3 Node0_5_13 Node1_5_13 12.320000000000002
C_0_5_13 Node0_5_13 GND 3.609375e-06
I_0_5_14 GND Node0_5_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_14_1 Node0_5_14 Node0_5_15 77.0
R_0_5_14_2 Node0_5_14 Node0_6_14 77.0
R_0_5_14_3 Node0_5_14 Node1_5_14 12.320000000000002
C_0_5_14 Node0_5_14 GND 3.609375e-06
I_0_5_15 GND Node0_5_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_15_1 Node0_5_15 Node0_5_16 77.0
R_0_5_15_2 Node0_5_15 Node0_6_15 77.0
R_0_5_15_3 Node0_5_15 Node1_5_15 12.320000000000002
C_0_5_15 Node0_5_15 GND 3.609375e-06
I_0_5_16 GND Node0_5_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_16_1 Node0_5_16 Node0_5_17 77.0
R_0_5_16_2 Node0_5_16 Node0_6_16 77.0
R_0_5_16_3 Node0_5_16 Node1_5_16 12.320000000000002
C_0_5_16 Node0_5_16 GND 3.609375e-06
I_0_5_17 GND Node0_5_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_17_1 Node0_5_17 Node0_5_18 77.0
R_0_5_17_2 Node0_5_17 Node0_6_17 77.0
R_0_5_17_3 Node0_5_17 Node1_5_17 12.320000000000002
C_0_5_17 Node0_5_17 GND 3.609375e-06
I_0_5_18 GND Node0_5_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_18_1 Node0_5_18 Node0_5_19 77.0
R_0_5_18_2 Node0_5_18 Node0_6_18 77.0
R_0_5_18_3 Node0_5_18 Node1_5_18 12.320000000000002
C_0_5_18 Node0_5_18 GND 3.609375e-06
I_0_5_19 GND Node0_5_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_19_1 Node0_5_19 Node0_5_20 77.0
R_0_5_19_2 Node0_5_19 Node0_6_19 77.0
R_0_5_19_3 Node0_5_19 Node1_5_19 12.320000000000002
C_0_5_19 Node0_5_19 GND 3.609375e-06
I_0_5_20 GND Node0_5_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_20_1 Node0_5_20 Node0_5_21 77.0
R_0_5_20_2 Node0_5_20 Node0_6_20 77.0
R_0_5_20_3 Node0_5_20 Node1_5_20 12.320000000000002
C_0_5_20 Node0_5_20 GND 3.609375e-06
I_0_5_21 GND Node0_5_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_21_1 Node0_5_21 Node0_5_22 77.0
R_0_5_21_2 Node0_5_21 Node0_6_21 77.0
R_0_5_21_3 Node0_5_21 Node1_5_21 12.320000000000002
C_0_5_21 Node0_5_21 GND 3.609375e-06
I_0_5_22 GND Node0_5_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_22_1 Node0_5_22 Node0_5_23 77.0
R_0_5_22_2 Node0_5_22 Node0_6_22 77.0
R_0_5_22_3 Node0_5_22 Node1_5_22 12.320000000000002
C_0_5_22 Node0_5_22 GND 3.609375e-06
I_0_5_23 GND Node0_5_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_23_1 Node0_5_23 Node0_5_24 77.0
R_0_5_23_2 Node0_5_23 Node0_6_23 77.0
R_0_5_23_3 Node0_5_23 Node1_5_23 12.320000000000002
C_0_5_23 Node0_5_23 GND 3.609375e-06
I_0_5_24 GND Node0_5_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_24_1 Node0_5_24 Node0_5_25 77.0
R_0_5_24_2 Node0_5_24 Node0_6_24 77.0
R_0_5_24_3 Node0_5_24 Node1_5_24 12.320000000000002
C_0_5_24 Node0_5_24 GND 3.609375e-06
I_0_5_25 GND Node0_5_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_25_1 Node0_5_25 Node0_5_26 77.0
R_0_5_25_2 Node0_5_25 Node0_6_25 77.0
R_0_5_25_3 Node0_5_25 Node1_5_25 12.320000000000002
C_0_5_25 Node0_5_25 GND 3.609375e-06
I_0_5_26 GND Node0_5_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_26_1 Node0_5_26 Node0_5_27 77.0
R_0_5_26_2 Node0_5_26 Node0_6_26 77.0
R_0_5_26_3 Node0_5_26 Node1_5_26 12.320000000000002
C_0_5_26 Node0_5_26 GND 3.609375e-06
I_0_5_27 GND Node0_5_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_27_1 Node0_5_27 Node0_5_28 77.0
R_0_5_27_2 Node0_5_27 Node0_6_27 77.0
R_0_5_27_3 Node0_5_27 Node1_5_27 12.320000000000002
C_0_5_27 Node0_5_27 GND 3.609375e-06
I_0_5_28 GND Node0_5_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_28_1 Node0_5_28 Node0_5_29 77.0
R_0_5_28_2 Node0_5_28 Node0_6_28 77.0
R_0_5_28_3 Node0_5_28 Node1_5_28 12.320000000000002
C_0_5_28 Node0_5_28 GND 3.609375e-06
I_0_5_29 GND Node0_5_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_29_1 Node0_5_29 Node0_5_30 77.0
R_0_5_29_2 Node0_5_29 Node0_6_29 77.0
R_0_5_29_3 Node0_5_29 Node1_5_29 12.320000000000002
C_0_5_29 Node0_5_29 GND 3.609375e-06
I_0_5_30 GND Node0_5_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_30_1 Node0_5_30 Node0_5_31 77.0
R_0_5_30_2 Node0_5_30 Node0_6_30 77.0
R_0_5_30_3 Node0_5_30 Node1_5_30 12.320000000000002
C_0_5_30 Node0_5_30 GND 3.609375e-06
I_0_5_31 GND Node0_5_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_31_1 Node0_5_31 Node0_5_32 77.0
R_0_5_31_2 Node0_5_31 Node0_6_31 77.0
R_0_5_31_3 Node0_5_31 Node1_5_31 12.320000000000002
C_0_5_31 Node0_5_31 GND 3.609375e-06
I_0_5_32 GND Node0_5_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_32_1 Node0_5_32 Node0_5_33 77.0
R_0_5_32_2 Node0_5_32 Node0_6_32 77.0
R_0_5_32_3 Node0_5_32 Node1_5_32 12.320000000000002
C_0_5_32 Node0_5_32 GND 3.609375e-06
I_0_5_33 GND Node0_5_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_33_1 Node0_5_33 Node0_5_34 77.0
R_0_5_33_2 Node0_5_33 Node0_6_33 77.0
R_0_5_33_3 Node0_5_33 Node1_5_33 12.320000000000002
C_0_5_33 Node0_5_33 GND 3.609375e-06
I_0_5_34 GND Node0_5_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_34_1 Node0_5_34 Node0_5_35 77.0
R_0_5_34_2 Node0_5_34 Node0_6_34 77.0
R_0_5_34_3 Node0_5_34 Node1_5_34 12.320000000000002
C_0_5_34 Node0_5_34 GND 3.609375e-06
I_0_5_35 GND Node0_5_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_35_1 Node0_5_35 Node0_5_36 77.0
R_0_5_35_2 Node0_5_35 Node0_6_35 77.0
R_0_5_35_3 Node0_5_35 Node1_5_35 12.320000000000002
C_0_5_35 Node0_5_35 GND 3.609375e-06
I_0_5_36 GND Node0_5_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_36_1 Node0_5_36 Node0_5_37 77.0
R_0_5_36_2 Node0_5_36 Node0_6_36 77.0
R_0_5_36_3 Node0_5_36 Node1_5_36 12.320000000000002
C_0_5_36 Node0_5_36 GND 3.609375e-06
I_0_5_37 GND Node0_5_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_37_1 Node0_5_37 Node0_5_38 77.0
R_0_5_37_2 Node0_5_37 Node0_6_37 77.0
R_0_5_37_3 Node0_5_37 Node1_5_37 12.320000000000002
C_0_5_37 Node0_5_37 GND 3.609375e-06
I_0_5_38 GND Node0_5_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_38_1 Node0_5_38 Node0_5_39 77.0
R_0_5_38_2 Node0_5_38 Node0_6_38 77.0
R_0_5_38_3 Node0_5_38 Node1_5_38 12.320000000000002
C_0_5_38 Node0_5_38 GND 3.609375e-06
I_0_5_39 GND Node0_5_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_5_39_2 Node0_5_39 Node0_6_39 77.0
R_0_5_39_3 Node0_5_39 Node1_5_39 12.320000000000002
C_0_5_39 Node0_5_39 GND 3.609375e-06
I_0_6_0 GND Node0_6_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_0_1 Node0_6_0 Node0_6_1 77.0
R_0_6_0_2 Node0_6_0 Node0_7_0 77.0
R_0_6_0_3 Node0_6_0 Node1_6_0 12.320000000000002
C_0_6_0 Node0_6_0 GND 3.609375e-06
I_0_6_1 GND Node0_6_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_1_1 Node0_6_1 Node0_6_2 77.0
R_0_6_1_2 Node0_6_1 Node0_7_1 77.0
R_0_6_1_3 Node0_6_1 Node1_6_1 12.320000000000002
C_0_6_1 Node0_6_1 GND 3.609375e-06
I_0_6_2 GND Node0_6_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_2_1 Node0_6_2 Node0_6_3 77.0
R_0_6_2_2 Node0_6_2 Node0_7_2 77.0
R_0_6_2_3 Node0_6_2 Node1_6_2 12.320000000000002
C_0_6_2 Node0_6_2 GND 3.609375e-06
I_0_6_3 GND Node0_6_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_3_1 Node0_6_3 Node0_6_4 77.0
R_0_6_3_2 Node0_6_3 Node0_7_3 77.0
R_0_6_3_3 Node0_6_3 Node1_6_3 12.320000000000002
C_0_6_3 Node0_6_3 GND 3.609375e-06
I_0_6_4 GND Node0_6_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_4_1 Node0_6_4 Node0_6_5 77.0
R_0_6_4_2 Node0_6_4 Node0_7_4 77.0
R_0_6_4_3 Node0_6_4 Node1_6_4 12.320000000000002
C_0_6_4 Node0_6_4 GND 3.609375e-06
I_0_6_5 GND Node0_6_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_5_1 Node0_6_5 Node0_6_6 77.0
R_0_6_5_2 Node0_6_5 Node0_7_5 77.0
R_0_6_5_3 Node0_6_5 Node1_6_5 12.320000000000002
C_0_6_5 Node0_6_5 GND 3.609375e-06
I_0_6_6 GND Node0_6_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_6_1 Node0_6_6 Node0_6_7 77.0
R_0_6_6_2 Node0_6_6 Node0_7_6 77.0
R_0_6_6_3 Node0_6_6 Node1_6_6 12.320000000000002
C_0_6_6 Node0_6_6 GND 3.609375e-06
I_0_6_7 GND Node0_6_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_7_1 Node0_6_7 Node0_6_8 77.0
R_0_6_7_2 Node0_6_7 Node0_7_7 77.0
R_0_6_7_3 Node0_6_7 Node1_6_7 12.320000000000002
C_0_6_7 Node0_6_7 GND 3.609375e-06
I_0_6_8 GND Node0_6_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_8_1 Node0_6_8 Node0_6_9 77.0
R_0_6_8_2 Node0_6_8 Node0_7_8 77.0
R_0_6_8_3 Node0_6_8 Node1_6_8 12.320000000000002
C_0_6_8 Node0_6_8 GND 3.609375e-06
I_0_6_9 GND Node0_6_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_9_1 Node0_6_9 Node0_6_10 77.0
R_0_6_9_2 Node0_6_9 Node0_7_9 77.0
R_0_6_9_3 Node0_6_9 Node1_6_9 12.320000000000002
C_0_6_9 Node0_6_9 GND 3.609375e-06
I_0_6_10 GND Node0_6_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_10_1 Node0_6_10 Node0_6_11 77.0
R_0_6_10_2 Node0_6_10 Node0_7_10 77.0
R_0_6_10_3 Node0_6_10 Node1_6_10 12.320000000000002
C_0_6_10 Node0_6_10 GND 3.609375e-06
I_0_6_11 GND Node0_6_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_11_1 Node0_6_11 Node0_6_12 77.0
R_0_6_11_2 Node0_6_11 Node0_7_11 77.0
R_0_6_11_3 Node0_6_11 Node1_6_11 12.320000000000002
C_0_6_11 Node0_6_11 GND 3.609375e-06
I_0_6_12 GND Node0_6_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_12_1 Node0_6_12 Node0_6_13 77.0
R_0_6_12_2 Node0_6_12 Node0_7_12 77.0
R_0_6_12_3 Node0_6_12 Node1_6_12 12.320000000000002
C_0_6_12 Node0_6_12 GND 3.609375e-06
I_0_6_13 GND Node0_6_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_13_1 Node0_6_13 Node0_6_14 77.0
R_0_6_13_2 Node0_6_13 Node0_7_13 77.0
R_0_6_13_3 Node0_6_13 Node1_6_13 12.320000000000002
C_0_6_13 Node0_6_13 GND 3.609375e-06
I_0_6_14 GND Node0_6_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_14_1 Node0_6_14 Node0_6_15 77.0
R_0_6_14_2 Node0_6_14 Node0_7_14 77.0
R_0_6_14_3 Node0_6_14 Node1_6_14 12.320000000000002
C_0_6_14 Node0_6_14 GND 3.609375e-06
I_0_6_15 GND Node0_6_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_15_1 Node0_6_15 Node0_6_16 77.0
R_0_6_15_2 Node0_6_15 Node0_7_15 77.0
R_0_6_15_3 Node0_6_15 Node1_6_15 12.320000000000002
C_0_6_15 Node0_6_15 GND 3.609375e-06
I_0_6_16 GND Node0_6_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_16_1 Node0_6_16 Node0_6_17 77.0
R_0_6_16_2 Node0_6_16 Node0_7_16 77.0
R_0_6_16_3 Node0_6_16 Node1_6_16 12.320000000000002
C_0_6_16 Node0_6_16 GND 3.609375e-06
I_0_6_17 GND Node0_6_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_17_1 Node0_6_17 Node0_6_18 77.0
R_0_6_17_2 Node0_6_17 Node0_7_17 77.0
R_0_6_17_3 Node0_6_17 Node1_6_17 12.320000000000002
C_0_6_17 Node0_6_17 GND 3.609375e-06
I_0_6_18 GND Node0_6_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_18_1 Node0_6_18 Node0_6_19 77.0
R_0_6_18_2 Node0_6_18 Node0_7_18 77.0
R_0_6_18_3 Node0_6_18 Node1_6_18 12.320000000000002
C_0_6_18 Node0_6_18 GND 3.609375e-06
I_0_6_19 GND Node0_6_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_19_1 Node0_6_19 Node0_6_20 77.0
R_0_6_19_2 Node0_6_19 Node0_7_19 77.0
R_0_6_19_3 Node0_6_19 Node1_6_19 12.320000000000002
C_0_6_19 Node0_6_19 GND 3.609375e-06
I_0_6_20 GND Node0_6_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_20_1 Node0_6_20 Node0_6_21 77.0
R_0_6_20_2 Node0_6_20 Node0_7_20 77.0
R_0_6_20_3 Node0_6_20 Node1_6_20 12.320000000000002
C_0_6_20 Node0_6_20 GND 3.609375e-06
I_0_6_21 GND Node0_6_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_21_1 Node0_6_21 Node0_6_22 77.0
R_0_6_21_2 Node0_6_21 Node0_7_21 77.0
R_0_6_21_3 Node0_6_21 Node1_6_21 12.320000000000002
C_0_6_21 Node0_6_21 GND 3.609375e-06
I_0_6_22 GND Node0_6_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_22_1 Node0_6_22 Node0_6_23 77.0
R_0_6_22_2 Node0_6_22 Node0_7_22 77.0
R_0_6_22_3 Node0_6_22 Node1_6_22 12.320000000000002
C_0_6_22 Node0_6_22 GND 3.609375e-06
I_0_6_23 GND Node0_6_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_23_1 Node0_6_23 Node0_6_24 77.0
R_0_6_23_2 Node0_6_23 Node0_7_23 77.0
R_0_6_23_3 Node0_6_23 Node1_6_23 12.320000000000002
C_0_6_23 Node0_6_23 GND 3.609375e-06
I_0_6_24 GND Node0_6_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_24_1 Node0_6_24 Node0_6_25 77.0
R_0_6_24_2 Node0_6_24 Node0_7_24 77.0
R_0_6_24_3 Node0_6_24 Node1_6_24 12.320000000000002
C_0_6_24 Node0_6_24 GND 3.609375e-06
I_0_6_25 GND Node0_6_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_25_1 Node0_6_25 Node0_6_26 77.0
R_0_6_25_2 Node0_6_25 Node0_7_25 77.0
R_0_6_25_3 Node0_6_25 Node1_6_25 12.320000000000002
C_0_6_25 Node0_6_25 GND 3.609375e-06
I_0_6_26 GND Node0_6_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_26_1 Node0_6_26 Node0_6_27 77.0
R_0_6_26_2 Node0_6_26 Node0_7_26 77.0
R_0_6_26_3 Node0_6_26 Node1_6_26 12.320000000000002
C_0_6_26 Node0_6_26 GND 3.609375e-06
I_0_6_27 GND Node0_6_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_27_1 Node0_6_27 Node0_6_28 77.0
R_0_6_27_2 Node0_6_27 Node0_7_27 77.0
R_0_6_27_3 Node0_6_27 Node1_6_27 12.320000000000002
C_0_6_27 Node0_6_27 GND 3.609375e-06
I_0_6_28 GND Node0_6_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_28_1 Node0_6_28 Node0_6_29 77.0
R_0_6_28_2 Node0_6_28 Node0_7_28 77.0
R_0_6_28_3 Node0_6_28 Node1_6_28 12.320000000000002
C_0_6_28 Node0_6_28 GND 3.609375e-06
I_0_6_29 GND Node0_6_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_29_1 Node0_6_29 Node0_6_30 77.0
R_0_6_29_2 Node0_6_29 Node0_7_29 77.0
R_0_6_29_3 Node0_6_29 Node1_6_29 12.320000000000002
C_0_6_29 Node0_6_29 GND 3.609375e-06
I_0_6_30 GND Node0_6_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_30_1 Node0_6_30 Node0_6_31 77.0
R_0_6_30_2 Node0_6_30 Node0_7_30 77.0
R_0_6_30_3 Node0_6_30 Node1_6_30 12.320000000000002
C_0_6_30 Node0_6_30 GND 3.609375e-06
I_0_6_31 GND Node0_6_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_31_1 Node0_6_31 Node0_6_32 77.0
R_0_6_31_2 Node0_6_31 Node0_7_31 77.0
R_0_6_31_3 Node0_6_31 Node1_6_31 12.320000000000002
C_0_6_31 Node0_6_31 GND 3.609375e-06
I_0_6_32 GND Node0_6_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_32_1 Node0_6_32 Node0_6_33 77.0
R_0_6_32_2 Node0_6_32 Node0_7_32 77.0
R_0_6_32_3 Node0_6_32 Node1_6_32 12.320000000000002
C_0_6_32 Node0_6_32 GND 3.609375e-06
I_0_6_33 GND Node0_6_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_33_1 Node0_6_33 Node0_6_34 77.0
R_0_6_33_2 Node0_6_33 Node0_7_33 77.0
R_0_6_33_3 Node0_6_33 Node1_6_33 12.320000000000002
C_0_6_33 Node0_6_33 GND 3.609375e-06
I_0_6_34 GND Node0_6_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_34_1 Node0_6_34 Node0_6_35 77.0
R_0_6_34_2 Node0_6_34 Node0_7_34 77.0
R_0_6_34_3 Node0_6_34 Node1_6_34 12.320000000000002
C_0_6_34 Node0_6_34 GND 3.609375e-06
I_0_6_35 GND Node0_6_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_35_1 Node0_6_35 Node0_6_36 77.0
R_0_6_35_2 Node0_6_35 Node0_7_35 77.0
R_0_6_35_3 Node0_6_35 Node1_6_35 12.320000000000002
C_0_6_35 Node0_6_35 GND 3.609375e-06
I_0_6_36 GND Node0_6_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_36_1 Node0_6_36 Node0_6_37 77.0
R_0_6_36_2 Node0_6_36 Node0_7_36 77.0
R_0_6_36_3 Node0_6_36 Node1_6_36 12.320000000000002
C_0_6_36 Node0_6_36 GND 3.609375e-06
I_0_6_37 GND Node0_6_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_37_1 Node0_6_37 Node0_6_38 77.0
R_0_6_37_2 Node0_6_37 Node0_7_37 77.0
R_0_6_37_3 Node0_6_37 Node1_6_37 12.320000000000002
C_0_6_37 Node0_6_37 GND 3.609375e-06
I_0_6_38 GND Node0_6_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_38_1 Node0_6_38 Node0_6_39 77.0
R_0_6_38_2 Node0_6_38 Node0_7_38 77.0
R_0_6_38_3 Node0_6_38 Node1_6_38 12.320000000000002
C_0_6_38 Node0_6_38 GND 3.609375e-06
I_0_6_39 GND Node0_6_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_6_39_2 Node0_6_39 Node0_7_39 77.0
R_0_6_39_3 Node0_6_39 Node1_6_39 12.320000000000002
C_0_6_39 Node0_6_39 GND 3.609375e-06
I_0_7_0 GND Node0_7_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_0_1 Node0_7_0 Node0_7_1 77.0
R_0_7_0_2 Node0_7_0 Node0_8_0 77.0
R_0_7_0_3 Node0_7_0 Node1_7_0 12.320000000000002
C_0_7_0 Node0_7_0 GND 3.609375e-06
I_0_7_1 GND Node0_7_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_1_1 Node0_7_1 Node0_7_2 77.0
R_0_7_1_2 Node0_7_1 Node0_8_1 77.0
R_0_7_1_3 Node0_7_1 Node1_7_1 12.320000000000002
C_0_7_1 Node0_7_1 GND 3.609375e-06
I_0_7_2 GND Node0_7_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_2_1 Node0_7_2 Node0_7_3 77.0
R_0_7_2_2 Node0_7_2 Node0_8_2 77.0
R_0_7_2_3 Node0_7_2 Node1_7_2 12.320000000000002
C_0_7_2 Node0_7_2 GND 3.609375e-06
I_0_7_3 GND Node0_7_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_3_1 Node0_7_3 Node0_7_4 77.0
R_0_7_3_2 Node0_7_3 Node0_8_3 77.0
R_0_7_3_3 Node0_7_3 Node1_7_3 12.320000000000002
C_0_7_3 Node0_7_3 GND 3.609375e-06
I_0_7_4 GND Node0_7_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_4_1 Node0_7_4 Node0_7_5 77.0
R_0_7_4_2 Node0_7_4 Node0_8_4 77.0
R_0_7_4_3 Node0_7_4 Node1_7_4 12.320000000000002
C_0_7_4 Node0_7_4 GND 3.609375e-06
I_0_7_5 GND Node0_7_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_5_1 Node0_7_5 Node0_7_6 77.0
R_0_7_5_2 Node0_7_5 Node0_8_5 77.0
R_0_7_5_3 Node0_7_5 Node1_7_5 12.320000000000002
C_0_7_5 Node0_7_5 GND 3.609375e-06
I_0_7_6 GND Node0_7_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_6_1 Node0_7_6 Node0_7_7 77.0
R_0_7_6_2 Node0_7_6 Node0_8_6 77.0
R_0_7_6_3 Node0_7_6 Node1_7_6 12.320000000000002
C_0_7_6 Node0_7_6 GND 3.609375e-06
I_0_7_7 GND Node0_7_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_7_1 Node0_7_7 Node0_7_8 77.0
R_0_7_7_2 Node0_7_7 Node0_8_7 77.0
R_0_7_7_3 Node0_7_7 Node1_7_7 12.320000000000002
C_0_7_7 Node0_7_7 GND 3.609375e-06
I_0_7_8 GND Node0_7_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_8_1 Node0_7_8 Node0_7_9 77.0
R_0_7_8_2 Node0_7_8 Node0_8_8 77.0
R_0_7_8_3 Node0_7_8 Node1_7_8 12.320000000000002
C_0_7_8 Node0_7_8 GND 3.609375e-06
I_0_7_9 GND Node0_7_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_9_1 Node0_7_9 Node0_7_10 77.0
R_0_7_9_2 Node0_7_9 Node0_8_9 77.0
R_0_7_9_3 Node0_7_9 Node1_7_9 12.320000000000002
C_0_7_9 Node0_7_9 GND 3.609375e-06
I_0_7_10 GND Node0_7_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_10_1 Node0_7_10 Node0_7_11 77.0
R_0_7_10_2 Node0_7_10 Node0_8_10 77.0
R_0_7_10_3 Node0_7_10 Node1_7_10 12.320000000000002
C_0_7_10 Node0_7_10 GND 3.609375e-06
I_0_7_11 GND Node0_7_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_11_1 Node0_7_11 Node0_7_12 77.0
R_0_7_11_2 Node0_7_11 Node0_8_11 77.0
R_0_7_11_3 Node0_7_11 Node1_7_11 12.320000000000002
C_0_7_11 Node0_7_11 GND 3.609375e-06
I_0_7_12 GND Node0_7_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_12_1 Node0_7_12 Node0_7_13 77.0
R_0_7_12_2 Node0_7_12 Node0_8_12 77.0
R_0_7_12_3 Node0_7_12 Node1_7_12 12.320000000000002
C_0_7_12 Node0_7_12 GND 3.609375e-06
I_0_7_13 GND Node0_7_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_13_1 Node0_7_13 Node0_7_14 77.0
R_0_7_13_2 Node0_7_13 Node0_8_13 77.0
R_0_7_13_3 Node0_7_13 Node1_7_13 12.320000000000002
C_0_7_13 Node0_7_13 GND 3.609375e-06
I_0_7_14 GND Node0_7_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_14_1 Node0_7_14 Node0_7_15 77.0
R_0_7_14_2 Node0_7_14 Node0_8_14 77.0
R_0_7_14_3 Node0_7_14 Node1_7_14 12.320000000000002
C_0_7_14 Node0_7_14 GND 3.609375e-06
I_0_7_15 GND Node0_7_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_15_1 Node0_7_15 Node0_7_16 77.0
R_0_7_15_2 Node0_7_15 Node0_8_15 77.0
R_0_7_15_3 Node0_7_15 Node1_7_15 12.320000000000002
C_0_7_15 Node0_7_15 GND 3.609375e-06
I_0_7_16 GND Node0_7_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_16_1 Node0_7_16 Node0_7_17 77.0
R_0_7_16_2 Node0_7_16 Node0_8_16 77.0
R_0_7_16_3 Node0_7_16 Node1_7_16 12.320000000000002
C_0_7_16 Node0_7_16 GND 3.609375e-06
I_0_7_17 GND Node0_7_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_17_1 Node0_7_17 Node0_7_18 77.0
R_0_7_17_2 Node0_7_17 Node0_8_17 77.0
R_0_7_17_3 Node0_7_17 Node1_7_17 12.320000000000002
C_0_7_17 Node0_7_17 GND 3.609375e-06
I_0_7_18 GND Node0_7_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_18_1 Node0_7_18 Node0_7_19 77.0
R_0_7_18_2 Node0_7_18 Node0_8_18 77.0
R_0_7_18_3 Node0_7_18 Node1_7_18 12.320000000000002
C_0_7_18 Node0_7_18 GND 3.609375e-06
I_0_7_19 GND Node0_7_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_19_1 Node0_7_19 Node0_7_20 77.0
R_0_7_19_2 Node0_7_19 Node0_8_19 77.0
R_0_7_19_3 Node0_7_19 Node1_7_19 12.320000000000002
C_0_7_19 Node0_7_19 GND 3.609375e-06
I_0_7_20 GND Node0_7_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_20_1 Node0_7_20 Node0_7_21 77.0
R_0_7_20_2 Node0_7_20 Node0_8_20 77.0
R_0_7_20_3 Node0_7_20 Node1_7_20 12.320000000000002
C_0_7_20 Node0_7_20 GND 3.609375e-06
I_0_7_21 GND Node0_7_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_21_1 Node0_7_21 Node0_7_22 77.0
R_0_7_21_2 Node0_7_21 Node0_8_21 77.0
R_0_7_21_3 Node0_7_21 Node1_7_21 12.320000000000002
C_0_7_21 Node0_7_21 GND 3.609375e-06
I_0_7_22 GND Node0_7_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_22_1 Node0_7_22 Node0_7_23 77.0
R_0_7_22_2 Node0_7_22 Node0_8_22 77.0
R_0_7_22_3 Node0_7_22 Node1_7_22 12.320000000000002
C_0_7_22 Node0_7_22 GND 3.609375e-06
I_0_7_23 GND Node0_7_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_23_1 Node0_7_23 Node0_7_24 77.0
R_0_7_23_2 Node0_7_23 Node0_8_23 77.0
R_0_7_23_3 Node0_7_23 Node1_7_23 12.320000000000002
C_0_7_23 Node0_7_23 GND 3.609375e-06
I_0_7_24 GND Node0_7_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_24_1 Node0_7_24 Node0_7_25 77.0
R_0_7_24_2 Node0_7_24 Node0_8_24 77.0
R_0_7_24_3 Node0_7_24 Node1_7_24 12.320000000000002
C_0_7_24 Node0_7_24 GND 3.609375e-06
I_0_7_25 GND Node0_7_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_25_1 Node0_7_25 Node0_7_26 77.0
R_0_7_25_2 Node0_7_25 Node0_8_25 77.0
R_0_7_25_3 Node0_7_25 Node1_7_25 12.320000000000002
C_0_7_25 Node0_7_25 GND 3.609375e-06
I_0_7_26 GND Node0_7_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_26_1 Node0_7_26 Node0_7_27 77.0
R_0_7_26_2 Node0_7_26 Node0_8_26 77.0
R_0_7_26_3 Node0_7_26 Node1_7_26 12.320000000000002
C_0_7_26 Node0_7_26 GND 3.609375e-06
I_0_7_27 GND Node0_7_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_27_1 Node0_7_27 Node0_7_28 77.0
R_0_7_27_2 Node0_7_27 Node0_8_27 77.0
R_0_7_27_3 Node0_7_27 Node1_7_27 12.320000000000002
C_0_7_27 Node0_7_27 GND 3.609375e-06
I_0_7_28 GND Node0_7_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_28_1 Node0_7_28 Node0_7_29 77.0
R_0_7_28_2 Node0_7_28 Node0_8_28 77.0
R_0_7_28_3 Node0_7_28 Node1_7_28 12.320000000000002
C_0_7_28 Node0_7_28 GND 3.609375e-06
I_0_7_29 GND Node0_7_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_29_1 Node0_7_29 Node0_7_30 77.0
R_0_7_29_2 Node0_7_29 Node0_8_29 77.0
R_0_7_29_3 Node0_7_29 Node1_7_29 12.320000000000002
C_0_7_29 Node0_7_29 GND 3.609375e-06
I_0_7_30 GND Node0_7_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_30_1 Node0_7_30 Node0_7_31 77.0
R_0_7_30_2 Node0_7_30 Node0_8_30 77.0
R_0_7_30_3 Node0_7_30 Node1_7_30 12.320000000000002
C_0_7_30 Node0_7_30 GND 3.609375e-06
I_0_7_31 GND Node0_7_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_31_1 Node0_7_31 Node0_7_32 77.0
R_0_7_31_2 Node0_7_31 Node0_8_31 77.0
R_0_7_31_3 Node0_7_31 Node1_7_31 12.320000000000002
C_0_7_31 Node0_7_31 GND 3.609375e-06
I_0_7_32 GND Node0_7_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_32_1 Node0_7_32 Node0_7_33 77.0
R_0_7_32_2 Node0_7_32 Node0_8_32 77.0
R_0_7_32_3 Node0_7_32 Node1_7_32 12.320000000000002
C_0_7_32 Node0_7_32 GND 3.609375e-06
I_0_7_33 GND Node0_7_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_33_1 Node0_7_33 Node0_7_34 77.0
R_0_7_33_2 Node0_7_33 Node0_8_33 77.0
R_0_7_33_3 Node0_7_33 Node1_7_33 12.320000000000002
C_0_7_33 Node0_7_33 GND 3.609375e-06
I_0_7_34 GND Node0_7_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_34_1 Node0_7_34 Node0_7_35 77.0
R_0_7_34_2 Node0_7_34 Node0_8_34 77.0
R_0_7_34_3 Node0_7_34 Node1_7_34 12.320000000000002
C_0_7_34 Node0_7_34 GND 3.609375e-06
I_0_7_35 GND Node0_7_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_35_1 Node0_7_35 Node0_7_36 77.0
R_0_7_35_2 Node0_7_35 Node0_8_35 77.0
R_0_7_35_3 Node0_7_35 Node1_7_35 12.320000000000002
C_0_7_35 Node0_7_35 GND 3.609375e-06
I_0_7_36 GND Node0_7_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_36_1 Node0_7_36 Node0_7_37 77.0
R_0_7_36_2 Node0_7_36 Node0_8_36 77.0
R_0_7_36_3 Node0_7_36 Node1_7_36 12.320000000000002
C_0_7_36 Node0_7_36 GND 3.609375e-06
I_0_7_37 GND Node0_7_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_37_1 Node0_7_37 Node0_7_38 77.0
R_0_7_37_2 Node0_7_37 Node0_8_37 77.0
R_0_7_37_3 Node0_7_37 Node1_7_37 12.320000000000002
C_0_7_37 Node0_7_37 GND 3.609375e-06
I_0_7_38 GND Node0_7_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_38_1 Node0_7_38 Node0_7_39 77.0
R_0_7_38_2 Node0_7_38 Node0_8_38 77.0
R_0_7_38_3 Node0_7_38 Node1_7_38 12.320000000000002
C_0_7_38 Node0_7_38 GND 3.609375e-06
I_0_7_39 GND Node0_7_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_7_39_2 Node0_7_39 Node0_8_39 77.0
R_0_7_39_3 Node0_7_39 Node1_7_39 12.320000000000002
C_0_7_39 Node0_7_39 GND 3.609375e-06
I_0_8_0 GND Node0_8_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_0_1 Node0_8_0 Node0_8_1 77.0
R_0_8_0_2 Node0_8_0 Node0_9_0 77.0
R_0_8_0_3 Node0_8_0 Node1_8_0 12.320000000000002
C_0_8_0 Node0_8_0 GND 3.609375e-06
I_0_8_1 GND Node0_8_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_1_1 Node0_8_1 Node0_8_2 77.0
R_0_8_1_2 Node0_8_1 Node0_9_1 77.0
R_0_8_1_3 Node0_8_1 Node1_8_1 12.320000000000002
C_0_8_1 Node0_8_1 GND 3.609375e-06
I_0_8_2 GND Node0_8_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_2_1 Node0_8_2 Node0_8_3 77.0
R_0_8_2_2 Node0_8_2 Node0_9_2 77.0
R_0_8_2_3 Node0_8_2 Node1_8_2 12.320000000000002
C_0_8_2 Node0_8_2 GND 3.609375e-06
I_0_8_3 GND Node0_8_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_3_1 Node0_8_3 Node0_8_4 77.0
R_0_8_3_2 Node0_8_3 Node0_9_3 77.0
R_0_8_3_3 Node0_8_3 Node1_8_3 12.320000000000002
C_0_8_3 Node0_8_3 GND 3.609375e-06
I_0_8_4 GND Node0_8_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_4_1 Node0_8_4 Node0_8_5 77.0
R_0_8_4_2 Node0_8_4 Node0_9_4 77.0
R_0_8_4_3 Node0_8_4 Node1_8_4 12.320000000000002
C_0_8_4 Node0_8_4 GND 3.609375e-06
I_0_8_5 GND Node0_8_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_5_1 Node0_8_5 Node0_8_6 77.0
R_0_8_5_2 Node0_8_5 Node0_9_5 77.0
R_0_8_5_3 Node0_8_5 Node1_8_5 12.320000000000002
C_0_8_5 Node0_8_5 GND 3.609375e-06
I_0_8_6 GND Node0_8_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_6_1 Node0_8_6 Node0_8_7 77.0
R_0_8_6_2 Node0_8_6 Node0_9_6 77.0
R_0_8_6_3 Node0_8_6 Node1_8_6 12.320000000000002
C_0_8_6 Node0_8_6 GND 3.609375e-06
I_0_8_7 GND Node0_8_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_7_1 Node0_8_7 Node0_8_8 77.0
R_0_8_7_2 Node0_8_7 Node0_9_7 77.0
R_0_8_7_3 Node0_8_7 Node1_8_7 12.320000000000002
C_0_8_7 Node0_8_7 GND 3.609375e-06
I_0_8_8 GND Node0_8_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_8_1 Node0_8_8 Node0_8_9 77.0
R_0_8_8_2 Node0_8_8 Node0_9_8 77.0
R_0_8_8_3 Node0_8_8 Node1_8_8 12.320000000000002
C_0_8_8 Node0_8_8 GND 3.609375e-06
I_0_8_9 GND Node0_8_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_9_1 Node0_8_9 Node0_8_10 77.0
R_0_8_9_2 Node0_8_9 Node0_9_9 77.0
R_0_8_9_3 Node0_8_9 Node1_8_9 12.320000000000002
C_0_8_9 Node0_8_9 GND 3.609375e-06
I_0_8_10 GND Node0_8_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_10_1 Node0_8_10 Node0_8_11 77.0
R_0_8_10_2 Node0_8_10 Node0_9_10 77.0
R_0_8_10_3 Node0_8_10 Node1_8_10 12.320000000000002
C_0_8_10 Node0_8_10 GND 3.609375e-06
I_0_8_11 GND Node0_8_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_11_1 Node0_8_11 Node0_8_12 77.0
R_0_8_11_2 Node0_8_11 Node0_9_11 77.0
R_0_8_11_3 Node0_8_11 Node1_8_11 12.320000000000002
C_0_8_11 Node0_8_11 GND 3.609375e-06
I_0_8_12 GND Node0_8_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_12_1 Node0_8_12 Node0_8_13 77.0
R_0_8_12_2 Node0_8_12 Node0_9_12 77.0
R_0_8_12_3 Node0_8_12 Node1_8_12 12.320000000000002
C_0_8_12 Node0_8_12 GND 3.609375e-06
I_0_8_13 GND Node0_8_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_13_1 Node0_8_13 Node0_8_14 77.0
R_0_8_13_2 Node0_8_13 Node0_9_13 77.0
R_0_8_13_3 Node0_8_13 Node1_8_13 12.320000000000002
C_0_8_13 Node0_8_13 GND 3.609375e-06
I_0_8_14 GND Node0_8_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_14_1 Node0_8_14 Node0_8_15 77.0
R_0_8_14_2 Node0_8_14 Node0_9_14 77.0
R_0_8_14_3 Node0_8_14 Node1_8_14 12.320000000000002
C_0_8_14 Node0_8_14 GND 3.609375e-06
I_0_8_15 GND Node0_8_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_15_1 Node0_8_15 Node0_8_16 77.0
R_0_8_15_2 Node0_8_15 Node0_9_15 77.0
R_0_8_15_3 Node0_8_15 Node1_8_15 12.320000000000002
C_0_8_15 Node0_8_15 GND 3.609375e-06
I_0_8_16 GND Node0_8_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_16_1 Node0_8_16 Node0_8_17 77.0
R_0_8_16_2 Node0_8_16 Node0_9_16 77.0
R_0_8_16_3 Node0_8_16 Node1_8_16 12.320000000000002
C_0_8_16 Node0_8_16 GND 3.609375e-06
I_0_8_17 GND Node0_8_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_17_1 Node0_8_17 Node0_8_18 77.0
R_0_8_17_2 Node0_8_17 Node0_9_17 77.0
R_0_8_17_3 Node0_8_17 Node1_8_17 12.320000000000002
C_0_8_17 Node0_8_17 GND 3.609375e-06
I_0_8_18 GND Node0_8_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_18_1 Node0_8_18 Node0_8_19 77.0
R_0_8_18_2 Node0_8_18 Node0_9_18 77.0
R_0_8_18_3 Node0_8_18 Node1_8_18 12.320000000000002
C_0_8_18 Node0_8_18 GND 3.609375e-06
I_0_8_19 GND Node0_8_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_19_1 Node0_8_19 Node0_8_20 77.0
R_0_8_19_2 Node0_8_19 Node0_9_19 77.0
R_0_8_19_3 Node0_8_19 Node1_8_19 12.320000000000002
C_0_8_19 Node0_8_19 GND 3.609375e-06
I_0_8_20 GND Node0_8_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_20_1 Node0_8_20 Node0_8_21 77.0
R_0_8_20_2 Node0_8_20 Node0_9_20 77.0
R_0_8_20_3 Node0_8_20 Node1_8_20 12.320000000000002
C_0_8_20 Node0_8_20 GND 3.609375e-06
I_0_8_21 GND Node0_8_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_21_1 Node0_8_21 Node0_8_22 77.0
R_0_8_21_2 Node0_8_21 Node0_9_21 77.0
R_0_8_21_3 Node0_8_21 Node1_8_21 12.320000000000002
C_0_8_21 Node0_8_21 GND 3.609375e-06
I_0_8_22 GND Node0_8_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_22_1 Node0_8_22 Node0_8_23 77.0
R_0_8_22_2 Node0_8_22 Node0_9_22 77.0
R_0_8_22_3 Node0_8_22 Node1_8_22 12.320000000000002
C_0_8_22 Node0_8_22 GND 3.609375e-06
I_0_8_23 GND Node0_8_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_23_1 Node0_8_23 Node0_8_24 77.0
R_0_8_23_2 Node0_8_23 Node0_9_23 77.0
R_0_8_23_3 Node0_8_23 Node1_8_23 12.320000000000002
C_0_8_23 Node0_8_23 GND 3.609375e-06
I_0_8_24 GND Node0_8_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_24_1 Node0_8_24 Node0_8_25 77.0
R_0_8_24_2 Node0_8_24 Node0_9_24 77.0
R_0_8_24_3 Node0_8_24 Node1_8_24 12.320000000000002
C_0_8_24 Node0_8_24 GND 3.609375e-06
I_0_8_25 GND Node0_8_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_25_1 Node0_8_25 Node0_8_26 77.0
R_0_8_25_2 Node0_8_25 Node0_9_25 77.0
R_0_8_25_3 Node0_8_25 Node1_8_25 12.320000000000002
C_0_8_25 Node0_8_25 GND 3.609375e-06
I_0_8_26 GND Node0_8_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_26_1 Node0_8_26 Node0_8_27 77.0
R_0_8_26_2 Node0_8_26 Node0_9_26 77.0
R_0_8_26_3 Node0_8_26 Node1_8_26 12.320000000000002
C_0_8_26 Node0_8_26 GND 3.609375e-06
I_0_8_27 GND Node0_8_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_27_1 Node0_8_27 Node0_8_28 77.0
R_0_8_27_2 Node0_8_27 Node0_9_27 77.0
R_0_8_27_3 Node0_8_27 Node1_8_27 12.320000000000002
C_0_8_27 Node0_8_27 GND 3.609375e-06
I_0_8_28 GND Node0_8_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_28_1 Node0_8_28 Node0_8_29 77.0
R_0_8_28_2 Node0_8_28 Node0_9_28 77.0
R_0_8_28_3 Node0_8_28 Node1_8_28 12.320000000000002
C_0_8_28 Node0_8_28 GND 3.609375e-06
I_0_8_29 GND Node0_8_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_29_1 Node0_8_29 Node0_8_30 77.0
R_0_8_29_2 Node0_8_29 Node0_9_29 77.0
R_0_8_29_3 Node0_8_29 Node1_8_29 12.320000000000002
C_0_8_29 Node0_8_29 GND 3.609375e-06
I_0_8_30 GND Node0_8_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_30_1 Node0_8_30 Node0_8_31 77.0
R_0_8_30_2 Node0_8_30 Node0_9_30 77.0
R_0_8_30_3 Node0_8_30 Node1_8_30 12.320000000000002
C_0_8_30 Node0_8_30 GND 3.609375e-06
I_0_8_31 GND Node0_8_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_31_1 Node0_8_31 Node0_8_32 77.0
R_0_8_31_2 Node0_8_31 Node0_9_31 77.0
R_0_8_31_3 Node0_8_31 Node1_8_31 12.320000000000002
C_0_8_31 Node0_8_31 GND 3.609375e-06
I_0_8_32 GND Node0_8_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_32_1 Node0_8_32 Node0_8_33 77.0
R_0_8_32_2 Node0_8_32 Node0_9_32 77.0
R_0_8_32_3 Node0_8_32 Node1_8_32 12.320000000000002
C_0_8_32 Node0_8_32 GND 3.609375e-06
I_0_8_33 GND Node0_8_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_33_1 Node0_8_33 Node0_8_34 77.0
R_0_8_33_2 Node0_8_33 Node0_9_33 77.0
R_0_8_33_3 Node0_8_33 Node1_8_33 12.320000000000002
C_0_8_33 Node0_8_33 GND 3.609375e-06
I_0_8_34 GND Node0_8_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_34_1 Node0_8_34 Node0_8_35 77.0
R_0_8_34_2 Node0_8_34 Node0_9_34 77.0
R_0_8_34_3 Node0_8_34 Node1_8_34 12.320000000000002
C_0_8_34 Node0_8_34 GND 3.609375e-06
I_0_8_35 GND Node0_8_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_35_1 Node0_8_35 Node0_8_36 77.0
R_0_8_35_2 Node0_8_35 Node0_9_35 77.0
R_0_8_35_3 Node0_8_35 Node1_8_35 12.320000000000002
C_0_8_35 Node0_8_35 GND 3.609375e-06
I_0_8_36 GND Node0_8_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_36_1 Node0_8_36 Node0_8_37 77.0
R_0_8_36_2 Node0_8_36 Node0_9_36 77.0
R_0_8_36_3 Node0_8_36 Node1_8_36 12.320000000000002
C_0_8_36 Node0_8_36 GND 3.609375e-06
I_0_8_37 GND Node0_8_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_37_1 Node0_8_37 Node0_8_38 77.0
R_0_8_37_2 Node0_8_37 Node0_9_37 77.0
R_0_8_37_3 Node0_8_37 Node1_8_37 12.320000000000002
C_0_8_37 Node0_8_37 GND 3.609375e-06
I_0_8_38 GND Node0_8_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_38_1 Node0_8_38 Node0_8_39 77.0
R_0_8_38_2 Node0_8_38 Node0_9_38 77.0
R_0_8_38_3 Node0_8_38 Node1_8_38 12.320000000000002
C_0_8_38 Node0_8_38 GND 3.609375e-06
I_0_8_39 GND Node0_8_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_8_39_2 Node0_8_39 Node0_9_39 77.0
R_0_8_39_3 Node0_8_39 Node1_8_39 12.320000000000002
C_0_8_39 Node0_8_39 GND 3.609375e-06
I_0_9_0 GND Node0_9_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_0_1 Node0_9_0 Node0_9_1 77.0
R_0_9_0_2 Node0_9_0 Node0_10_0 77.0
R_0_9_0_3 Node0_9_0 Node1_9_0 12.320000000000002
C_0_9_0 Node0_9_0 GND 3.609375e-06
I_0_9_1 GND Node0_9_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_1_1 Node0_9_1 Node0_9_2 77.0
R_0_9_1_2 Node0_9_1 Node0_10_1 77.0
R_0_9_1_3 Node0_9_1 Node1_9_1 12.320000000000002
C_0_9_1 Node0_9_1 GND 3.609375e-06
I_0_9_2 GND Node0_9_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_2_1 Node0_9_2 Node0_9_3 77.0
R_0_9_2_2 Node0_9_2 Node0_10_2 77.0
R_0_9_2_3 Node0_9_2 Node1_9_2 12.320000000000002
C_0_9_2 Node0_9_2 GND 3.609375e-06
I_0_9_3 GND Node0_9_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_3_1 Node0_9_3 Node0_9_4 77.0
R_0_9_3_2 Node0_9_3 Node0_10_3 77.0
R_0_9_3_3 Node0_9_3 Node1_9_3 12.320000000000002
C_0_9_3 Node0_9_3 GND 3.609375e-06
I_0_9_4 GND Node0_9_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_4_1 Node0_9_4 Node0_9_5 77.0
R_0_9_4_2 Node0_9_4 Node0_10_4 77.0
R_0_9_4_3 Node0_9_4 Node1_9_4 12.320000000000002
C_0_9_4 Node0_9_4 GND 3.609375e-06
I_0_9_5 GND Node0_9_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_5_1 Node0_9_5 Node0_9_6 77.0
R_0_9_5_2 Node0_9_5 Node0_10_5 77.0
R_0_9_5_3 Node0_9_5 Node1_9_5 12.320000000000002
C_0_9_5 Node0_9_5 GND 3.609375e-06
I_0_9_6 GND Node0_9_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_6_1 Node0_9_6 Node0_9_7 77.0
R_0_9_6_2 Node0_9_6 Node0_10_6 77.0
R_0_9_6_3 Node0_9_6 Node1_9_6 12.320000000000002
C_0_9_6 Node0_9_6 GND 3.609375e-06
I_0_9_7 GND Node0_9_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_7_1 Node0_9_7 Node0_9_8 77.0
R_0_9_7_2 Node0_9_7 Node0_10_7 77.0
R_0_9_7_3 Node0_9_7 Node1_9_7 12.320000000000002
C_0_9_7 Node0_9_7 GND 3.609375e-06
I_0_9_8 GND Node0_9_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_8_1 Node0_9_8 Node0_9_9 77.0
R_0_9_8_2 Node0_9_8 Node0_10_8 77.0
R_0_9_8_3 Node0_9_8 Node1_9_8 12.320000000000002
C_0_9_8 Node0_9_8 GND 3.609375e-06
I_0_9_9 GND Node0_9_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_9_1 Node0_9_9 Node0_9_10 77.0
R_0_9_9_2 Node0_9_9 Node0_10_9 77.0
R_0_9_9_3 Node0_9_9 Node1_9_9 12.320000000000002
C_0_9_9 Node0_9_9 GND 3.609375e-06
I_0_9_10 GND Node0_9_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_10_1 Node0_9_10 Node0_9_11 77.0
R_0_9_10_2 Node0_9_10 Node0_10_10 77.0
R_0_9_10_3 Node0_9_10 Node1_9_10 12.320000000000002
C_0_9_10 Node0_9_10 GND 3.609375e-06
I_0_9_11 GND Node0_9_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_11_1 Node0_9_11 Node0_9_12 77.0
R_0_9_11_2 Node0_9_11 Node0_10_11 77.0
R_0_9_11_3 Node0_9_11 Node1_9_11 12.320000000000002
C_0_9_11 Node0_9_11 GND 3.609375e-06
I_0_9_12 GND Node0_9_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_12_1 Node0_9_12 Node0_9_13 77.0
R_0_9_12_2 Node0_9_12 Node0_10_12 77.0
R_0_9_12_3 Node0_9_12 Node1_9_12 12.320000000000002
C_0_9_12 Node0_9_12 GND 3.609375e-06
I_0_9_13 GND Node0_9_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_13_1 Node0_9_13 Node0_9_14 77.0
R_0_9_13_2 Node0_9_13 Node0_10_13 77.0
R_0_9_13_3 Node0_9_13 Node1_9_13 12.320000000000002
C_0_9_13 Node0_9_13 GND 3.609375e-06
I_0_9_14 GND Node0_9_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_14_1 Node0_9_14 Node0_9_15 77.0
R_0_9_14_2 Node0_9_14 Node0_10_14 77.0
R_0_9_14_3 Node0_9_14 Node1_9_14 12.320000000000002
C_0_9_14 Node0_9_14 GND 3.609375e-06
I_0_9_15 GND Node0_9_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_15_1 Node0_9_15 Node0_9_16 77.0
R_0_9_15_2 Node0_9_15 Node0_10_15 77.0
R_0_9_15_3 Node0_9_15 Node1_9_15 12.320000000000002
C_0_9_15 Node0_9_15 GND 3.609375e-06
I_0_9_16 GND Node0_9_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_16_1 Node0_9_16 Node0_9_17 77.0
R_0_9_16_2 Node0_9_16 Node0_10_16 77.0
R_0_9_16_3 Node0_9_16 Node1_9_16 12.320000000000002
C_0_9_16 Node0_9_16 GND 3.609375e-06
I_0_9_17 GND Node0_9_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_17_1 Node0_9_17 Node0_9_18 77.0
R_0_9_17_2 Node0_9_17 Node0_10_17 77.0
R_0_9_17_3 Node0_9_17 Node1_9_17 12.320000000000002
C_0_9_17 Node0_9_17 GND 3.609375e-06
I_0_9_18 GND Node0_9_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_18_1 Node0_9_18 Node0_9_19 77.0
R_0_9_18_2 Node0_9_18 Node0_10_18 77.0
R_0_9_18_3 Node0_9_18 Node1_9_18 12.320000000000002
C_0_9_18 Node0_9_18 GND 3.609375e-06
I_0_9_19 GND Node0_9_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_19_1 Node0_9_19 Node0_9_20 77.0
R_0_9_19_2 Node0_9_19 Node0_10_19 77.0
R_0_9_19_3 Node0_9_19 Node1_9_19 12.320000000000002
C_0_9_19 Node0_9_19 GND 3.609375e-06
I_0_9_20 GND Node0_9_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_20_1 Node0_9_20 Node0_9_21 77.0
R_0_9_20_2 Node0_9_20 Node0_10_20 77.0
R_0_9_20_3 Node0_9_20 Node1_9_20 12.320000000000002
C_0_9_20 Node0_9_20 GND 3.609375e-06
I_0_9_21 GND Node0_9_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_21_1 Node0_9_21 Node0_9_22 77.0
R_0_9_21_2 Node0_9_21 Node0_10_21 77.0
R_0_9_21_3 Node0_9_21 Node1_9_21 12.320000000000002
C_0_9_21 Node0_9_21 GND 3.609375e-06
I_0_9_22 GND Node0_9_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_22_1 Node0_9_22 Node0_9_23 77.0
R_0_9_22_2 Node0_9_22 Node0_10_22 77.0
R_0_9_22_3 Node0_9_22 Node1_9_22 12.320000000000002
C_0_9_22 Node0_9_22 GND 3.609375e-06
I_0_9_23 GND Node0_9_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_23_1 Node0_9_23 Node0_9_24 77.0
R_0_9_23_2 Node0_9_23 Node0_10_23 77.0
R_0_9_23_3 Node0_9_23 Node1_9_23 12.320000000000002
C_0_9_23 Node0_9_23 GND 3.609375e-06
I_0_9_24 GND Node0_9_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_24_1 Node0_9_24 Node0_9_25 77.0
R_0_9_24_2 Node0_9_24 Node0_10_24 77.0
R_0_9_24_3 Node0_9_24 Node1_9_24 12.320000000000002
C_0_9_24 Node0_9_24 GND 3.609375e-06
I_0_9_25 GND Node0_9_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_25_1 Node0_9_25 Node0_9_26 77.0
R_0_9_25_2 Node0_9_25 Node0_10_25 77.0
R_0_9_25_3 Node0_9_25 Node1_9_25 12.320000000000002
C_0_9_25 Node0_9_25 GND 3.609375e-06
I_0_9_26 GND Node0_9_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_26_1 Node0_9_26 Node0_9_27 77.0
R_0_9_26_2 Node0_9_26 Node0_10_26 77.0
R_0_9_26_3 Node0_9_26 Node1_9_26 12.320000000000002
C_0_9_26 Node0_9_26 GND 3.609375e-06
I_0_9_27 GND Node0_9_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_27_1 Node0_9_27 Node0_9_28 77.0
R_0_9_27_2 Node0_9_27 Node0_10_27 77.0
R_0_9_27_3 Node0_9_27 Node1_9_27 12.320000000000002
C_0_9_27 Node0_9_27 GND 3.609375e-06
I_0_9_28 GND Node0_9_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_28_1 Node0_9_28 Node0_9_29 77.0
R_0_9_28_2 Node0_9_28 Node0_10_28 77.0
R_0_9_28_3 Node0_9_28 Node1_9_28 12.320000000000002
C_0_9_28 Node0_9_28 GND 3.609375e-06
I_0_9_29 GND Node0_9_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_29_1 Node0_9_29 Node0_9_30 77.0
R_0_9_29_2 Node0_9_29 Node0_10_29 77.0
R_0_9_29_3 Node0_9_29 Node1_9_29 12.320000000000002
C_0_9_29 Node0_9_29 GND 3.609375e-06
I_0_9_30 GND Node0_9_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_30_1 Node0_9_30 Node0_9_31 77.0
R_0_9_30_2 Node0_9_30 Node0_10_30 77.0
R_0_9_30_3 Node0_9_30 Node1_9_30 12.320000000000002
C_0_9_30 Node0_9_30 GND 3.609375e-06
I_0_9_31 GND Node0_9_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_31_1 Node0_9_31 Node0_9_32 77.0
R_0_9_31_2 Node0_9_31 Node0_10_31 77.0
R_0_9_31_3 Node0_9_31 Node1_9_31 12.320000000000002
C_0_9_31 Node0_9_31 GND 3.609375e-06
I_0_9_32 GND Node0_9_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_32_1 Node0_9_32 Node0_9_33 77.0
R_0_9_32_2 Node0_9_32 Node0_10_32 77.0
R_0_9_32_3 Node0_9_32 Node1_9_32 12.320000000000002
C_0_9_32 Node0_9_32 GND 3.609375e-06
I_0_9_33 GND Node0_9_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_33_1 Node0_9_33 Node0_9_34 77.0
R_0_9_33_2 Node0_9_33 Node0_10_33 77.0
R_0_9_33_3 Node0_9_33 Node1_9_33 12.320000000000002
C_0_9_33 Node0_9_33 GND 3.609375e-06
I_0_9_34 GND Node0_9_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_34_1 Node0_9_34 Node0_9_35 77.0
R_0_9_34_2 Node0_9_34 Node0_10_34 77.0
R_0_9_34_3 Node0_9_34 Node1_9_34 12.320000000000002
C_0_9_34 Node0_9_34 GND 3.609375e-06
I_0_9_35 GND Node0_9_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_35_1 Node0_9_35 Node0_9_36 77.0
R_0_9_35_2 Node0_9_35 Node0_10_35 77.0
R_0_9_35_3 Node0_9_35 Node1_9_35 12.320000000000002
C_0_9_35 Node0_9_35 GND 3.609375e-06
I_0_9_36 GND Node0_9_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_36_1 Node0_9_36 Node0_9_37 77.0
R_0_9_36_2 Node0_9_36 Node0_10_36 77.0
R_0_9_36_3 Node0_9_36 Node1_9_36 12.320000000000002
C_0_9_36 Node0_9_36 GND 3.609375e-06
I_0_9_37 GND Node0_9_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_37_1 Node0_9_37 Node0_9_38 77.0
R_0_9_37_2 Node0_9_37 Node0_10_37 77.0
R_0_9_37_3 Node0_9_37 Node1_9_37 12.320000000000002
C_0_9_37 Node0_9_37 GND 3.609375e-06
I_0_9_38 GND Node0_9_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_38_1 Node0_9_38 Node0_9_39 77.0
R_0_9_38_2 Node0_9_38 Node0_10_38 77.0
R_0_9_38_3 Node0_9_38 Node1_9_38 12.320000000000002
C_0_9_38 Node0_9_38 GND 3.609375e-06
I_0_9_39 GND Node0_9_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_9_39_2 Node0_9_39 Node0_10_39 77.0
R_0_9_39_3 Node0_9_39 Node1_9_39 12.320000000000002
C_0_9_39 Node0_9_39 GND 3.609375e-06
I_0_10_0 GND Node0_10_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_0_1 Node0_10_0 Node0_10_1 77.0
R_0_10_0_2 Node0_10_0 Node0_11_0 77.0
R_0_10_0_3 Node0_10_0 Node1_10_0 12.320000000000002
C_0_10_0 Node0_10_0 GND 3.609375e-06
I_0_10_1 GND Node0_10_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_1_1 Node0_10_1 Node0_10_2 77.0
R_0_10_1_2 Node0_10_1 Node0_11_1 77.0
R_0_10_1_3 Node0_10_1 Node1_10_1 12.320000000000002
C_0_10_1 Node0_10_1 GND 3.609375e-06
I_0_10_2 GND Node0_10_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_2_1 Node0_10_2 Node0_10_3 77.0
R_0_10_2_2 Node0_10_2 Node0_11_2 77.0
R_0_10_2_3 Node0_10_2 Node1_10_2 12.320000000000002
C_0_10_2 Node0_10_2 GND 3.609375e-06
I_0_10_3 GND Node0_10_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_3_1 Node0_10_3 Node0_10_4 77.0
R_0_10_3_2 Node0_10_3 Node0_11_3 77.0
R_0_10_3_3 Node0_10_3 Node1_10_3 12.320000000000002
C_0_10_3 Node0_10_3 GND 3.609375e-06
I_0_10_4 GND Node0_10_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_4_1 Node0_10_4 Node0_10_5 77.0
R_0_10_4_2 Node0_10_4 Node0_11_4 77.0
R_0_10_4_3 Node0_10_4 Node1_10_4 12.320000000000002
C_0_10_4 Node0_10_4 GND 3.609375e-06
I_0_10_5 GND Node0_10_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_5_1 Node0_10_5 Node0_10_6 77.0
R_0_10_5_2 Node0_10_5 Node0_11_5 77.0
R_0_10_5_3 Node0_10_5 Node1_10_5 12.320000000000002
C_0_10_5 Node0_10_5 GND 3.609375e-06
I_0_10_6 GND Node0_10_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_6_1 Node0_10_6 Node0_10_7 77.0
R_0_10_6_2 Node0_10_6 Node0_11_6 77.0
R_0_10_6_3 Node0_10_6 Node1_10_6 12.320000000000002
C_0_10_6 Node0_10_6 GND 3.609375e-06
I_0_10_7 GND Node0_10_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_7_1 Node0_10_7 Node0_10_8 77.0
R_0_10_7_2 Node0_10_7 Node0_11_7 77.0
R_0_10_7_3 Node0_10_7 Node1_10_7 12.320000000000002
C_0_10_7 Node0_10_7 GND 3.609375e-06
I_0_10_8 GND Node0_10_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_8_1 Node0_10_8 Node0_10_9 77.0
R_0_10_8_2 Node0_10_8 Node0_11_8 77.0
R_0_10_8_3 Node0_10_8 Node1_10_8 12.320000000000002
C_0_10_8 Node0_10_8 GND 3.609375e-06
I_0_10_9 GND Node0_10_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_9_1 Node0_10_9 Node0_10_10 77.0
R_0_10_9_2 Node0_10_9 Node0_11_9 77.0
R_0_10_9_3 Node0_10_9 Node1_10_9 12.320000000000002
C_0_10_9 Node0_10_9 GND 3.609375e-06
I_0_10_10 GND Node0_10_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_10_1 Node0_10_10 Node0_10_11 77.0
R_0_10_10_2 Node0_10_10 Node0_11_10 77.0
R_0_10_10_3 Node0_10_10 Node1_10_10 12.320000000000002
C_0_10_10 Node0_10_10 GND 3.609375e-06
I_0_10_11 GND Node0_10_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_11_1 Node0_10_11 Node0_10_12 77.0
R_0_10_11_2 Node0_10_11 Node0_11_11 77.0
R_0_10_11_3 Node0_10_11 Node1_10_11 12.320000000000002
C_0_10_11 Node0_10_11 GND 3.609375e-06
I_0_10_12 GND Node0_10_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_12_1 Node0_10_12 Node0_10_13 77.0
R_0_10_12_2 Node0_10_12 Node0_11_12 77.0
R_0_10_12_3 Node0_10_12 Node1_10_12 12.320000000000002
C_0_10_12 Node0_10_12 GND 3.609375e-06
I_0_10_13 GND Node0_10_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_13_1 Node0_10_13 Node0_10_14 77.0
R_0_10_13_2 Node0_10_13 Node0_11_13 77.0
R_0_10_13_3 Node0_10_13 Node1_10_13 12.320000000000002
C_0_10_13 Node0_10_13 GND 3.609375e-06
I_0_10_14 GND Node0_10_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_14_1 Node0_10_14 Node0_10_15 77.0
R_0_10_14_2 Node0_10_14 Node0_11_14 77.0
R_0_10_14_3 Node0_10_14 Node1_10_14 12.320000000000002
C_0_10_14 Node0_10_14 GND 3.609375e-06
I_0_10_15 GND Node0_10_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_15_1 Node0_10_15 Node0_10_16 77.0
R_0_10_15_2 Node0_10_15 Node0_11_15 77.0
R_0_10_15_3 Node0_10_15 Node1_10_15 12.320000000000002
C_0_10_15 Node0_10_15 GND 3.609375e-06
I_0_10_16 GND Node0_10_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_16_1 Node0_10_16 Node0_10_17 77.0
R_0_10_16_2 Node0_10_16 Node0_11_16 77.0
R_0_10_16_3 Node0_10_16 Node1_10_16 12.320000000000002
C_0_10_16 Node0_10_16 GND 3.609375e-06
I_0_10_17 GND Node0_10_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_17_1 Node0_10_17 Node0_10_18 77.0
R_0_10_17_2 Node0_10_17 Node0_11_17 77.0
R_0_10_17_3 Node0_10_17 Node1_10_17 12.320000000000002
C_0_10_17 Node0_10_17 GND 3.609375e-06
I_0_10_18 GND Node0_10_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_18_1 Node0_10_18 Node0_10_19 77.0
R_0_10_18_2 Node0_10_18 Node0_11_18 77.0
R_0_10_18_3 Node0_10_18 Node1_10_18 12.320000000000002
C_0_10_18 Node0_10_18 GND 3.609375e-06
I_0_10_19 GND Node0_10_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_19_1 Node0_10_19 Node0_10_20 77.0
R_0_10_19_2 Node0_10_19 Node0_11_19 77.0
R_0_10_19_3 Node0_10_19 Node1_10_19 12.320000000000002
C_0_10_19 Node0_10_19 GND 3.609375e-06
I_0_10_20 GND Node0_10_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_20_1 Node0_10_20 Node0_10_21 77.0
R_0_10_20_2 Node0_10_20 Node0_11_20 77.0
R_0_10_20_3 Node0_10_20 Node1_10_20 12.320000000000002
C_0_10_20 Node0_10_20 GND 3.609375e-06
I_0_10_21 GND Node0_10_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_21_1 Node0_10_21 Node0_10_22 77.0
R_0_10_21_2 Node0_10_21 Node0_11_21 77.0
R_0_10_21_3 Node0_10_21 Node1_10_21 12.320000000000002
C_0_10_21 Node0_10_21 GND 3.609375e-06
I_0_10_22 GND Node0_10_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_22_1 Node0_10_22 Node0_10_23 77.0
R_0_10_22_2 Node0_10_22 Node0_11_22 77.0
R_0_10_22_3 Node0_10_22 Node1_10_22 12.320000000000002
C_0_10_22 Node0_10_22 GND 3.609375e-06
I_0_10_23 GND Node0_10_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_23_1 Node0_10_23 Node0_10_24 77.0
R_0_10_23_2 Node0_10_23 Node0_11_23 77.0
R_0_10_23_3 Node0_10_23 Node1_10_23 12.320000000000002
C_0_10_23 Node0_10_23 GND 3.609375e-06
I_0_10_24 GND Node0_10_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_24_1 Node0_10_24 Node0_10_25 77.0
R_0_10_24_2 Node0_10_24 Node0_11_24 77.0
R_0_10_24_3 Node0_10_24 Node1_10_24 12.320000000000002
C_0_10_24 Node0_10_24 GND 3.609375e-06
I_0_10_25 GND Node0_10_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_25_1 Node0_10_25 Node0_10_26 77.0
R_0_10_25_2 Node0_10_25 Node0_11_25 77.0
R_0_10_25_3 Node0_10_25 Node1_10_25 12.320000000000002
C_0_10_25 Node0_10_25 GND 3.609375e-06
I_0_10_26 GND Node0_10_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_26_1 Node0_10_26 Node0_10_27 77.0
R_0_10_26_2 Node0_10_26 Node0_11_26 77.0
R_0_10_26_3 Node0_10_26 Node1_10_26 12.320000000000002
C_0_10_26 Node0_10_26 GND 3.609375e-06
I_0_10_27 GND Node0_10_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_27_1 Node0_10_27 Node0_10_28 77.0
R_0_10_27_2 Node0_10_27 Node0_11_27 77.0
R_0_10_27_3 Node0_10_27 Node1_10_27 12.320000000000002
C_0_10_27 Node0_10_27 GND 3.609375e-06
I_0_10_28 GND Node0_10_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_28_1 Node0_10_28 Node0_10_29 77.0
R_0_10_28_2 Node0_10_28 Node0_11_28 77.0
R_0_10_28_3 Node0_10_28 Node1_10_28 12.320000000000002
C_0_10_28 Node0_10_28 GND 3.609375e-06
I_0_10_29 GND Node0_10_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_29_1 Node0_10_29 Node0_10_30 77.0
R_0_10_29_2 Node0_10_29 Node0_11_29 77.0
R_0_10_29_3 Node0_10_29 Node1_10_29 12.320000000000002
C_0_10_29 Node0_10_29 GND 3.609375e-06
I_0_10_30 GND Node0_10_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_30_1 Node0_10_30 Node0_10_31 77.0
R_0_10_30_2 Node0_10_30 Node0_11_30 77.0
R_0_10_30_3 Node0_10_30 Node1_10_30 12.320000000000002
C_0_10_30 Node0_10_30 GND 3.609375e-06
I_0_10_31 GND Node0_10_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_31_1 Node0_10_31 Node0_10_32 77.0
R_0_10_31_2 Node0_10_31 Node0_11_31 77.0
R_0_10_31_3 Node0_10_31 Node1_10_31 12.320000000000002
C_0_10_31 Node0_10_31 GND 3.609375e-06
I_0_10_32 GND Node0_10_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_32_1 Node0_10_32 Node0_10_33 77.0
R_0_10_32_2 Node0_10_32 Node0_11_32 77.0
R_0_10_32_3 Node0_10_32 Node1_10_32 12.320000000000002
C_0_10_32 Node0_10_32 GND 3.609375e-06
I_0_10_33 GND Node0_10_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_33_1 Node0_10_33 Node0_10_34 77.0
R_0_10_33_2 Node0_10_33 Node0_11_33 77.0
R_0_10_33_3 Node0_10_33 Node1_10_33 12.320000000000002
C_0_10_33 Node0_10_33 GND 3.609375e-06
I_0_10_34 GND Node0_10_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_34_1 Node0_10_34 Node0_10_35 77.0
R_0_10_34_2 Node0_10_34 Node0_11_34 77.0
R_0_10_34_3 Node0_10_34 Node1_10_34 12.320000000000002
C_0_10_34 Node0_10_34 GND 3.609375e-06
I_0_10_35 GND Node0_10_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_35_1 Node0_10_35 Node0_10_36 77.0
R_0_10_35_2 Node0_10_35 Node0_11_35 77.0
R_0_10_35_3 Node0_10_35 Node1_10_35 12.320000000000002
C_0_10_35 Node0_10_35 GND 3.609375e-06
I_0_10_36 GND Node0_10_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_36_1 Node0_10_36 Node0_10_37 77.0
R_0_10_36_2 Node0_10_36 Node0_11_36 77.0
R_0_10_36_3 Node0_10_36 Node1_10_36 12.320000000000002
C_0_10_36 Node0_10_36 GND 3.609375e-06
I_0_10_37 GND Node0_10_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_37_1 Node0_10_37 Node0_10_38 77.0
R_0_10_37_2 Node0_10_37 Node0_11_37 77.0
R_0_10_37_3 Node0_10_37 Node1_10_37 12.320000000000002
C_0_10_37 Node0_10_37 GND 3.609375e-06
I_0_10_38 GND Node0_10_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_38_1 Node0_10_38 Node0_10_39 77.0
R_0_10_38_2 Node0_10_38 Node0_11_38 77.0
R_0_10_38_3 Node0_10_38 Node1_10_38 12.320000000000002
C_0_10_38 Node0_10_38 GND 3.609375e-06
I_0_10_39 GND Node0_10_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_10_39_2 Node0_10_39 Node0_11_39 77.0
R_0_10_39_3 Node0_10_39 Node1_10_39 12.320000000000002
C_0_10_39 Node0_10_39 GND 3.609375e-06
I_0_11_0 GND Node0_11_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_0_1 Node0_11_0 Node0_11_1 77.0
R_0_11_0_2 Node0_11_0 Node0_12_0 77.0
R_0_11_0_3 Node0_11_0 Node1_11_0 12.320000000000002
C_0_11_0 Node0_11_0 GND 3.609375e-06
I_0_11_1 GND Node0_11_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_1_1 Node0_11_1 Node0_11_2 77.0
R_0_11_1_2 Node0_11_1 Node0_12_1 77.0
R_0_11_1_3 Node0_11_1 Node1_11_1 12.320000000000002
C_0_11_1 Node0_11_1 GND 3.609375e-06
I_0_11_2 GND Node0_11_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_2_1 Node0_11_2 Node0_11_3 77.0
R_0_11_2_2 Node0_11_2 Node0_12_2 77.0
R_0_11_2_3 Node0_11_2 Node1_11_2 12.320000000000002
C_0_11_2 Node0_11_2 GND 3.609375e-06
I_0_11_3 GND Node0_11_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_3_1 Node0_11_3 Node0_11_4 77.0
R_0_11_3_2 Node0_11_3 Node0_12_3 77.0
R_0_11_3_3 Node0_11_3 Node1_11_3 12.320000000000002
C_0_11_3 Node0_11_3 GND 3.609375e-06
I_0_11_4 GND Node0_11_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_4_1 Node0_11_4 Node0_11_5 77.0
R_0_11_4_2 Node0_11_4 Node0_12_4 77.0
R_0_11_4_3 Node0_11_4 Node1_11_4 12.320000000000002
C_0_11_4 Node0_11_4 GND 3.609375e-06
I_0_11_5 GND Node0_11_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_5_1 Node0_11_5 Node0_11_6 77.0
R_0_11_5_2 Node0_11_5 Node0_12_5 77.0
R_0_11_5_3 Node0_11_5 Node1_11_5 12.320000000000002
C_0_11_5 Node0_11_5 GND 3.609375e-06
I_0_11_6 GND Node0_11_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_6_1 Node0_11_6 Node0_11_7 77.0
R_0_11_6_2 Node0_11_6 Node0_12_6 77.0
R_0_11_6_3 Node0_11_6 Node1_11_6 12.320000000000002
C_0_11_6 Node0_11_6 GND 3.609375e-06
I_0_11_7 GND Node0_11_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_7_1 Node0_11_7 Node0_11_8 77.0
R_0_11_7_2 Node0_11_7 Node0_12_7 77.0
R_0_11_7_3 Node0_11_7 Node1_11_7 12.320000000000002
C_0_11_7 Node0_11_7 GND 3.609375e-06
I_0_11_8 GND Node0_11_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_8_1 Node0_11_8 Node0_11_9 77.0
R_0_11_8_2 Node0_11_8 Node0_12_8 77.0
R_0_11_8_3 Node0_11_8 Node1_11_8 12.320000000000002
C_0_11_8 Node0_11_8 GND 3.609375e-06
I_0_11_9 GND Node0_11_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_9_1 Node0_11_9 Node0_11_10 77.0
R_0_11_9_2 Node0_11_9 Node0_12_9 77.0
R_0_11_9_3 Node0_11_9 Node1_11_9 12.320000000000002
C_0_11_9 Node0_11_9 GND 3.609375e-06
I_0_11_10 GND Node0_11_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_10_1 Node0_11_10 Node0_11_11 77.0
R_0_11_10_2 Node0_11_10 Node0_12_10 77.0
R_0_11_10_3 Node0_11_10 Node1_11_10 12.320000000000002
C_0_11_10 Node0_11_10 GND 3.609375e-06
I_0_11_11 GND Node0_11_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_11_1 Node0_11_11 Node0_11_12 77.0
R_0_11_11_2 Node0_11_11 Node0_12_11 77.0
R_0_11_11_3 Node0_11_11 Node1_11_11 12.320000000000002
C_0_11_11 Node0_11_11 GND 3.609375e-06
I_0_11_12 GND Node0_11_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_12_1 Node0_11_12 Node0_11_13 77.0
R_0_11_12_2 Node0_11_12 Node0_12_12 77.0
R_0_11_12_3 Node0_11_12 Node1_11_12 12.320000000000002
C_0_11_12 Node0_11_12 GND 3.609375e-06
I_0_11_13 GND Node0_11_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_13_1 Node0_11_13 Node0_11_14 77.0
R_0_11_13_2 Node0_11_13 Node0_12_13 77.0
R_0_11_13_3 Node0_11_13 Node1_11_13 12.320000000000002
C_0_11_13 Node0_11_13 GND 3.609375e-06
I_0_11_14 GND Node0_11_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_14_1 Node0_11_14 Node0_11_15 77.0
R_0_11_14_2 Node0_11_14 Node0_12_14 77.0
R_0_11_14_3 Node0_11_14 Node1_11_14 12.320000000000002
C_0_11_14 Node0_11_14 GND 3.609375e-06
I_0_11_15 GND Node0_11_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_15_1 Node0_11_15 Node0_11_16 77.0
R_0_11_15_2 Node0_11_15 Node0_12_15 77.0
R_0_11_15_3 Node0_11_15 Node1_11_15 12.320000000000002
C_0_11_15 Node0_11_15 GND 3.609375e-06
I_0_11_16 GND Node0_11_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_16_1 Node0_11_16 Node0_11_17 77.0
R_0_11_16_2 Node0_11_16 Node0_12_16 77.0
R_0_11_16_3 Node0_11_16 Node1_11_16 12.320000000000002
C_0_11_16 Node0_11_16 GND 3.609375e-06
I_0_11_17 GND Node0_11_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_17_1 Node0_11_17 Node0_11_18 77.0
R_0_11_17_2 Node0_11_17 Node0_12_17 77.0
R_0_11_17_3 Node0_11_17 Node1_11_17 12.320000000000002
C_0_11_17 Node0_11_17 GND 3.609375e-06
I_0_11_18 GND Node0_11_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_18_1 Node0_11_18 Node0_11_19 77.0
R_0_11_18_2 Node0_11_18 Node0_12_18 77.0
R_0_11_18_3 Node0_11_18 Node1_11_18 12.320000000000002
C_0_11_18 Node0_11_18 GND 3.609375e-06
I_0_11_19 GND Node0_11_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_19_1 Node0_11_19 Node0_11_20 77.0
R_0_11_19_2 Node0_11_19 Node0_12_19 77.0
R_0_11_19_3 Node0_11_19 Node1_11_19 12.320000000000002
C_0_11_19 Node0_11_19 GND 3.609375e-06
I_0_11_20 GND Node0_11_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_20_1 Node0_11_20 Node0_11_21 77.0
R_0_11_20_2 Node0_11_20 Node0_12_20 77.0
R_0_11_20_3 Node0_11_20 Node1_11_20 12.320000000000002
C_0_11_20 Node0_11_20 GND 3.609375e-06
I_0_11_21 GND Node0_11_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_21_1 Node0_11_21 Node0_11_22 77.0
R_0_11_21_2 Node0_11_21 Node0_12_21 77.0
R_0_11_21_3 Node0_11_21 Node1_11_21 12.320000000000002
C_0_11_21 Node0_11_21 GND 3.609375e-06
I_0_11_22 GND Node0_11_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_22_1 Node0_11_22 Node0_11_23 77.0
R_0_11_22_2 Node0_11_22 Node0_12_22 77.0
R_0_11_22_3 Node0_11_22 Node1_11_22 12.320000000000002
C_0_11_22 Node0_11_22 GND 3.609375e-06
I_0_11_23 GND Node0_11_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_23_1 Node0_11_23 Node0_11_24 77.0
R_0_11_23_2 Node0_11_23 Node0_12_23 77.0
R_0_11_23_3 Node0_11_23 Node1_11_23 12.320000000000002
C_0_11_23 Node0_11_23 GND 3.609375e-06
I_0_11_24 GND Node0_11_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_24_1 Node0_11_24 Node0_11_25 77.0
R_0_11_24_2 Node0_11_24 Node0_12_24 77.0
R_0_11_24_3 Node0_11_24 Node1_11_24 12.320000000000002
C_0_11_24 Node0_11_24 GND 3.609375e-06
I_0_11_25 GND Node0_11_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_25_1 Node0_11_25 Node0_11_26 77.0
R_0_11_25_2 Node0_11_25 Node0_12_25 77.0
R_0_11_25_3 Node0_11_25 Node1_11_25 12.320000000000002
C_0_11_25 Node0_11_25 GND 3.609375e-06
I_0_11_26 GND Node0_11_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_26_1 Node0_11_26 Node0_11_27 77.0
R_0_11_26_2 Node0_11_26 Node0_12_26 77.0
R_0_11_26_3 Node0_11_26 Node1_11_26 12.320000000000002
C_0_11_26 Node0_11_26 GND 3.609375e-06
I_0_11_27 GND Node0_11_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_27_1 Node0_11_27 Node0_11_28 77.0
R_0_11_27_2 Node0_11_27 Node0_12_27 77.0
R_0_11_27_3 Node0_11_27 Node1_11_27 12.320000000000002
C_0_11_27 Node0_11_27 GND 3.609375e-06
I_0_11_28 GND Node0_11_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_28_1 Node0_11_28 Node0_11_29 77.0
R_0_11_28_2 Node0_11_28 Node0_12_28 77.0
R_0_11_28_3 Node0_11_28 Node1_11_28 12.320000000000002
C_0_11_28 Node0_11_28 GND 3.609375e-06
I_0_11_29 GND Node0_11_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_29_1 Node0_11_29 Node0_11_30 77.0
R_0_11_29_2 Node0_11_29 Node0_12_29 77.0
R_0_11_29_3 Node0_11_29 Node1_11_29 12.320000000000002
C_0_11_29 Node0_11_29 GND 3.609375e-06
I_0_11_30 GND Node0_11_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_30_1 Node0_11_30 Node0_11_31 77.0
R_0_11_30_2 Node0_11_30 Node0_12_30 77.0
R_0_11_30_3 Node0_11_30 Node1_11_30 12.320000000000002
C_0_11_30 Node0_11_30 GND 3.609375e-06
I_0_11_31 GND Node0_11_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_31_1 Node0_11_31 Node0_11_32 77.0
R_0_11_31_2 Node0_11_31 Node0_12_31 77.0
R_0_11_31_3 Node0_11_31 Node1_11_31 12.320000000000002
C_0_11_31 Node0_11_31 GND 3.609375e-06
I_0_11_32 GND Node0_11_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_32_1 Node0_11_32 Node0_11_33 77.0
R_0_11_32_2 Node0_11_32 Node0_12_32 77.0
R_0_11_32_3 Node0_11_32 Node1_11_32 12.320000000000002
C_0_11_32 Node0_11_32 GND 3.609375e-06
I_0_11_33 GND Node0_11_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_33_1 Node0_11_33 Node0_11_34 77.0
R_0_11_33_2 Node0_11_33 Node0_12_33 77.0
R_0_11_33_3 Node0_11_33 Node1_11_33 12.320000000000002
C_0_11_33 Node0_11_33 GND 3.609375e-06
I_0_11_34 GND Node0_11_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_34_1 Node0_11_34 Node0_11_35 77.0
R_0_11_34_2 Node0_11_34 Node0_12_34 77.0
R_0_11_34_3 Node0_11_34 Node1_11_34 12.320000000000002
C_0_11_34 Node0_11_34 GND 3.609375e-06
I_0_11_35 GND Node0_11_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_35_1 Node0_11_35 Node0_11_36 77.0
R_0_11_35_2 Node0_11_35 Node0_12_35 77.0
R_0_11_35_3 Node0_11_35 Node1_11_35 12.320000000000002
C_0_11_35 Node0_11_35 GND 3.609375e-06
I_0_11_36 GND Node0_11_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_36_1 Node0_11_36 Node0_11_37 77.0
R_0_11_36_2 Node0_11_36 Node0_12_36 77.0
R_0_11_36_3 Node0_11_36 Node1_11_36 12.320000000000002
C_0_11_36 Node0_11_36 GND 3.609375e-06
I_0_11_37 GND Node0_11_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_37_1 Node0_11_37 Node0_11_38 77.0
R_0_11_37_2 Node0_11_37 Node0_12_37 77.0
R_0_11_37_3 Node0_11_37 Node1_11_37 12.320000000000002
C_0_11_37 Node0_11_37 GND 3.609375e-06
I_0_11_38 GND Node0_11_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_38_1 Node0_11_38 Node0_11_39 77.0
R_0_11_38_2 Node0_11_38 Node0_12_38 77.0
R_0_11_38_3 Node0_11_38 Node1_11_38 12.320000000000002
C_0_11_38 Node0_11_38 GND 3.609375e-06
I_0_11_39 GND Node0_11_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_11_39_2 Node0_11_39 Node0_12_39 77.0
R_0_11_39_3 Node0_11_39 Node1_11_39 12.320000000000002
C_0_11_39 Node0_11_39 GND 3.609375e-06
I_0_12_0 GND Node0_12_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_0_1 Node0_12_0 Node0_12_1 77.0
R_0_12_0_2 Node0_12_0 Node0_13_0 77.0
R_0_12_0_3 Node0_12_0 Node1_12_0 12.320000000000002
C_0_12_0 Node0_12_0 GND 3.609375e-06
I_0_12_1 GND Node0_12_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_1_1 Node0_12_1 Node0_12_2 77.0
R_0_12_1_2 Node0_12_1 Node0_13_1 77.0
R_0_12_1_3 Node0_12_1 Node1_12_1 12.320000000000002
C_0_12_1 Node0_12_1 GND 3.609375e-06
I_0_12_2 GND Node0_12_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_2_1 Node0_12_2 Node0_12_3 77.0
R_0_12_2_2 Node0_12_2 Node0_13_2 77.0
R_0_12_2_3 Node0_12_2 Node1_12_2 12.320000000000002
C_0_12_2 Node0_12_2 GND 3.609375e-06
I_0_12_3 GND Node0_12_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_3_1 Node0_12_3 Node0_12_4 77.0
R_0_12_3_2 Node0_12_3 Node0_13_3 77.0
R_0_12_3_3 Node0_12_3 Node1_12_3 12.320000000000002
C_0_12_3 Node0_12_3 GND 3.609375e-06
I_0_12_4 GND Node0_12_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_4_1 Node0_12_4 Node0_12_5 77.0
R_0_12_4_2 Node0_12_4 Node0_13_4 77.0
R_0_12_4_3 Node0_12_4 Node1_12_4 12.320000000000002
C_0_12_4 Node0_12_4 GND 3.609375e-06
I_0_12_5 GND Node0_12_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_5_1 Node0_12_5 Node0_12_6 77.0
R_0_12_5_2 Node0_12_5 Node0_13_5 77.0
R_0_12_5_3 Node0_12_5 Node1_12_5 12.320000000000002
C_0_12_5 Node0_12_5 GND 3.609375e-06
I_0_12_6 GND Node0_12_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_6_1 Node0_12_6 Node0_12_7 77.0
R_0_12_6_2 Node0_12_6 Node0_13_6 77.0
R_0_12_6_3 Node0_12_6 Node1_12_6 12.320000000000002
C_0_12_6 Node0_12_6 GND 3.609375e-06
I_0_12_7 GND Node0_12_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_7_1 Node0_12_7 Node0_12_8 77.0
R_0_12_7_2 Node0_12_7 Node0_13_7 77.0
R_0_12_7_3 Node0_12_7 Node1_12_7 12.320000000000002
C_0_12_7 Node0_12_7 GND 3.609375e-06
I_0_12_8 GND Node0_12_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_8_1 Node0_12_8 Node0_12_9 77.0
R_0_12_8_2 Node0_12_8 Node0_13_8 77.0
R_0_12_8_3 Node0_12_8 Node1_12_8 12.320000000000002
C_0_12_8 Node0_12_8 GND 3.609375e-06
I_0_12_9 GND Node0_12_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_9_1 Node0_12_9 Node0_12_10 77.0
R_0_12_9_2 Node0_12_9 Node0_13_9 77.0
R_0_12_9_3 Node0_12_9 Node1_12_9 12.320000000000002
C_0_12_9 Node0_12_9 GND 3.609375e-06
I_0_12_10 GND Node0_12_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_10_1 Node0_12_10 Node0_12_11 77.0
R_0_12_10_2 Node0_12_10 Node0_13_10 77.0
R_0_12_10_3 Node0_12_10 Node1_12_10 12.320000000000002
C_0_12_10 Node0_12_10 GND 3.609375e-06
I_0_12_11 GND Node0_12_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_11_1 Node0_12_11 Node0_12_12 77.0
R_0_12_11_2 Node0_12_11 Node0_13_11 77.0
R_0_12_11_3 Node0_12_11 Node1_12_11 12.320000000000002
C_0_12_11 Node0_12_11 GND 3.609375e-06
I_0_12_12 GND Node0_12_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_12_1 Node0_12_12 Node0_12_13 77.0
R_0_12_12_2 Node0_12_12 Node0_13_12 77.0
R_0_12_12_3 Node0_12_12 Node1_12_12 12.320000000000002
C_0_12_12 Node0_12_12 GND 3.609375e-06
I_0_12_13 GND Node0_12_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_13_1 Node0_12_13 Node0_12_14 77.0
R_0_12_13_2 Node0_12_13 Node0_13_13 77.0
R_0_12_13_3 Node0_12_13 Node1_12_13 12.320000000000002
C_0_12_13 Node0_12_13 GND 3.609375e-06
I_0_12_14 GND Node0_12_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_14_1 Node0_12_14 Node0_12_15 77.0
R_0_12_14_2 Node0_12_14 Node0_13_14 77.0
R_0_12_14_3 Node0_12_14 Node1_12_14 12.320000000000002
C_0_12_14 Node0_12_14 GND 3.609375e-06
I_0_12_15 GND Node0_12_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_15_1 Node0_12_15 Node0_12_16 77.0
R_0_12_15_2 Node0_12_15 Node0_13_15 77.0
R_0_12_15_3 Node0_12_15 Node1_12_15 12.320000000000002
C_0_12_15 Node0_12_15 GND 3.609375e-06
I_0_12_16 GND Node0_12_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_16_1 Node0_12_16 Node0_12_17 77.0
R_0_12_16_2 Node0_12_16 Node0_13_16 77.0
R_0_12_16_3 Node0_12_16 Node1_12_16 12.320000000000002
C_0_12_16 Node0_12_16 GND 3.609375e-06
I_0_12_17 GND Node0_12_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_17_1 Node0_12_17 Node0_12_18 77.0
R_0_12_17_2 Node0_12_17 Node0_13_17 77.0
R_0_12_17_3 Node0_12_17 Node1_12_17 12.320000000000002
C_0_12_17 Node0_12_17 GND 3.609375e-06
I_0_12_18 GND Node0_12_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_18_1 Node0_12_18 Node0_12_19 77.0
R_0_12_18_2 Node0_12_18 Node0_13_18 77.0
R_0_12_18_3 Node0_12_18 Node1_12_18 12.320000000000002
C_0_12_18 Node0_12_18 GND 3.609375e-06
I_0_12_19 GND Node0_12_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_19_1 Node0_12_19 Node0_12_20 77.0
R_0_12_19_2 Node0_12_19 Node0_13_19 77.0
R_0_12_19_3 Node0_12_19 Node1_12_19 12.320000000000002
C_0_12_19 Node0_12_19 GND 3.609375e-06
I_0_12_20 GND Node0_12_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_20_1 Node0_12_20 Node0_12_21 77.0
R_0_12_20_2 Node0_12_20 Node0_13_20 77.0
R_0_12_20_3 Node0_12_20 Node1_12_20 12.320000000000002
C_0_12_20 Node0_12_20 GND 3.609375e-06
I_0_12_21 GND Node0_12_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_21_1 Node0_12_21 Node0_12_22 77.0
R_0_12_21_2 Node0_12_21 Node0_13_21 77.0
R_0_12_21_3 Node0_12_21 Node1_12_21 12.320000000000002
C_0_12_21 Node0_12_21 GND 3.609375e-06
I_0_12_22 GND Node0_12_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_22_1 Node0_12_22 Node0_12_23 77.0
R_0_12_22_2 Node0_12_22 Node0_13_22 77.0
R_0_12_22_3 Node0_12_22 Node1_12_22 12.320000000000002
C_0_12_22 Node0_12_22 GND 3.609375e-06
I_0_12_23 GND Node0_12_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_23_1 Node0_12_23 Node0_12_24 77.0
R_0_12_23_2 Node0_12_23 Node0_13_23 77.0
R_0_12_23_3 Node0_12_23 Node1_12_23 12.320000000000002
C_0_12_23 Node0_12_23 GND 3.609375e-06
I_0_12_24 GND Node0_12_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_24_1 Node0_12_24 Node0_12_25 77.0
R_0_12_24_2 Node0_12_24 Node0_13_24 77.0
R_0_12_24_3 Node0_12_24 Node1_12_24 12.320000000000002
C_0_12_24 Node0_12_24 GND 3.609375e-06
I_0_12_25 GND Node0_12_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_25_1 Node0_12_25 Node0_12_26 77.0
R_0_12_25_2 Node0_12_25 Node0_13_25 77.0
R_0_12_25_3 Node0_12_25 Node1_12_25 12.320000000000002
C_0_12_25 Node0_12_25 GND 3.609375e-06
I_0_12_26 GND Node0_12_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_26_1 Node0_12_26 Node0_12_27 77.0
R_0_12_26_2 Node0_12_26 Node0_13_26 77.0
R_0_12_26_3 Node0_12_26 Node1_12_26 12.320000000000002
C_0_12_26 Node0_12_26 GND 3.609375e-06
I_0_12_27 GND Node0_12_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_27_1 Node0_12_27 Node0_12_28 77.0
R_0_12_27_2 Node0_12_27 Node0_13_27 77.0
R_0_12_27_3 Node0_12_27 Node1_12_27 12.320000000000002
C_0_12_27 Node0_12_27 GND 3.609375e-06
I_0_12_28 GND Node0_12_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_28_1 Node0_12_28 Node0_12_29 77.0
R_0_12_28_2 Node0_12_28 Node0_13_28 77.0
R_0_12_28_3 Node0_12_28 Node1_12_28 12.320000000000002
C_0_12_28 Node0_12_28 GND 3.609375e-06
I_0_12_29 GND Node0_12_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_29_1 Node0_12_29 Node0_12_30 77.0
R_0_12_29_2 Node0_12_29 Node0_13_29 77.0
R_0_12_29_3 Node0_12_29 Node1_12_29 12.320000000000002
C_0_12_29 Node0_12_29 GND 3.609375e-06
I_0_12_30 GND Node0_12_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_30_1 Node0_12_30 Node0_12_31 77.0
R_0_12_30_2 Node0_12_30 Node0_13_30 77.0
R_0_12_30_3 Node0_12_30 Node1_12_30 12.320000000000002
C_0_12_30 Node0_12_30 GND 3.609375e-06
I_0_12_31 GND Node0_12_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_31_1 Node0_12_31 Node0_12_32 77.0
R_0_12_31_2 Node0_12_31 Node0_13_31 77.0
R_0_12_31_3 Node0_12_31 Node1_12_31 12.320000000000002
C_0_12_31 Node0_12_31 GND 3.609375e-06
I_0_12_32 GND Node0_12_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_32_1 Node0_12_32 Node0_12_33 77.0
R_0_12_32_2 Node0_12_32 Node0_13_32 77.0
R_0_12_32_3 Node0_12_32 Node1_12_32 12.320000000000002
C_0_12_32 Node0_12_32 GND 3.609375e-06
I_0_12_33 GND Node0_12_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_33_1 Node0_12_33 Node0_12_34 77.0
R_0_12_33_2 Node0_12_33 Node0_13_33 77.0
R_0_12_33_3 Node0_12_33 Node1_12_33 12.320000000000002
C_0_12_33 Node0_12_33 GND 3.609375e-06
I_0_12_34 GND Node0_12_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_34_1 Node0_12_34 Node0_12_35 77.0
R_0_12_34_2 Node0_12_34 Node0_13_34 77.0
R_0_12_34_3 Node0_12_34 Node1_12_34 12.320000000000002
C_0_12_34 Node0_12_34 GND 3.609375e-06
I_0_12_35 GND Node0_12_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_35_1 Node0_12_35 Node0_12_36 77.0
R_0_12_35_2 Node0_12_35 Node0_13_35 77.0
R_0_12_35_3 Node0_12_35 Node1_12_35 12.320000000000002
C_0_12_35 Node0_12_35 GND 3.609375e-06
I_0_12_36 GND Node0_12_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_36_1 Node0_12_36 Node0_12_37 77.0
R_0_12_36_2 Node0_12_36 Node0_13_36 77.0
R_0_12_36_3 Node0_12_36 Node1_12_36 12.320000000000002
C_0_12_36 Node0_12_36 GND 3.609375e-06
I_0_12_37 GND Node0_12_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_37_1 Node0_12_37 Node0_12_38 77.0
R_0_12_37_2 Node0_12_37 Node0_13_37 77.0
R_0_12_37_3 Node0_12_37 Node1_12_37 12.320000000000002
C_0_12_37 Node0_12_37 GND 3.609375e-06
I_0_12_38 GND Node0_12_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_38_1 Node0_12_38 Node0_12_39 77.0
R_0_12_38_2 Node0_12_38 Node0_13_38 77.0
R_0_12_38_3 Node0_12_38 Node1_12_38 12.320000000000002
C_0_12_38 Node0_12_38 GND 3.609375e-06
I_0_12_39 GND Node0_12_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_12_39_2 Node0_12_39 Node0_13_39 77.0
R_0_12_39_3 Node0_12_39 Node1_12_39 12.320000000000002
C_0_12_39 Node0_12_39 GND 3.609375e-06
I_0_13_0 GND Node0_13_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_0_1 Node0_13_0 Node0_13_1 77.0
R_0_13_0_2 Node0_13_0 Node0_14_0 77.0
R_0_13_0_3 Node0_13_0 Node1_13_0 12.320000000000002
C_0_13_0 Node0_13_0 GND 3.609375e-06
I_0_13_1 GND Node0_13_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_1_1 Node0_13_1 Node0_13_2 77.0
R_0_13_1_2 Node0_13_1 Node0_14_1 77.0
R_0_13_1_3 Node0_13_1 Node1_13_1 12.320000000000002
C_0_13_1 Node0_13_1 GND 3.609375e-06
I_0_13_2 GND Node0_13_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_2_1 Node0_13_2 Node0_13_3 77.0
R_0_13_2_2 Node0_13_2 Node0_14_2 77.0
R_0_13_2_3 Node0_13_2 Node1_13_2 12.320000000000002
C_0_13_2 Node0_13_2 GND 3.609375e-06
I_0_13_3 GND Node0_13_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_3_1 Node0_13_3 Node0_13_4 77.0
R_0_13_3_2 Node0_13_3 Node0_14_3 77.0
R_0_13_3_3 Node0_13_3 Node1_13_3 12.320000000000002
C_0_13_3 Node0_13_3 GND 3.609375e-06
I_0_13_4 GND Node0_13_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_4_1 Node0_13_4 Node0_13_5 77.0
R_0_13_4_2 Node0_13_4 Node0_14_4 77.0
R_0_13_4_3 Node0_13_4 Node1_13_4 12.320000000000002
C_0_13_4 Node0_13_4 GND 3.609375e-06
I_0_13_5 GND Node0_13_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_5_1 Node0_13_5 Node0_13_6 77.0
R_0_13_5_2 Node0_13_5 Node0_14_5 77.0
R_0_13_5_3 Node0_13_5 Node1_13_5 12.320000000000002
C_0_13_5 Node0_13_5 GND 3.609375e-06
I_0_13_6 GND Node0_13_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_6_1 Node0_13_6 Node0_13_7 77.0
R_0_13_6_2 Node0_13_6 Node0_14_6 77.0
R_0_13_6_3 Node0_13_6 Node1_13_6 12.320000000000002
C_0_13_6 Node0_13_6 GND 3.609375e-06
I_0_13_7 GND Node0_13_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_7_1 Node0_13_7 Node0_13_8 77.0
R_0_13_7_2 Node0_13_7 Node0_14_7 77.0
R_0_13_7_3 Node0_13_7 Node1_13_7 12.320000000000002
C_0_13_7 Node0_13_7 GND 3.609375e-06
I_0_13_8 GND Node0_13_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_8_1 Node0_13_8 Node0_13_9 77.0
R_0_13_8_2 Node0_13_8 Node0_14_8 77.0
R_0_13_8_3 Node0_13_8 Node1_13_8 12.320000000000002
C_0_13_8 Node0_13_8 GND 3.609375e-06
I_0_13_9 GND Node0_13_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_9_1 Node0_13_9 Node0_13_10 77.0
R_0_13_9_2 Node0_13_9 Node0_14_9 77.0
R_0_13_9_3 Node0_13_9 Node1_13_9 12.320000000000002
C_0_13_9 Node0_13_9 GND 3.609375e-06
I_0_13_10 GND Node0_13_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_10_1 Node0_13_10 Node0_13_11 77.0
R_0_13_10_2 Node0_13_10 Node0_14_10 77.0
R_0_13_10_3 Node0_13_10 Node1_13_10 12.320000000000002
C_0_13_10 Node0_13_10 GND 3.609375e-06
I_0_13_11 GND Node0_13_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_11_1 Node0_13_11 Node0_13_12 77.0
R_0_13_11_2 Node0_13_11 Node0_14_11 77.0
R_0_13_11_3 Node0_13_11 Node1_13_11 12.320000000000002
C_0_13_11 Node0_13_11 GND 3.609375e-06
I_0_13_12 GND Node0_13_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_12_1 Node0_13_12 Node0_13_13 77.0
R_0_13_12_2 Node0_13_12 Node0_14_12 77.0
R_0_13_12_3 Node0_13_12 Node1_13_12 12.320000000000002
C_0_13_12 Node0_13_12 GND 3.609375e-06
I_0_13_13 GND Node0_13_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_13_1 Node0_13_13 Node0_13_14 77.0
R_0_13_13_2 Node0_13_13 Node0_14_13 77.0
R_0_13_13_3 Node0_13_13 Node1_13_13 12.320000000000002
C_0_13_13 Node0_13_13 GND 3.609375e-06
I_0_13_14 GND Node0_13_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_14_1 Node0_13_14 Node0_13_15 77.0
R_0_13_14_2 Node0_13_14 Node0_14_14 77.0
R_0_13_14_3 Node0_13_14 Node1_13_14 12.320000000000002
C_0_13_14 Node0_13_14 GND 3.609375e-06
I_0_13_15 GND Node0_13_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_15_1 Node0_13_15 Node0_13_16 77.0
R_0_13_15_2 Node0_13_15 Node0_14_15 77.0
R_0_13_15_3 Node0_13_15 Node1_13_15 12.320000000000002
C_0_13_15 Node0_13_15 GND 3.609375e-06
I_0_13_16 GND Node0_13_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_16_1 Node0_13_16 Node0_13_17 77.0
R_0_13_16_2 Node0_13_16 Node0_14_16 77.0
R_0_13_16_3 Node0_13_16 Node1_13_16 12.320000000000002
C_0_13_16 Node0_13_16 GND 3.609375e-06
I_0_13_17 GND Node0_13_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_17_1 Node0_13_17 Node0_13_18 77.0
R_0_13_17_2 Node0_13_17 Node0_14_17 77.0
R_0_13_17_3 Node0_13_17 Node1_13_17 12.320000000000002
C_0_13_17 Node0_13_17 GND 3.609375e-06
I_0_13_18 GND Node0_13_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_18_1 Node0_13_18 Node0_13_19 77.0
R_0_13_18_2 Node0_13_18 Node0_14_18 77.0
R_0_13_18_3 Node0_13_18 Node1_13_18 12.320000000000002
C_0_13_18 Node0_13_18 GND 3.609375e-06
I_0_13_19 GND Node0_13_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_19_1 Node0_13_19 Node0_13_20 77.0
R_0_13_19_2 Node0_13_19 Node0_14_19 77.0
R_0_13_19_3 Node0_13_19 Node1_13_19 12.320000000000002
C_0_13_19 Node0_13_19 GND 3.609375e-06
I_0_13_20 GND Node0_13_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_20_1 Node0_13_20 Node0_13_21 77.0
R_0_13_20_2 Node0_13_20 Node0_14_20 77.0
R_0_13_20_3 Node0_13_20 Node1_13_20 12.320000000000002
C_0_13_20 Node0_13_20 GND 3.609375e-06
I_0_13_21 GND Node0_13_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_21_1 Node0_13_21 Node0_13_22 77.0
R_0_13_21_2 Node0_13_21 Node0_14_21 77.0
R_0_13_21_3 Node0_13_21 Node1_13_21 12.320000000000002
C_0_13_21 Node0_13_21 GND 3.609375e-06
I_0_13_22 GND Node0_13_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_22_1 Node0_13_22 Node0_13_23 77.0
R_0_13_22_2 Node0_13_22 Node0_14_22 77.0
R_0_13_22_3 Node0_13_22 Node1_13_22 12.320000000000002
C_0_13_22 Node0_13_22 GND 3.609375e-06
I_0_13_23 GND Node0_13_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_23_1 Node0_13_23 Node0_13_24 77.0
R_0_13_23_2 Node0_13_23 Node0_14_23 77.0
R_0_13_23_3 Node0_13_23 Node1_13_23 12.320000000000002
C_0_13_23 Node0_13_23 GND 3.609375e-06
I_0_13_24 GND Node0_13_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_24_1 Node0_13_24 Node0_13_25 77.0
R_0_13_24_2 Node0_13_24 Node0_14_24 77.0
R_0_13_24_3 Node0_13_24 Node1_13_24 12.320000000000002
C_0_13_24 Node0_13_24 GND 3.609375e-06
I_0_13_25 GND Node0_13_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_25_1 Node0_13_25 Node0_13_26 77.0
R_0_13_25_2 Node0_13_25 Node0_14_25 77.0
R_0_13_25_3 Node0_13_25 Node1_13_25 12.320000000000002
C_0_13_25 Node0_13_25 GND 3.609375e-06
I_0_13_26 GND Node0_13_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_26_1 Node0_13_26 Node0_13_27 77.0
R_0_13_26_2 Node0_13_26 Node0_14_26 77.0
R_0_13_26_3 Node0_13_26 Node1_13_26 12.320000000000002
C_0_13_26 Node0_13_26 GND 3.609375e-06
I_0_13_27 GND Node0_13_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_27_1 Node0_13_27 Node0_13_28 77.0
R_0_13_27_2 Node0_13_27 Node0_14_27 77.0
R_0_13_27_3 Node0_13_27 Node1_13_27 12.320000000000002
C_0_13_27 Node0_13_27 GND 3.609375e-06
I_0_13_28 GND Node0_13_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_28_1 Node0_13_28 Node0_13_29 77.0
R_0_13_28_2 Node0_13_28 Node0_14_28 77.0
R_0_13_28_3 Node0_13_28 Node1_13_28 12.320000000000002
C_0_13_28 Node0_13_28 GND 3.609375e-06
I_0_13_29 GND Node0_13_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_29_1 Node0_13_29 Node0_13_30 77.0
R_0_13_29_2 Node0_13_29 Node0_14_29 77.0
R_0_13_29_3 Node0_13_29 Node1_13_29 12.320000000000002
C_0_13_29 Node0_13_29 GND 3.609375e-06
I_0_13_30 GND Node0_13_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_30_1 Node0_13_30 Node0_13_31 77.0
R_0_13_30_2 Node0_13_30 Node0_14_30 77.0
R_0_13_30_3 Node0_13_30 Node1_13_30 12.320000000000002
C_0_13_30 Node0_13_30 GND 3.609375e-06
I_0_13_31 GND Node0_13_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_31_1 Node0_13_31 Node0_13_32 77.0
R_0_13_31_2 Node0_13_31 Node0_14_31 77.0
R_0_13_31_3 Node0_13_31 Node1_13_31 12.320000000000002
C_0_13_31 Node0_13_31 GND 3.609375e-06
I_0_13_32 GND Node0_13_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_32_1 Node0_13_32 Node0_13_33 77.0
R_0_13_32_2 Node0_13_32 Node0_14_32 77.0
R_0_13_32_3 Node0_13_32 Node1_13_32 12.320000000000002
C_0_13_32 Node0_13_32 GND 3.609375e-06
I_0_13_33 GND Node0_13_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_33_1 Node0_13_33 Node0_13_34 77.0
R_0_13_33_2 Node0_13_33 Node0_14_33 77.0
R_0_13_33_3 Node0_13_33 Node1_13_33 12.320000000000002
C_0_13_33 Node0_13_33 GND 3.609375e-06
I_0_13_34 GND Node0_13_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_34_1 Node0_13_34 Node0_13_35 77.0
R_0_13_34_2 Node0_13_34 Node0_14_34 77.0
R_0_13_34_3 Node0_13_34 Node1_13_34 12.320000000000002
C_0_13_34 Node0_13_34 GND 3.609375e-06
I_0_13_35 GND Node0_13_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_35_1 Node0_13_35 Node0_13_36 77.0
R_0_13_35_2 Node0_13_35 Node0_14_35 77.0
R_0_13_35_3 Node0_13_35 Node1_13_35 12.320000000000002
C_0_13_35 Node0_13_35 GND 3.609375e-06
I_0_13_36 GND Node0_13_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_36_1 Node0_13_36 Node0_13_37 77.0
R_0_13_36_2 Node0_13_36 Node0_14_36 77.0
R_0_13_36_3 Node0_13_36 Node1_13_36 12.320000000000002
C_0_13_36 Node0_13_36 GND 3.609375e-06
I_0_13_37 GND Node0_13_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_37_1 Node0_13_37 Node0_13_38 77.0
R_0_13_37_2 Node0_13_37 Node0_14_37 77.0
R_0_13_37_3 Node0_13_37 Node1_13_37 12.320000000000002
C_0_13_37 Node0_13_37 GND 3.609375e-06
I_0_13_38 GND Node0_13_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_38_1 Node0_13_38 Node0_13_39 77.0
R_0_13_38_2 Node0_13_38 Node0_14_38 77.0
R_0_13_38_3 Node0_13_38 Node1_13_38 12.320000000000002
C_0_13_38 Node0_13_38 GND 3.609375e-06
I_0_13_39 GND Node0_13_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_13_39_2 Node0_13_39 Node0_14_39 77.0
R_0_13_39_3 Node0_13_39 Node1_13_39 12.320000000000002
C_0_13_39 Node0_13_39 GND 3.609375e-06
I_0_14_0 GND Node0_14_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_0_1 Node0_14_0 Node0_14_1 77.0
R_0_14_0_2 Node0_14_0 Node0_15_0 77.0
R_0_14_0_3 Node0_14_0 Node1_14_0 12.320000000000002
C_0_14_0 Node0_14_0 GND 3.609375e-06
I_0_14_1 GND Node0_14_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_1_1 Node0_14_1 Node0_14_2 77.0
R_0_14_1_2 Node0_14_1 Node0_15_1 77.0
R_0_14_1_3 Node0_14_1 Node1_14_1 12.320000000000002
C_0_14_1 Node0_14_1 GND 3.609375e-06
I_0_14_2 GND Node0_14_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_2_1 Node0_14_2 Node0_14_3 77.0
R_0_14_2_2 Node0_14_2 Node0_15_2 77.0
R_0_14_2_3 Node0_14_2 Node1_14_2 12.320000000000002
C_0_14_2 Node0_14_2 GND 3.609375e-06
I_0_14_3 GND Node0_14_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_3_1 Node0_14_3 Node0_14_4 77.0
R_0_14_3_2 Node0_14_3 Node0_15_3 77.0
R_0_14_3_3 Node0_14_3 Node1_14_3 12.320000000000002
C_0_14_3 Node0_14_3 GND 3.609375e-06
I_0_14_4 GND Node0_14_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_4_1 Node0_14_4 Node0_14_5 77.0
R_0_14_4_2 Node0_14_4 Node0_15_4 77.0
R_0_14_4_3 Node0_14_4 Node1_14_4 12.320000000000002
C_0_14_4 Node0_14_4 GND 3.609375e-06
I_0_14_5 GND Node0_14_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_5_1 Node0_14_5 Node0_14_6 77.0
R_0_14_5_2 Node0_14_5 Node0_15_5 77.0
R_0_14_5_3 Node0_14_5 Node1_14_5 12.320000000000002
C_0_14_5 Node0_14_5 GND 3.609375e-06
I_0_14_6 GND Node0_14_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_6_1 Node0_14_6 Node0_14_7 77.0
R_0_14_6_2 Node0_14_6 Node0_15_6 77.0
R_0_14_6_3 Node0_14_6 Node1_14_6 12.320000000000002
C_0_14_6 Node0_14_6 GND 3.609375e-06
I_0_14_7 GND Node0_14_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_7_1 Node0_14_7 Node0_14_8 77.0
R_0_14_7_2 Node0_14_7 Node0_15_7 77.0
R_0_14_7_3 Node0_14_7 Node1_14_7 12.320000000000002
C_0_14_7 Node0_14_7 GND 3.609375e-06
I_0_14_8 GND Node0_14_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_8_1 Node0_14_8 Node0_14_9 77.0
R_0_14_8_2 Node0_14_8 Node0_15_8 77.0
R_0_14_8_3 Node0_14_8 Node1_14_8 12.320000000000002
C_0_14_8 Node0_14_8 GND 3.609375e-06
I_0_14_9 GND Node0_14_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_9_1 Node0_14_9 Node0_14_10 77.0
R_0_14_9_2 Node0_14_9 Node0_15_9 77.0
R_0_14_9_3 Node0_14_9 Node1_14_9 12.320000000000002
C_0_14_9 Node0_14_9 GND 3.609375e-06
I_0_14_10 GND Node0_14_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_10_1 Node0_14_10 Node0_14_11 77.0
R_0_14_10_2 Node0_14_10 Node0_15_10 77.0
R_0_14_10_3 Node0_14_10 Node1_14_10 12.320000000000002
C_0_14_10 Node0_14_10 GND 3.609375e-06
I_0_14_11 GND Node0_14_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_11_1 Node0_14_11 Node0_14_12 77.0
R_0_14_11_2 Node0_14_11 Node0_15_11 77.0
R_0_14_11_3 Node0_14_11 Node1_14_11 12.320000000000002
C_0_14_11 Node0_14_11 GND 3.609375e-06
I_0_14_12 GND Node0_14_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_12_1 Node0_14_12 Node0_14_13 77.0
R_0_14_12_2 Node0_14_12 Node0_15_12 77.0
R_0_14_12_3 Node0_14_12 Node1_14_12 12.320000000000002
C_0_14_12 Node0_14_12 GND 3.609375e-06
I_0_14_13 GND Node0_14_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_13_1 Node0_14_13 Node0_14_14 77.0
R_0_14_13_2 Node0_14_13 Node0_15_13 77.0
R_0_14_13_3 Node0_14_13 Node1_14_13 12.320000000000002
C_0_14_13 Node0_14_13 GND 3.609375e-06
I_0_14_14 GND Node0_14_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_14_1 Node0_14_14 Node0_14_15 77.0
R_0_14_14_2 Node0_14_14 Node0_15_14 77.0
R_0_14_14_3 Node0_14_14 Node1_14_14 12.320000000000002
C_0_14_14 Node0_14_14 GND 3.609375e-06
I_0_14_15 GND Node0_14_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_15_1 Node0_14_15 Node0_14_16 77.0
R_0_14_15_2 Node0_14_15 Node0_15_15 77.0
R_0_14_15_3 Node0_14_15 Node1_14_15 12.320000000000002
C_0_14_15 Node0_14_15 GND 3.609375e-06
I_0_14_16 GND Node0_14_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_16_1 Node0_14_16 Node0_14_17 77.0
R_0_14_16_2 Node0_14_16 Node0_15_16 77.0
R_0_14_16_3 Node0_14_16 Node1_14_16 12.320000000000002
C_0_14_16 Node0_14_16 GND 3.609375e-06
I_0_14_17 GND Node0_14_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_17_1 Node0_14_17 Node0_14_18 77.0
R_0_14_17_2 Node0_14_17 Node0_15_17 77.0
R_0_14_17_3 Node0_14_17 Node1_14_17 12.320000000000002
C_0_14_17 Node0_14_17 GND 3.609375e-06
I_0_14_18 GND Node0_14_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_18_1 Node0_14_18 Node0_14_19 77.0
R_0_14_18_2 Node0_14_18 Node0_15_18 77.0
R_0_14_18_3 Node0_14_18 Node1_14_18 12.320000000000002
C_0_14_18 Node0_14_18 GND 3.609375e-06
I_0_14_19 GND Node0_14_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_19_1 Node0_14_19 Node0_14_20 77.0
R_0_14_19_2 Node0_14_19 Node0_15_19 77.0
R_0_14_19_3 Node0_14_19 Node1_14_19 12.320000000000002
C_0_14_19 Node0_14_19 GND 3.609375e-06
I_0_14_20 GND Node0_14_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_20_1 Node0_14_20 Node0_14_21 77.0
R_0_14_20_2 Node0_14_20 Node0_15_20 77.0
R_0_14_20_3 Node0_14_20 Node1_14_20 12.320000000000002
C_0_14_20 Node0_14_20 GND 3.609375e-06
I_0_14_21 GND Node0_14_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_21_1 Node0_14_21 Node0_14_22 77.0
R_0_14_21_2 Node0_14_21 Node0_15_21 77.0
R_0_14_21_3 Node0_14_21 Node1_14_21 12.320000000000002
C_0_14_21 Node0_14_21 GND 3.609375e-06
I_0_14_22 GND Node0_14_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_22_1 Node0_14_22 Node0_14_23 77.0
R_0_14_22_2 Node0_14_22 Node0_15_22 77.0
R_0_14_22_3 Node0_14_22 Node1_14_22 12.320000000000002
C_0_14_22 Node0_14_22 GND 3.609375e-06
I_0_14_23 GND Node0_14_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_23_1 Node0_14_23 Node0_14_24 77.0
R_0_14_23_2 Node0_14_23 Node0_15_23 77.0
R_0_14_23_3 Node0_14_23 Node1_14_23 12.320000000000002
C_0_14_23 Node0_14_23 GND 3.609375e-06
I_0_14_24 GND Node0_14_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_24_1 Node0_14_24 Node0_14_25 77.0
R_0_14_24_2 Node0_14_24 Node0_15_24 77.0
R_0_14_24_3 Node0_14_24 Node1_14_24 12.320000000000002
C_0_14_24 Node0_14_24 GND 3.609375e-06
I_0_14_25 GND Node0_14_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_25_1 Node0_14_25 Node0_14_26 77.0
R_0_14_25_2 Node0_14_25 Node0_15_25 77.0
R_0_14_25_3 Node0_14_25 Node1_14_25 12.320000000000002
C_0_14_25 Node0_14_25 GND 3.609375e-06
I_0_14_26 GND Node0_14_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_26_1 Node0_14_26 Node0_14_27 77.0
R_0_14_26_2 Node0_14_26 Node0_15_26 77.0
R_0_14_26_3 Node0_14_26 Node1_14_26 12.320000000000002
C_0_14_26 Node0_14_26 GND 3.609375e-06
I_0_14_27 GND Node0_14_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_27_1 Node0_14_27 Node0_14_28 77.0
R_0_14_27_2 Node0_14_27 Node0_15_27 77.0
R_0_14_27_3 Node0_14_27 Node1_14_27 12.320000000000002
C_0_14_27 Node0_14_27 GND 3.609375e-06
I_0_14_28 GND Node0_14_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_28_1 Node0_14_28 Node0_14_29 77.0
R_0_14_28_2 Node0_14_28 Node0_15_28 77.0
R_0_14_28_3 Node0_14_28 Node1_14_28 12.320000000000002
C_0_14_28 Node0_14_28 GND 3.609375e-06
I_0_14_29 GND Node0_14_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_29_1 Node0_14_29 Node0_14_30 77.0
R_0_14_29_2 Node0_14_29 Node0_15_29 77.0
R_0_14_29_3 Node0_14_29 Node1_14_29 12.320000000000002
C_0_14_29 Node0_14_29 GND 3.609375e-06
I_0_14_30 GND Node0_14_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_30_1 Node0_14_30 Node0_14_31 77.0
R_0_14_30_2 Node0_14_30 Node0_15_30 77.0
R_0_14_30_3 Node0_14_30 Node1_14_30 12.320000000000002
C_0_14_30 Node0_14_30 GND 3.609375e-06
I_0_14_31 GND Node0_14_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_31_1 Node0_14_31 Node0_14_32 77.0
R_0_14_31_2 Node0_14_31 Node0_15_31 77.0
R_0_14_31_3 Node0_14_31 Node1_14_31 12.320000000000002
C_0_14_31 Node0_14_31 GND 3.609375e-06
I_0_14_32 GND Node0_14_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_32_1 Node0_14_32 Node0_14_33 77.0
R_0_14_32_2 Node0_14_32 Node0_15_32 77.0
R_0_14_32_3 Node0_14_32 Node1_14_32 12.320000000000002
C_0_14_32 Node0_14_32 GND 3.609375e-06
I_0_14_33 GND Node0_14_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_33_1 Node0_14_33 Node0_14_34 77.0
R_0_14_33_2 Node0_14_33 Node0_15_33 77.0
R_0_14_33_3 Node0_14_33 Node1_14_33 12.320000000000002
C_0_14_33 Node0_14_33 GND 3.609375e-06
I_0_14_34 GND Node0_14_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_34_1 Node0_14_34 Node0_14_35 77.0
R_0_14_34_2 Node0_14_34 Node0_15_34 77.0
R_0_14_34_3 Node0_14_34 Node1_14_34 12.320000000000002
C_0_14_34 Node0_14_34 GND 3.609375e-06
I_0_14_35 GND Node0_14_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_35_1 Node0_14_35 Node0_14_36 77.0
R_0_14_35_2 Node0_14_35 Node0_15_35 77.0
R_0_14_35_3 Node0_14_35 Node1_14_35 12.320000000000002
C_0_14_35 Node0_14_35 GND 3.609375e-06
I_0_14_36 GND Node0_14_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_36_1 Node0_14_36 Node0_14_37 77.0
R_0_14_36_2 Node0_14_36 Node0_15_36 77.0
R_0_14_36_3 Node0_14_36 Node1_14_36 12.320000000000002
C_0_14_36 Node0_14_36 GND 3.609375e-06
I_0_14_37 GND Node0_14_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_37_1 Node0_14_37 Node0_14_38 77.0
R_0_14_37_2 Node0_14_37 Node0_15_37 77.0
R_0_14_37_3 Node0_14_37 Node1_14_37 12.320000000000002
C_0_14_37 Node0_14_37 GND 3.609375e-06
I_0_14_38 GND Node0_14_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_38_1 Node0_14_38 Node0_14_39 77.0
R_0_14_38_2 Node0_14_38 Node0_15_38 77.0
R_0_14_38_3 Node0_14_38 Node1_14_38 12.320000000000002
C_0_14_38 Node0_14_38 GND 3.609375e-06
I_0_14_39 GND Node0_14_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_14_39_2 Node0_14_39 Node0_15_39 77.0
R_0_14_39_3 Node0_14_39 Node1_14_39 12.320000000000002
C_0_14_39 Node0_14_39 GND 3.609375e-06
I_0_15_0 GND Node0_15_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_0_1 Node0_15_0 Node0_15_1 77.0
R_0_15_0_2 Node0_15_0 Node0_16_0 77.0
R_0_15_0_3 Node0_15_0 Node1_15_0 12.320000000000002
C_0_15_0 Node0_15_0 GND 3.609375e-06
I_0_15_1 GND Node0_15_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_1_1 Node0_15_1 Node0_15_2 77.0
R_0_15_1_2 Node0_15_1 Node0_16_1 77.0
R_0_15_1_3 Node0_15_1 Node1_15_1 12.320000000000002
C_0_15_1 Node0_15_1 GND 3.609375e-06
I_0_15_2 GND Node0_15_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_2_1 Node0_15_2 Node0_15_3 77.0
R_0_15_2_2 Node0_15_2 Node0_16_2 77.0
R_0_15_2_3 Node0_15_2 Node1_15_2 12.320000000000002
C_0_15_2 Node0_15_2 GND 3.609375e-06
I_0_15_3 GND Node0_15_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_3_1 Node0_15_3 Node0_15_4 77.0
R_0_15_3_2 Node0_15_3 Node0_16_3 77.0
R_0_15_3_3 Node0_15_3 Node1_15_3 12.320000000000002
C_0_15_3 Node0_15_3 GND 3.609375e-06
I_0_15_4 GND Node0_15_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_4_1 Node0_15_4 Node0_15_5 77.0
R_0_15_4_2 Node0_15_4 Node0_16_4 77.0
R_0_15_4_3 Node0_15_4 Node1_15_4 12.320000000000002
C_0_15_4 Node0_15_4 GND 3.609375e-06
I_0_15_5 GND Node0_15_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_5_1 Node0_15_5 Node0_15_6 77.0
R_0_15_5_2 Node0_15_5 Node0_16_5 77.0
R_0_15_5_3 Node0_15_5 Node1_15_5 12.320000000000002
C_0_15_5 Node0_15_5 GND 3.609375e-06
I_0_15_6 GND Node0_15_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_6_1 Node0_15_6 Node0_15_7 77.0
R_0_15_6_2 Node0_15_6 Node0_16_6 77.0
R_0_15_6_3 Node0_15_6 Node1_15_6 12.320000000000002
C_0_15_6 Node0_15_6 GND 3.609375e-06
I_0_15_7 GND Node0_15_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_7_1 Node0_15_7 Node0_15_8 77.0
R_0_15_7_2 Node0_15_7 Node0_16_7 77.0
R_0_15_7_3 Node0_15_7 Node1_15_7 12.320000000000002
C_0_15_7 Node0_15_7 GND 3.609375e-06
I_0_15_8 GND Node0_15_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_8_1 Node0_15_8 Node0_15_9 77.0
R_0_15_8_2 Node0_15_8 Node0_16_8 77.0
R_0_15_8_3 Node0_15_8 Node1_15_8 12.320000000000002
C_0_15_8 Node0_15_8 GND 3.609375e-06
I_0_15_9 GND Node0_15_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_9_1 Node0_15_9 Node0_15_10 77.0
R_0_15_9_2 Node0_15_9 Node0_16_9 77.0
R_0_15_9_3 Node0_15_9 Node1_15_9 12.320000000000002
C_0_15_9 Node0_15_9 GND 3.609375e-06
I_0_15_10 GND Node0_15_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_10_1 Node0_15_10 Node0_15_11 77.0
R_0_15_10_2 Node0_15_10 Node0_16_10 77.0
R_0_15_10_3 Node0_15_10 Node1_15_10 12.320000000000002
C_0_15_10 Node0_15_10 GND 3.609375e-06
I_0_15_11 GND Node0_15_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_11_1 Node0_15_11 Node0_15_12 77.0
R_0_15_11_2 Node0_15_11 Node0_16_11 77.0
R_0_15_11_3 Node0_15_11 Node1_15_11 12.320000000000002
C_0_15_11 Node0_15_11 GND 3.609375e-06
I_0_15_12 GND Node0_15_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_12_1 Node0_15_12 Node0_15_13 77.0
R_0_15_12_2 Node0_15_12 Node0_16_12 77.0
R_0_15_12_3 Node0_15_12 Node1_15_12 12.320000000000002
C_0_15_12 Node0_15_12 GND 3.609375e-06
I_0_15_13 GND Node0_15_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_13_1 Node0_15_13 Node0_15_14 77.0
R_0_15_13_2 Node0_15_13 Node0_16_13 77.0
R_0_15_13_3 Node0_15_13 Node1_15_13 12.320000000000002
C_0_15_13 Node0_15_13 GND 3.609375e-06
I_0_15_14 GND Node0_15_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_14_1 Node0_15_14 Node0_15_15 77.0
R_0_15_14_2 Node0_15_14 Node0_16_14 77.0
R_0_15_14_3 Node0_15_14 Node1_15_14 12.320000000000002
C_0_15_14 Node0_15_14 GND 3.609375e-06
I_0_15_15 GND Node0_15_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_15_1 Node0_15_15 Node0_15_16 77.0
R_0_15_15_2 Node0_15_15 Node0_16_15 77.0
R_0_15_15_3 Node0_15_15 Node1_15_15 12.320000000000002
C_0_15_15 Node0_15_15 GND 3.609375e-06
I_0_15_16 GND Node0_15_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_16_1 Node0_15_16 Node0_15_17 77.0
R_0_15_16_2 Node0_15_16 Node0_16_16 77.0
R_0_15_16_3 Node0_15_16 Node1_15_16 12.320000000000002
C_0_15_16 Node0_15_16 GND 3.609375e-06
I_0_15_17 GND Node0_15_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_17_1 Node0_15_17 Node0_15_18 77.0
R_0_15_17_2 Node0_15_17 Node0_16_17 77.0
R_0_15_17_3 Node0_15_17 Node1_15_17 12.320000000000002
C_0_15_17 Node0_15_17 GND 3.609375e-06
I_0_15_18 GND Node0_15_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_18_1 Node0_15_18 Node0_15_19 77.0
R_0_15_18_2 Node0_15_18 Node0_16_18 77.0
R_0_15_18_3 Node0_15_18 Node1_15_18 12.320000000000002
C_0_15_18 Node0_15_18 GND 3.609375e-06
I_0_15_19 GND Node0_15_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_19_1 Node0_15_19 Node0_15_20 77.0
R_0_15_19_2 Node0_15_19 Node0_16_19 77.0
R_0_15_19_3 Node0_15_19 Node1_15_19 12.320000000000002
C_0_15_19 Node0_15_19 GND 3.609375e-06
I_0_15_20 GND Node0_15_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_20_1 Node0_15_20 Node0_15_21 77.0
R_0_15_20_2 Node0_15_20 Node0_16_20 77.0
R_0_15_20_3 Node0_15_20 Node1_15_20 12.320000000000002
C_0_15_20 Node0_15_20 GND 3.609375e-06
I_0_15_21 GND Node0_15_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_21_1 Node0_15_21 Node0_15_22 77.0
R_0_15_21_2 Node0_15_21 Node0_16_21 77.0
R_0_15_21_3 Node0_15_21 Node1_15_21 12.320000000000002
C_0_15_21 Node0_15_21 GND 3.609375e-06
I_0_15_22 GND Node0_15_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_22_1 Node0_15_22 Node0_15_23 77.0
R_0_15_22_2 Node0_15_22 Node0_16_22 77.0
R_0_15_22_3 Node0_15_22 Node1_15_22 12.320000000000002
C_0_15_22 Node0_15_22 GND 3.609375e-06
I_0_15_23 GND Node0_15_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_23_1 Node0_15_23 Node0_15_24 77.0
R_0_15_23_2 Node0_15_23 Node0_16_23 77.0
R_0_15_23_3 Node0_15_23 Node1_15_23 12.320000000000002
C_0_15_23 Node0_15_23 GND 3.609375e-06
I_0_15_24 GND Node0_15_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_24_1 Node0_15_24 Node0_15_25 77.0
R_0_15_24_2 Node0_15_24 Node0_16_24 77.0
R_0_15_24_3 Node0_15_24 Node1_15_24 12.320000000000002
C_0_15_24 Node0_15_24 GND 3.609375e-06
I_0_15_25 GND Node0_15_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_25_1 Node0_15_25 Node0_15_26 77.0
R_0_15_25_2 Node0_15_25 Node0_16_25 77.0
R_0_15_25_3 Node0_15_25 Node1_15_25 12.320000000000002
C_0_15_25 Node0_15_25 GND 3.609375e-06
I_0_15_26 GND Node0_15_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_26_1 Node0_15_26 Node0_15_27 77.0
R_0_15_26_2 Node0_15_26 Node0_16_26 77.0
R_0_15_26_3 Node0_15_26 Node1_15_26 12.320000000000002
C_0_15_26 Node0_15_26 GND 3.609375e-06
I_0_15_27 GND Node0_15_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_27_1 Node0_15_27 Node0_15_28 77.0
R_0_15_27_2 Node0_15_27 Node0_16_27 77.0
R_0_15_27_3 Node0_15_27 Node1_15_27 12.320000000000002
C_0_15_27 Node0_15_27 GND 3.609375e-06
I_0_15_28 GND Node0_15_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_28_1 Node0_15_28 Node0_15_29 77.0
R_0_15_28_2 Node0_15_28 Node0_16_28 77.0
R_0_15_28_3 Node0_15_28 Node1_15_28 12.320000000000002
C_0_15_28 Node0_15_28 GND 3.609375e-06
I_0_15_29 GND Node0_15_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_29_1 Node0_15_29 Node0_15_30 77.0
R_0_15_29_2 Node0_15_29 Node0_16_29 77.0
R_0_15_29_3 Node0_15_29 Node1_15_29 12.320000000000002
C_0_15_29 Node0_15_29 GND 3.609375e-06
I_0_15_30 GND Node0_15_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_30_1 Node0_15_30 Node0_15_31 77.0
R_0_15_30_2 Node0_15_30 Node0_16_30 77.0
R_0_15_30_3 Node0_15_30 Node1_15_30 12.320000000000002
C_0_15_30 Node0_15_30 GND 3.609375e-06
I_0_15_31 GND Node0_15_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_31_1 Node0_15_31 Node0_15_32 77.0
R_0_15_31_2 Node0_15_31 Node0_16_31 77.0
R_0_15_31_3 Node0_15_31 Node1_15_31 12.320000000000002
C_0_15_31 Node0_15_31 GND 3.609375e-06
I_0_15_32 GND Node0_15_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_32_1 Node0_15_32 Node0_15_33 77.0
R_0_15_32_2 Node0_15_32 Node0_16_32 77.0
R_0_15_32_3 Node0_15_32 Node1_15_32 12.320000000000002
C_0_15_32 Node0_15_32 GND 3.609375e-06
I_0_15_33 GND Node0_15_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_33_1 Node0_15_33 Node0_15_34 77.0
R_0_15_33_2 Node0_15_33 Node0_16_33 77.0
R_0_15_33_3 Node0_15_33 Node1_15_33 12.320000000000002
C_0_15_33 Node0_15_33 GND 3.609375e-06
I_0_15_34 GND Node0_15_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_34_1 Node0_15_34 Node0_15_35 77.0
R_0_15_34_2 Node0_15_34 Node0_16_34 77.0
R_0_15_34_3 Node0_15_34 Node1_15_34 12.320000000000002
C_0_15_34 Node0_15_34 GND 3.609375e-06
I_0_15_35 GND Node0_15_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_35_1 Node0_15_35 Node0_15_36 77.0
R_0_15_35_2 Node0_15_35 Node0_16_35 77.0
R_0_15_35_3 Node0_15_35 Node1_15_35 12.320000000000002
C_0_15_35 Node0_15_35 GND 3.609375e-06
I_0_15_36 GND Node0_15_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_36_1 Node0_15_36 Node0_15_37 77.0
R_0_15_36_2 Node0_15_36 Node0_16_36 77.0
R_0_15_36_3 Node0_15_36 Node1_15_36 12.320000000000002
C_0_15_36 Node0_15_36 GND 3.609375e-06
I_0_15_37 GND Node0_15_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_37_1 Node0_15_37 Node0_15_38 77.0
R_0_15_37_2 Node0_15_37 Node0_16_37 77.0
R_0_15_37_3 Node0_15_37 Node1_15_37 12.320000000000002
C_0_15_37 Node0_15_37 GND 3.609375e-06
I_0_15_38 GND Node0_15_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_38_1 Node0_15_38 Node0_15_39 77.0
R_0_15_38_2 Node0_15_38 Node0_16_38 77.0
R_0_15_38_3 Node0_15_38 Node1_15_38 12.320000000000002
C_0_15_38 Node0_15_38 GND 3.609375e-06
I_0_15_39 GND Node0_15_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_15_39_2 Node0_15_39 Node0_16_39 77.0
R_0_15_39_3 Node0_15_39 Node1_15_39 12.320000000000002
C_0_15_39 Node0_15_39 GND 3.609375e-06
I_0_16_0 GND Node0_16_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_0_1 Node0_16_0 Node0_16_1 77.0
R_0_16_0_2 Node0_16_0 Node0_17_0 77.0
R_0_16_0_3 Node0_16_0 Node1_16_0 12.320000000000002
C_0_16_0 Node0_16_0 GND 3.609375e-06
I_0_16_1 GND Node0_16_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_1_1 Node0_16_1 Node0_16_2 77.0
R_0_16_1_2 Node0_16_1 Node0_17_1 77.0
R_0_16_1_3 Node0_16_1 Node1_16_1 12.320000000000002
C_0_16_1 Node0_16_1 GND 3.609375e-06
I_0_16_2 GND Node0_16_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_2_1 Node0_16_2 Node0_16_3 77.0
R_0_16_2_2 Node0_16_2 Node0_17_2 77.0
R_0_16_2_3 Node0_16_2 Node1_16_2 12.320000000000002
C_0_16_2 Node0_16_2 GND 3.609375e-06
I_0_16_3 GND Node0_16_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_3_1 Node0_16_3 Node0_16_4 77.0
R_0_16_3_2 Node0_16_3 Node0_17_3 77.0
R_0_16_3_3 Node0_16_3 Node1_16_3 12.320000000000002
C_0_16_3 Node0_16_3 GND 3.609375e-06
I_0_16_4 GND Node0_16_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_4_1 Node0_16_4 Node0_16_5 77.0
R_0_16_4_2 Node0_16_4 Node0_17_4 77.0
R_0_16_4_3 Node0_16_4 Node1_16_4 12.320000000000002
C_0_16_4 Node0_16_4 GND 3.609375e-06
I_0_16_5 GND Node0_16_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_5_1 Node0_16_5 Node0_16_6 77.0
R_0_16_5_2 Node0_16_5 Node0_17_5 77.0
R_0_16_5_3 Node0_16_5 Node1_16_5 12.320000000000002
C_0_16_5 Node0_16_5 GND 3.609375e-06
I_0_16_6 GND Node0_16_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_6_1 Node0_16_6 Node0_16_7 77.0
R_0_16_6_2 Node0_16_6 Node0_17_6 77.0
R_0_16_6_3 Node0_16_6 Node1_16_6 12.320000000000002
C_0_16_6 Node0_16_6 GND 3.609375e-06
I_0_16_7 GND Node0_16_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_7_1 Node0_16_7 Node0_16_8 77.0
R_0_16_7_2 Node0_16_7 Node0_17_7 77.0
R_0_16_7_3 Node0_16_7 Node1_16_7 12.320000000000002
C_0_16_7 Node0_16_7 GND 3.609375e-06
I_0_16_8 GND Node0_16_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_8_1 Node0_16_8 Node0_16_9 77.0
R_0_16_8_2 Node0_16_8 Node0_17_8 77.0
R_0_16_8_3 Node0_16_8 Node1_16_8 12.320000000000002
C_0_16_8 Node0_16_8 GND 3.609375e-06
I_0_16_9 GND Node0_16_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_9_1 Node0_16_9 Node0_16_10 77.0
R_0_16_9_2 Node0_16_9 Node0_17_9 77.0
R_0_16_9_3 Node0_16_9 Node1_16_9 12.320000000000002
C_0_16_9 Node0_16_9 GND 3.609375e-06
I_0_16_10 GND Node0_16_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_10_1 Node0_16_10 Node0_16_11 77.0
R_0_16_10_2 Node0_16_10 Node0_17_10 77.0
R_0_16_10_3 Node0_16_10 Node1_16_10 12.320000000000002
C_0_16_10 Node0_16_10 GND 3.609375e-06
I_0_16_11 GND Node0_16_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_11_1 Node0_16_11 Node0_16_12 77.0
R_0_16_11_2 Node0_16_11 Node0_17_11 77.0
R_0_16_11_3 Node0_16_11 Node1_16_11 12.320000000000002
C_0_16_11 Node0_16_11 GND 3.609375e-06
I_0_16_12 GND Node0_16_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_12_1 Node0_16_12 Node0_16_13 77.0
R_0_16_12_2 Node0_16_12 Node0_17_12 77.0
R_0_16_12_3 Node0_16_12 Node1_16_12 12.320000000000002
C_0_16_12 Node0_16_12 GND 3.609375e-06
I_0_16_13 GND Node0_16_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_13_1 Node0_16_13 Node0_16_14 77.0
R_0_16_13_2 Node0_16_13 Node0_17_13 77.0
R_0_16_13_3 Node0_16_13 Node1_16_13 12.320000000000002
C_0_16_13 Node0_16_13 GND 3.609375e-06
I_0_16_14 GND Node0_16_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_14_1 Node0_16_14 Node0_16_15 77.0
R_0_16_14_2 Node0_16_14 Node0_17_14 77.0
R_0_16_14_3 Node0_16_14 Node1_16_14 12.320000000000002
C_0_16_14 Node0_16_14 GND 3.609375e-06
I_0_16_15 GND Node0_16_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_15_1 Node0_16_15 Node0_16_16 77.0
R_0_16_15_2 Node0_16_15 Node0_17_15 77.0
R_0_16_15_3 Node0_16_15 Node1_16_15 12.320000000000002
C_0_16_15 Node0_16_15 GND 3.609375e-06
I_0_16_16 GND Node0_16_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_16_1 Node0_16_16 Node0_16_17 77.0
R_0_16_16_2 Node0_16_16 Node0_17_16 77.0
R_0_16_16_3 Node0_16_16 Node1_16_16 12.320000000000002
C_0_16_16 Node0_16_16 GND 3.609375e-06
I_0_16_17 GND Node0_16_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_17_1 Node0_16_17 Node0_16_18 77.0
R_0_16_17_2 Node0_16_17 Node0_17_17 77.0
R_0_16_17_3 Node0_16_17 Node1_16_17 12.320000000000002
C_0_16_17 Node0_16_17 GND 3.609375e-06
I_0_16_18 GND Node0_16_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_18_1 Node0_16_18 Node0_16_19 77.0
R_0_16_18_2 Node0_16_18 Node0_17_18 77.0
R_0_16_18_3 Node0_16_18 Node1_16_18 12.320000000000002
C_0_16_18 Node0_16_18 GND 3.609375e-06
I_0_16_19 GND Node0_16_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_19_1 Node0_16_19 Node0_16_20 77.0
R_0_16_19_2 Node0_16_19 Node0_17_19 77.0
R_0_16_19_3 Node0_16_19 Node1_16_19 12.320000000000002
C_0_16_19 Node0_16_19 GND 3.609375e-06
I_0_16_20 GND Node0_16_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_20_1 Node0_16_20 Node0_16_21 77.0
R_0_16_20_2 Node0_16_20 Node0_17_20 77.0
R_0_16_20_3 Node0_16_20 Node1_16_20 12.320000000000002
C_0_16_20 Node0_16_20 GND 3.609375e-06
I_0_16_21 GND Node0_16_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_21_1 Node0_16_21 Node0_16_22 77.0
R_0_16_21_2 Node0_16_21 Node0_17_21 77.0
R_0_16_21_3 Node0_16_21 Node1_16_21 12.320000000000002
C_0_16_21 Node0_16_21 GND 3.609375e-06
I_0_16_22 GND Node0_16_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_22_1 Node0_16_22 Node0_16_23 77.0
R_0_16_22_2 Node0_16_22 Node0_17_22 77.0
R_0_16_22_3 Node0_16_22 Node1_16_22 12.320000000000002
C_0_16_22 Node0_16_22 GND 3.609375e-06
I_0_16_23 GND Node0_16_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_23_1 Node0_16_23 Node0_16_24 77.0
R_0_16_23_2 Node0_16_23 Node0_17_23 77.0
R_0_16_23_3 Node0_16_23 Node1_16_23 12.320000000000002
C_0_16_23 Node0_16_23 GND 3.609375e-06
I_0_16_24 GND Node0_16_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_24_1 Node0_16_24 Node0_16_25 77.0
R_0_16_24_2 Node0_16_24 Node0_17_24 77.0
R_0_16_24_3 Node0_16_24 Node1_16_24 12.320000000000002
C_0_16_24 Node0_16_24 GND 3.609375e-06
I_0_16_25 GND Node0_16_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_25_1 Node0_16_25 Node0_16_26 77.0
R_0_16_25_2 Node0_16_25 Node0_17_25 77.0
R_0_16_25_3 Node0_16_25 Node1_16_25 12.320000000000002
C_0_16_25 Node0_16_25 GND 3.609375e-06
I_0_16_26 GND Node0_16_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_26_1 Node0_16_26 Node0_16_27 77.0
R_0_16_26_2 Node0_16_26 Node0_17_26 77.0
R_0_16_26_3 Node0_16_26 Node1_16_26 12.320000000000002
C_0_16_26 Node0_16_26 GND 3.609375e-06
I_0_16_27 GND Node0_16_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_27_1 Node0_16_27 Node0_16_28 77.0
R_0_16_27_2 Node0_16_27 Node0_17_27 77.0
R_0_16_27_3 Node0_16_27 Node1_16_27 12.320000000000002
C_0_16_27 Node0_16_27 GND 3.609375e-06
I_0_16_28 GND Node0_16_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_28_1 Node0_16_28 Node0_16_29 77.0
R_0_16_28_2 Node0_16_28 Node0_17_28 77.0
R_0_16_28_3 Node0_16_28 Node1_16_28 12.320000000000002
C_0_16_28 Node0_16_28 GND 3.609375e-06
I_0_16_29 GND Node0_16_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_29_1 Node0_16_29 Node0_16_30 77.0
R_0_16_29_2 Node0_16_29 Node0_17_29 77.0
R_0_16_29_3 Node0_16_29 Node1_16_29 12.320000000000002
C_0_16_29 Node0_16_29 GND 3.609375e-06
I_0_16_30 GND Node0_16_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_30_1 Node0_16_30 Node0_16_31 77.0
R_0_16_30_2 Node0_16_30 Node0_17_30 77.0
R_0_16_30_3 Node0_16_30 Node1_16_30 12.320000000000002
C_0_16_30 Node0_16_30 GND 3.609375e-06
I_0_16_31 GND Node0_16_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_31_1 Node0_16_31 Node0_16_32 77.0
R_0_16_31_2 Node0_16_31 Node0_17_31 77.0
R_0_16_31_3 Node0_16_31 Node1_16_31 12.320000000000002
C_0_16_31 Node0_16_31 GND 3.609375e-06
I_0_16_32 GND Node0_16_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_32_1 Node0_16_32 Node0_16_33 77.0
R_0_16_32_2 Node0_16_32 Node0_17_32 77.0
R_0_16_32_3 Node0_16_32 Node1_16_32 12.320000000000002
C_0_16_32 Node0_16_32 GND 3.609375e-06
I_0_16_33 GND Node0_16_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_33_1 Node0_16_33 Node0_16_34 77.0
R_0_16_33_2 Node0_16_33 Node0_17_33 77.0
R_0_16_33_3 Node0_16_33 Node1_16_33 12.320000000000002
C_0_16_33 Node0_16_33 GND 3.609375e-06
I_0_16_34 GND Node0_16_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_34_1 Node0_16_34 Node0_16_35 77.0
R_0_16_34_2 Node0_16_34 Node0_17_34 77.0
R_0_16_34_3 Node0_16_34 Node1_16_34 12.320000000000002
C_0_16_34 Node0_16_34 GND 3.609375e-06
I_0_16_35 GND Node0_16_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_35_1 Node0_16_35 Node0_16_36 77.0
R_0_16_35_2 Node0_16_35 Node0_17_35 77.0
R_0_16_35_3 Node0_16_35 Node1_16_35 12.320000000000002
C_0_16_35 Node0_16_35 GND 3.609375e-06
I_0_16_36 GND Node0_16_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_36_1 Node0_16_36 Node0_16_37 77.0
R_0_16_36_2 Node0_16_36 Node0_17_36 77.0
R_0_16_36_3 Node0_16_36 Node1_16_36 12.320000000000002
C_0_16_36 Node0_16_36 GND 3.609375e-06
I_0_16_37 GND Node0_16_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_37_1 Node0_16_37 Node0_16_38 77.0
R_0_16_37_2 Node0_16_37 Node0_17_37 77.0
R_0_16_37_3 Node0_16_37 Node1_16_37 12.320000000000002
C_0_16_37 Node0_16_37 GND 3.609375e-06
I_0_16_38 GND Node0_16_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_38_1 Node0_16_38 Node0_16_39 77.0
R_0_16_38_2 Node0_16_38 Node0_17_38 77.0
R_0_16_38_3 Node0_16_38 Node1_16_38 12.320000000000002
C_0_16_38 Node0_16_38 GND 3.609375e-06
I_0_16_39 GND Node0_16_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_16_39_2 Node0_16_39 Node0_17_39 77.0
R_0_16_39_3 Node0_16_39 Node1_16_39 12.320000000000002
C_0_16_39 Node0_16_39 GND 3.609375e-06
I_0_17_0 GND Node0_17_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_0_1 Node0_17_0 Node0_17_1 77.0
R_0_17_0_2 Node0_17_0 Node0_18_0 77.0
R_0_17_0_3 Node0_17_0 Node1_17_0 12.320000000000002
C_0_17_0 Node0_17_0 GND 3.609375e-06
I_0_17_1 GND Node0_17_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_1_1 Node0_17_1 Node0_17_2 77.0
R_0_17_1_2 Node0_17_1 Node0_18_1 77.0
R_0_17_1_3 Node0_17_1 Node1_17_1 12.320000000000002
C_0_17_1 Node0_17_1 GND 3.609375e-06
I_0_17_2 GND Node0_17_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_2_1 Node0_17_2 Node0_17_3 77.0
R_0_17_2_2 Node0_17_2 Node0_18_2 77.0
R_0_17_2_3 Node0_17_2 Node1_17_2 12.320000000000002
C_0_17_2 Node0_17_2 GND 3.609375e-06
I_0_17_3 GND Node0_17_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_3_1 Node0_17_3 Node0_17_4 77.0
R_0_17_3_2 Node0_17_3 Node0_18_3 77.0
R_0_17_3_3 Node0_17_3 Node1_17_3 12.320000000000002
C_0_17_3 Node0_17_3 GND 3.609375e-06
I_0_17_4 GND Node0_17_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_4_1 Node0_17_4 Node0_17_5 77.0
R_0_17_4_2 Node0_17_4 Node0_18_4 77.0
R_0_17_4_3 Node0_17_4 Node1_17_4 12.320000000000002
C_0_17_4 Node0_17_4 GND 3.609375e-06
I_0_17_5 GND Node0_17_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_5_1 Node0_17_5 Node0_17_6 77.0
R_0_17_5_2 Node0_17_5 Node0_18_5 77.0
R_0_17_5_3 Node0_17_5 Node1_17_5 12.320000000000002
C_0_17_5 Node0_17_5 GND 3.609375e-06
I_0_17_6 GND Node0_17_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_6_1 Node0_17_6 Node0_17_7 77.0
R_0_17_6_2 Node0_17_6 Node0_18_6 77.0
R_0_17_6_3 Node0_17_6 Node1_17_6 12.320000000000002
C_0_17_6 Node0_17_6 GND 3.609375e-06
I_0_17_7 GND Node0_17_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_7_1 Node0_17_7 Node0_17_8 77.0
R_0_17_7_2 Node0_17_7 Node0_18_7 77.0
R_0_17_7_3 Node0_17_7 Node1_17_7 12.320000000000002
C_0_17_7 Node0_17_7 GND 3.609375e-06
I_0_17_8 GND Node0_17_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_8_1 Node0_17_8 Node0_17_9 77.0
R_0_17_8_2 Node0_17_8 Node0_18_8 77.0
R_0_17_8_3 Node0_17_8 Node1_17_8 12.320000000000002
C_0_17_8 Node0_17_8 GND 3.609375e-06
I_0_17_9 GND Node0_17_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_9_1 Node0_17_9 Node0_17_10 77.0
R_0_17_9_2 Node0_17_9 Node0_18_9 77.0
R_0_17_9_3 Node0_17_9 Node1_17_9 12.320000000000002
C_0_17_9 Node0_17_9 GND 3.609375e-06
I_0_17_10 GND Node0_17_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_10_1 Node0_17_10 Node0_17_11 77.0
R_0_17_10_2 Node0_17_10 Node0_18_10 77.0
R_0_17_10_3 Node0_17_10 Node1_17_10 12.320000000000002
C_0_17_10 Node0_17_10 GND 3.609375e-06
I_0_17_11 GND Node0_17_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_11_1 Node0_17_11 Node0_17_12 77.0
R_0_17_11_2 Node0_17_11 Node0_18_11 77.0
R_0_17_11_3 Node0_17_11 Node1_17_11 12.320000000000002
C_0_17_11 Node0_17_11 GND 3.609375e-06
I_0_17_12 GND Node0_17_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_12_1 Node0_17_12 Node0_17_13 77.0
R_0_17_12_2 Node0_17_12 Node0_18_12 77.0
R_0_17_12_3 Node0_17_12 Node1_17_12 12.320000000000002
C_0_17_12 Node0_17_12 GND 3.609375e-06
I_0_17_13 GND Node0_17_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_13_1 Node0_17_13 Node0_17_14 77.0
R_0_17_13_2 Node0_17_13 Node0_18_13 77.0
R_0_17_13_3 Node0_17_13 Node1_17_13 12.320000000000002
C_0_17_13 Node0_17_13 GND 3.609375e-06
I_0_17_14 GND Node0_17_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_14_1 Node0_17_14 Node0_17_15 77.0
R_0_17_14_2 Node0_17_14 Node0_18_14 77.0
R_0_17_14_3 Node0_17_14 Node1_17_14 12.320000000000002
C_0_17_14 Node0_17_14 GND 3.609375e-06
I_0_17_15 GND Node0_17_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_15_1 Node0_17_15 Node0_17_16 77.0
R_0_17_15_2 Node0_17_15 Node0_18_15 77.0
R_0_17_15_3 Node0_17_15 Node1_17_15 12.320000000000002
C_0_17_15 Node0_17_15 GND 3.609375e-06
I_0_17_16 GND Node0_17_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_16_1 Node0_17_16 Node0_17_17 77.0
R_0_17_16_2 Node0_17_16 Node0_18_16 77.0
R_0_17_16_3 Node0_17_16 Node1_17_16 12.320000000000002
C_0_17_16 Node0_17_16 GND 3.609375e-06
I_0_17_17 GND Node0_17_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_17_1 Node0_17_17 Node0_17_18 77.0
R_0_17_17_2 Node0_17_17 Node0_18_17 77.0
R_0_17_17_3 Node0_17_17 Node1_17_17 12.320000000000002
C_0_17_17 Node0_17_17 GND 3.609375e-06
I_0_17_18 GND Node0_17_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_18_1 Node0_17_18 Node0_17_19 77.0
R_0_17_18_2 Node0_17_18 Node0_18_18 77.0
R_0_17_18_3 Node0_17_18 Node1_17_18 12.320000000000002
C_0_17_18 Node0_17_18 GND 3.609375e-06
I_0_17_19 GND Node0_17_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_19_1 Node0_17_19 Node0_17_20 77.0
R_0_17_19_2 Node0_17_19 Node0_18_19 77.0
R_0_17_19_3 Node0_17_19 Node1_17_19 12.320000000000002
C_0_17_19 Node0_17_19 GND 3.609375e-06
I_0_17_20 GND Node0_17_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_20_1 Node0_17_20 Node0_17_21 77.0
R_0_17_20_2 Node0_17_20 Node0_18_20 77.0
R_0_17_20_3 Node0_17_20 Node1_17_20 12.320000000000002
C_0_17_20 Node0_17_20 GND 3.609375e-06
I_0_17_21 GND Node0_17_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_21_1 Node0_17_21 Node0_17_22 77.0
R_0_17_21_2 Node0_17_21 Node0_18_21 77.0
R_0_17_21_3 Node0_17_21 Node1_17_21 12.320000000000002
C_0_17_21 Node0_17_21 GND 3.609375e-06
I_0_17_22 GND Node0_17_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_22_1 Node0_17_22 Node0_17_23 77.0
R_0_17_22_2 Node0_17_22 Node0_18_22 77.0
R_0_17_22_3 Node0_17_22 Node1_17_22 12.320000000000002
C_0_17_22 Node0_17_22 GND 3.609375e-06
I_0_17_23 GND Node0_17_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_23_1 Node0_17_23 Node0_17_24 77.0
R_0_17_23_2 Node0_17_23 Node0_18_23 77.0
R_0_17_23_3 Node0_17_23 Node1_17_23 12.320000000000002
C_0_17_23 Node0_17_23 GND 3.609375e-06
I_0_17_24 GND Node0_17_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_24_1 Node0_17_24 Node0_17_25 77.0
R_0_17_24_2 Node0_17_24 Node0_18_24 77.0
R_0_17_24_3 Node0_17_24 Node1_17_24 12.320000000000002
C_0_17_24 Node0_17_24 GND 3.609375e-06
I_0_17_25 GND Node0_17_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_25_1 Node0_17_25 Node0_17_26 77.0
R_0_17_25_2 Node0_17_25 Node0_18_25 77.0
R_0_17_25_3 Node0_17_25 Node1_17_25 12.320000000000002
C_0_17_25 Node0_17_25 GND 3.609375e-06
I_0_17_26 GND Node0_17_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_26_1 Node0_17_26 Node0_17_27 77.0
R_0_17_26_2 Node0_17_26 Node0_18_26 77.0
R_0_17_26_3 Node0_17_26 Node1_17_26 12.320000000000002
C_0_17_26 Node0_17_26 GND 3.609375e-06
I_0_17_27 GND Node0_17_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_27_1 Node0_17_27 Node0_17_28 77.0
R_0_17_27_2 Node0_17_27 Node0_18_27 77.0
R_0_17_27_3 Node0_17_27 Node1_17_27 12.320000000000002
C_0_17_27 Node0_17_27 GND 3.609375e-06
I_0_17_28 GND Node0_17_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_28_1 Node0_17_28 Node0_17_29 77.0
R_0_17_28_2 Node0_17_28 Node0_18_28 77.0
R_0_17_28_3 Node0_17_28 Node1_17_28 12.320000000000002
C_0_17_28 Node0_17_28 GND 3.609375e-06
I_0_17_29 GND Node0_17_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_29_1 Node0_17_29 Node0_17_30 77.0
R_0_17_29_2 Node0_17_29 Node0_18_29 77.0
R_0_17_29_3 Node0_17_29 Node1_17_29 12.320000000000002
C_0_17_29 Node0_17_29 GND 3.609375e-06
I_0_17_30 GND Node0_17_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_30_1 Node0_17_30 Node0_17_31 77.0
R_0_17_30_2 Node0_17_30 Node0_18_30 77.0
R_0_17_30_3 Node0_17_30 Node1_17_30 12.320000000000002
C_0_17_30 Node0_17_30 GND 3.609375e-06
I_0_17_31 GND Node0_17_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_31_1 Node0_17_31 Node0_17_32 77.0
R_0_17_31_2 Node0_17_31 Node0_18_31 77.0
R_0_17_31_3 Node0_17_31 Node1_17_31 12.320000000000002
C_0_17_31 Node0_17_31 GND 3.609375e-06
I_0_17_32 GND Node0_17_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_32_1 Node0_17_32 Node0_17_33 77.0
R_0_17_32_2 Node0_17_32 Node0_18_32 77.0
R_0_17_32_3 Node0_17_32 Node1_17_32 12.320000000000002
C_0_17_32 Node0_17_32 GND 3.609375e-06
I_0_17_33 GND Node0_17_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_33_1 Node0_17_33 Node0_17_34 77.0
R_0_17_33_2 Node0_17_33 Node0_18_33 77.0
R_0_17_33_3 Node0_17_33 Node1_17_33 12.320000000000002
C_0_17_33 Node0_17_33 GND 3.609375e-06
I_0_17_34 GND Node0_17_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_34_1 Node0_17_34 Node0_17_35 77.0
R_0_17_34_2 Node0_17_34 Node0_18_34 77.0
R_0_17_34_3 Node0_17_34 Node1_17_34 12.320000000000002
C_0_17_34 Node0_17_34 GND 3.609375e-06
I_0_17_35 GND Node0_17_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_35_1 Node0_17_35 Node0_17_36 77.0
R_0_17_35_2 Node0_17_35 Node0_18_35 77.0
R_0_17_35_3 Node0_17_35 Node1_17_35 12.320000000000002
C_0_17_35 Node0_17_35 GND 3.609375e-06
I_0_17_36 GND Node0_17_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_36_1 Node0_17_36 Node0_17_37 77.0
R_0_17_36_2 Node0_17_36 Node0_18_36 77.0
R_0_17_36_3 Node0_17_36 Node1_17_36 12.320000000000002
C_0_17_36 Node0_17_36 GND 3.609375e-06
I_0_17_37 GND Node0_17_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_37_1 Node0_17_37 Node0_17_38 77.0
R_0_17_37_2 Node0_17_37 Node0_18_37 77.0
R_0_17_37_3 Node0_17_37 Node1_17_37 12.320000000000002
C_0_17_37 Node0_17_37 GND 3.609375e-06
I_0_17_38 GND Node0_17_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_38_1 Node0_17_38 Node0_17_39 77.0
R_0_17_38_2 Node0_17_38 Node0_18_38 77.0
R_0_17_38_3 Node0_17_38 Node1_17_38 12.320000000000002
C_0_17_38 Node0_17_38 GND 3.609375e-06
I_0_17_39 GND Node0_17_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_17_39_2 Node0_17_39 Node0_18_39 77.0
R_0_17_39_3 Node0_17_39 Node1_17_39 12.320000000000002
C_0_17_39 Node0_17_39 GND 3.609375e-06
I_0_18_0 GND Node0_18_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_0_1 Node0_18_0 Node0_18_1 77.0
R_0_18_0_2 Node0_18_0 Node0_19_0 77.0
R_0_18_0_3 Node0_18_0 Node1_18_0 12.320000000000002
C_0_18_0 Node0_18_0 GND 3.609375e-06
I_0_18_1 GND Node0_18_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_1_1 Node0_18_1 Node0_18_2 77.0
R_0_18_1_2 Node0_18_1 Node0_19_1 77.0
R_0_18_1_3 Node0_18_1 Node1_18_1 12.320000000000002
C_0_18_1 Node0_18_1 GND 3.609375e-06
I_0_18_2 GND Node0_18_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_2_1 Node0_18_2 Node0_18_3 77.0
R_0_18_2_2 Node0_18_2 Node0_19_2 77.0
R_0_18_2_3 Node0_18_2 Node1_18_2 12.320000000000002
C_0_18_2 Node0_18_2 GND 3.609375e-06
I_0_18_3 GND Node0_18_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_3_1 Node0_18_3 Node0_18_4 77.0
R_0_18_3_2 Node0_18_3 Node0_19_3 77.0
R_0_18_3_3 Node0_18_3 Node1_18_3 12.320000000000002
C_0_18_3 Node0_18_3 GND 3.609375e-06
I_0_18_4 GND Node0_18_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_4_1 Node0_18_4 Node0_18_5 77.0
R_0_18_4_2 Node0_18_4 Node0_19_4 77.0
R_0_18_4_3 Node0_18_4 Node1_18_4 12.320000000000002
C_0_18_4 Node0_18_4 GND 3.609375e-06
I_0_18_5 GND Node0_18_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_5_1 Node0_18_5 Node0_18_6 77.0
R_0_18_5_2 Node0_18_5 Node0_19_5 77.0
R_0_18_5_3 Node0_18_5 Node1_18_5 12.320000000000002
C_0_18_5 Node0_18_5 GND 3.609375e-06
I_0_18_6 GND Node0_18_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_6_1 Node0_18_6 Node0_18_7 77.0
R_0_18_6_2 Node0_18_6 Node0_19_6 77.0
R_0_18_6_3 Node0_18_6 Node1_18_6 12.320000000000002
C_0_18_6 Node0_18_6 GND 3.609375e-06
I_0_18_7 GND Node0_18_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_7_1 Node0_18_7 Node0_18_8 77.0
R_0_18_7_2 Node0_18_7 Node0_19_7 77.0
R_0_18_7_3 Node0_18_7 Node1_18_7 12.320000000000002
C_0_18_7 Node0_18_7 GND 3.609375e-06
I_0_18_8 GND Node0_18_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_8_1 Node0_18_8 Node0_18_9 77.0
R_0_18_8_2 Node0_18_8 Node0_19_8 77.0
R_0_18_8_3 Node0_18_8 Node1_18_8 12.320000000000002
C_0_18_8 Node0_18_8 GND 3.609375e-06
I_0_18_9 GND Node0_18_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_9_1 Node0_18_9 Node0_18_10 77.0
R_0_18_9_2 Node0_18_9 Node0_19_9 77.0
R_0_18_9_3 Node0_18_9 Node1_18_9 12.320000000000002
C_0_18_9 Node0_18_9 GND 3.609375e-06
I_0_18_10 GND Node0_18_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_10_1 Node0_18_10 Node0_18_11 77.0
R_0_18_10_2 Node0_18_10 Node0_19_10 77.0
R_0_18_10_3 Node0_18_10 Node1_18_10 12.320000000000002
C_0_18_10 Node0_18_10 GND 3.609375e-06
I_0_18_11 GND Node0_18_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_11_1 Node0_18_11 Node0_18_12 77.0
R_0_18_11_2 Node0_18_11 Node0_19_11 77.0
R_0_18_11_3 Node0_18_11 Node1_18_11 12.320000000000002
C_0_18_11 Node0_18_11 GND 3.609375e-06
I_0_18_12 GND Node0_18_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_12_1 Node0_18_12 Node0_18_13 77.0
R_0_18_12_2 Node0_18_12 Node0_19_12 77.0
R_0_18_12_3 Node0_18_12 Node1_18_12 12.320000000000002
C_0_18_12 Node0_18_12 GND 3.609375e-06
I_0_18_13 GND Node0_18_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_13_1 Node0_18_13 Node0_18_14 77.0
R_0_18_13_2 Node0_18_13 Node0_19_13 77.0
R_0_18_13_3 Node0_18_13 Node1_18_13 12.320000000000002
C_0_18_13 Node0_18_13 GND 3.609375e-06
I_0_18_14 GND Node0_18_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_14_1 Node0_18_14 Node0_18_15 77.0
R_0_18_14_2 Node0_18_14 Node0_19_14 77.0
R_0_18_14_3 Node0_18_14 Node1_18_14 12.320000000000002
C_0_18_14 Node0_18_14 GND 3.609375e-06
I_0_18_15 GND Node0_18_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_15_1 Node0_18_15 Node0_18_16 77.0
R_0_18_15_2 Node0_18_15 Node0_19_15 77.0
R_0_18_15_3 Node0_18_15 Node1_18_15 12.320000000000002
C_0_18_15 Node0_18_15 GND 3.609375e-06
I_0_18_16 GND Node0_18_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_16_1 Node0_18_16 Node0_18_17 77.0
R_0_18_16_2 Node0_18_16 Node0_19_16 77.0
R_0_18_16_3 Node0_18_16 Node1_18_16 12.320000000000002
C_0_18_16 Node0_18_16 GND 3.609375e-06
I_0_18_17 GND Node0_18_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_17_1 Node0_18_17 Node0_18_18 77.0
R_0_18_17_2 Node0_18_17 Node0_19_17 77.0
R_0_18_17_3 Node0_18_17 Node1_18_17 12.320000000000002
C_0_18_17 Node0_18_17 GND 3.609375e-06
I_0_18_18 GND Node0_18_18 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_18_1 Node0_18_18 Node0_18_19 77.0
R_0_18_18_2 Node0_18_18 Node0_19_18 77.0
R_0_18_18_3 Node0_18_18 Node1_18_18 12.320000000000002
C_0_18_18 Node0_18_18 GND 3.609375e-06
I_0_18_19 GND Node0_18_19 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_19_1 Node0_18_19 Node0_18_20 77.0
R_0_18_19_2 Node0_18_19 Node0_19_19 77.0
R_0_18_19_3 Node0_18_19 Node1_18_19 12.320000000000002
C_0_18_19 Node0_18_19 GND 3.609375e-06
I_0_18_20 GND Node0_18_20 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_20_1 Node0_18_20 Node0_18_21 77.0
R_0_18_20_2 Node0_18_20 Node0_19_20 77.0
R_0_18_20_3 Node0_18_20 Node1_18_20 12.320000000000002
C_0_18_20 Node0_18_20 GND 3.609375e-06
I_0_18_21 GND Node0_18_21 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_21_1 Node0_18_21 Node0_18_22 77.0
R_0_18_21_2 Node0_18_21 Node0_19_21 77.0
R_0_18_21_3 Node0_18_21 Node1_18_21 12.320000000000002
C_0_18_21 Node0_18_21 GND 3.609375e-06
I_0_18_22 GND Node0_18_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_22_1 Node0_18_22 Node0_18_23 77.0
R_0_18_22_2 Node0_18_22 Node0_19_22 77.0
R_0_18_22_3 Node0_18_22 Node1_18_22 12.320000000000002
C_0_18_22 Node0_18_22 GND 3.609375e-06
I_0_18_23 GND Node0_18_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_23_1 Node0_18_23 Node0_18_24 77.0
R_0_18_23_2 Node0_18_23 Node0_19_23 77.0
R_0_18_23_3 Node0_18_23 Node1_18_23 12.320000000000002
C_0_18_23 Node0_18_23 GND 3.609375e-06
I_0_18_24 GND Node0_18_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_24_1 Node0_18_24 Node0_18_25 77.0
R_0_18_24_2 Node0_18_24 Node0_19_24 77.0
R_0_18_24_3 Node0_18_24 Node1_18_24 12.320000000000002
C_0_18_24 Node0_18_24 GND 3.609375e-06
I_0_18_25 GND Node0_18_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_25_1 Node0_18_25 Node0_18_26 77.0
R_0_18_25_2 Node0_18_25 Node0_19_25 77.0
R_0_18_25_3 Node0_18_25 Node1_18_25 12.320000000000002
C_0_18_25 Node0_18_25 GND 3.609375e-06
I_0_18_26 GND Node0_18_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_26_1 Node0_18_26 Node0_18_27 77.0
R_0_18_26_2 Node0_18_26 Node0_19_26 77.0
R_0_18_26_3 Node0_18_26 Node1_18_26 12.320000000000002
C_0_18_26 Node0_18_26 GND 3.609375e-06
I_0_18_27 GND Node0_18_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_27_1 Node0_18_27 Node0_18_28 77.0
R_0_18_27_2 Node0_18_27 Node0_19_27 77.0
R_0_18_27_3 Node0_18_27 Node1_18_27 12.320000000000002
C_0_18_27 Node0_18_27 GND 3.609375e-06
I_0_18_28 GND Node0_18_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_28_1 Node0_18_28 Node0_18_29 77.0
R_0_18_28_2 Node0_18_28 Node0_19_28 77.0
R_0_18_28_3 Node0_18_28 Node1_18_28 12.320000000000002
C_0_18_28 Node0_18_28 GND 3.609375e-06
I_0_18_29 GND Node0_18_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_29_1 Node0_18_29 Node0_18_30 77.0
R_0_18_29_2 Node0_18_29 Node0_19_29 77.0
R_0_18_29_3 Node0_18_29 Node1_18_29 12.320000000000002
C_0_18_29 Node0_18_29 GND 3.609375e-06
I_0_18_30 GND Node0_18_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_30_1 Node0_18_30 Node0_18_31 77.0
R_0_18_30_2 Node0_18_30 Node0_19_30 77.0
R_0_18_30_3 Node0_18_30 Node1_18_30 12.320000000000002
C_0_18_30 Node0_18_30 GND 3.609375e-06
I_0_18_31 GND Node0_18_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_31_1 Node0_18_31 Node0_18_32 77.0
R_0_18_31_2 Node0_18_31 Node0_19_31 77.0
R_0_18_31_3 Node0_18_31 Node1_18_31 12.320000000000002
C_0_18_31 Node0_18_31 GND 3.609375e-06
I_0_18_32 GND Node0_18_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_32_1 Node0_18_32 Node0_18_33 77.0
R_0_18_32_2 Node0_18_32 Node0_19_32 77.0
R_0_18_32_3 Node0_18_32 Node1_18_32 12.320000000000002
C_0_18_32 Node0_18_32 GND 3.609375e-06
I_0_18_33 GND Node0_18_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_33_1 Node0_18_33 Node0_18_34 77.0
R_0_18_33_2 Node0_18_33 Node0_19_33 77.0
R_0_18_33_3 Node0_18_33 Node1_18_33 12.320000000000002
C_0_18_33 Node0_18_33 GND 3.609375e-06
I_0_18_34 GND Node0_18_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_34_1 Node0_18_34 Node0_18_35 77.0
R_0_18_34_2 Node0_18_34 Node0_19_34 77.0
R_0_18_34_3 Node0_18_34 Node1_18_34 12.320000000000002
C_0_18_34 Node0_18_34 GND 3.609375e-06
I_0_18_35 GND Node0_18_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_35_1 Node0_18_35 Node0_18_36 77.0
R_0_18_35_2 Node0_18_35 Node0_19_35 77.0
R_0_18_35_3 Node0_18_35 Node1_18_35 12.320000000000002
C_0_18_35 Node0_18_35 GND 3.609375e-06
I_0_18_36 GND Node0_18_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_36_1 Node0_18_36 Node0_18_37 77.0
R_0_18_36_2 Node0_18_36 Node0_19_36 77.0
R_0_18_36_3 Node0_18_36 Node1_18_36 12.320000000000002
C_0_18_36 Node0_18_36 GND 3.609375e-06
I_0_18_37 GND Node0_18_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_37_1 Node0_18_37 Node0_18_38 77.0
R_0_18_37_2 Node0_18_37 Node0_19_37 77.0
R_0_18_37_3 Node0_18_37 Node1_18_37 12.320000000000002
C_0_18_37 Node0_18_37 GND 3.609375e-06
I_0_18_38 GND Node0_18_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_38_1 Node0_18_38 Node0_18_39 77.0
R_0_18_38_2 Node0_18_38 Node0_19_38 77.0
R_0_18_38_3 Node0_18_38 Node1_18_38 12.320000000000002
C_0_18_38 Node0_18_38 GND 3.609375e-06
I_0_18_39 GND Node0_18_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_18_39_2 Node0_18_39 Node0_19_39 77.0
R_0_18_39_3 Node0_18_39 Node1_18_39 12.320000000000002
C_0_18_39 Node0_18_39 GND 3.609375e-06
I_0_19_0 GND Node0_19_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_0_1 Node0_19_0 Node0_19_1 77.0
R_0_19_0_2 Node0_19_0 Node0_20_0 77.0
R_0_19_0_3 Node0_19_0 Node1_19_0 12.320000000000002
C_0_19_0 Node0_19_0 GND 3.609375e-06
I_0_19_1 GND Node0_19_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_1_1 Node0_19_1 Node0_19_2 77.0
R_0_19_1_2 Node0_19_1 Node0_20_1 77.0
R_0_19_1_3 Node0_19_1 Node1_19_1 12.320000000000002
C_0_19_1 Node0_19_1 GND 3.609375e-06
I_0_19_2 GND Node0_19_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_2_1 Node0_19_2 Node0_19_3 77.0
R_0_19_2_2 Node0_19_2 Node0_20_2 77.0
R_0_19_2_3 Node0_19_2 Node1_19_2 12.320000000000002
C_0_19_2 Node0_19_2 GND 3.609375e-06
I_0_19_3 GND Node0_19_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_3_1 Node0_19_3 Node0_19_4 77.0
R_0_19_3_2 Node0_19_3 Node0_20_3 77.0
R_0_19_3_3 Node0_19_3 Node1_19_3 12.320000000000002
C_0_19_3 Node0_19_3 GND 3.609375e-06
I_0_19_4 GND Node0_19_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_4_1 Node0_19_4 Node0_19_5 77.0
R_0_19_4_2 Node0_19_4 Node0_20_4 77.0
R_0_19_4_3 Node0_19_4 Node1_19_4 12.320000000000002
C_0_19_4 Node0_19_4 GND 3.609375e-06
I_0_19_5 GND Node0_19_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_5_1 Node0_19_5 Node0_19_6 77.0
R_0_19_5_2 Node0_19_5 Node0_20_5 77.0
R_0_19_5_3 Node0_19_5 Node1_19_5 12.320000000000002
C_0_19_5 Node0_19_5 GND 3.609375e-06
I_0_19_6 GND Node0_19_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_6_1 Node0_19_6 Node0_19_7 77.0
R_0_19_6_2 Node0_19_6 Node0_20_6 77.0
R_0_19_6_3 Node0_19_6 Node1_19_6 12.320000000000002
C_0_19_6 Node0_19_6 GND 3.609375e-06
I_0_19_7 GND Node0_19_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_7_1 Node0_19_7 Node0_19_8 77.0
R_0_19_7_2 Node0_19_7 Node0_20_7 77.0
R_0_19_7_3 Node0_19_7 Node1_19_7 12.320000000000002
C_0_19_7 Node0_19_7 GND 3.609375e-06
I_0_19_8 GND Node0_19_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_8_1 Node0_19_8 Node0_19_9 77.0
R_0_19_8_2 Node0_19_8 Node0_20_8 77.0
R_0_19_8_3 Node0_19_8 Node1_19_8 12.320000000000002
C_0_19_8 Node0_19_8 GND 3.609375e-06
I_0_19_9 GND Node0_19_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_9_1 Node0_19_9 Node0_19_10 77.0
R_0_19_9_2 Node0_19_9 Node0_20_9 77.0
R_0_19_9_3 Node0_19_9 Node1_19_9 12.320000000000002
C_0_19_9 Node0_19_9 GND 3.609375e-06
I_0_19_10 GND Node0_19_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_10_1 Node0_19_10 Node0_19_11 77.0
R_0_19_10_2 Node0_19_10 Node0_20_10 77.0
R_0_19_10_3 Node0_19_10 Node1_19_10 12.320000000000002
C_0_19_10 Node0_19_10 GND 3.609375e-06
I_0_19_11 GND Node0_19_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_11_1 Node0_19_11 Node0_19_12 77.0
R_0_19_11_2 Node0_19_11 Node0_20_11 77.0
R_0_19_11_3 Node0_19_11 Node1_19_11 12.320000000000002
C_0_19_11 Node0_19_11 GND 3.609375e-06
I_0_19_12 GND Node0_19_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_12_1 Node0_19_12 Node0_19_13 77.0
R_0_19_12_2 Node0_19_12 Node0_20_12 77.0
R_0_19_12_3 Node0_19_12 Node1_19_12 12.320000000000002
C_0_19_12 Node0_19_12 GND 3.609375e-06
I_0_19_13 GND Node0_19_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_13_1 Node0_19_13 Node0_19_14 77.0
R_0_19_13_2 Node0_19_13 Node0_20_13 77.0
R_0_19_13_3 Node0_19_13 Node1_19_13 12.320000000000002
C_0_19_13 Node0_19_13 GND 3.609375e-06
I_0_19_14 GND Node0_19_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_14_1 Node0_19_14 Node0_19_15 77.0
R_0_19_14_2 Node0_19_14 Node0_20_14 77.0
R_0_19_14_3 Node0_19_14 Node1_19_14 12.320000000000002
C_0_19_14 Node0_19_14 GND 3.609375e-06
I_0_19_15 GND Node0_19_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_15_1 Node0_19_15 Node0_19_16 77.0
R_0_19_15_2 Node0_19_15 Node0_20_15 77.0
R_0_19_15_3 Node0_19_15 Node1_19_15 12.320000000000002
C_0_19_15 Node0_19_15 GND 3.609375e-06
I_0_19_16 GND Node0_19_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_16_1 Node0_19_16 Node0_19_17 77.0
R_0_19_16_2 Node0_19_16 Node0_20_16 77.0
R_0_19_16_3 Node0_19_16 Node1_19_16 12.320000000000002
C_0_19_16 Node0_19_16 GND 3.609375e-06
I_0_19_17 GND Node0_19_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_17_1 Node0_19_17 Node0_19_18 77.0
R_0_19_17_2 Node0_19_17 Node0_20_17 77.0
R_0_19_17_3 Node0_19_17 Node1_19_17 12.320000000000002
C_0_19_17 Node0_19_17 GND 3.609375e-06
I_0_19_18 GND Node0_19_18 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_18_1 Node0_19_18 Node0_19_19 77.0
R_0_19_18_2 Node0_19_18 Node0_20_18 77.0
R_0_19_18_3 Node0_19_18 Node1_19_18 12.320000000000002
C_0_19_18 Node0_19_18 GND 3.609375e-06
I_0_19_19 GND Node0_19_19 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_19_1 Node0_19_19 Node0_19_20 77.0
R_0_19_19_2 Node0_19_19 Node0_20_19 77.0
R_0_19_19_3 Node0_19_19 Node1_19_19 12.320000000000002
C_0_19_19 Node0_19_19 GND 3.609375e-06
I_0_19_20 GND Node0_19_20 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_20_1 Node0_19_20 Node0_19_21 77.0
R_0_19_20_2 Node0_19_20 Node0_20_20 77.0
R_0_19_20_3 Node0_19_20 Node1_19_20 12.320000000000002
C_0_19_20 Node0_19_20 GND 3.609375e-06
I_0_19_21 GND Node0_19_21 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_21_1 Node0_19_21 Node0_19_22 77.0
R_0_19_21_2 Node0_19_21 Node0_20_21 77.0
R_0_19_21_3 Node0_19_21 Node1_19_21 12.320000000000002
C_0_19_21 Node0_19_21 GND 3.609375e-06
I_0_19_22 GND Node0_19_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_22_1 Node0_19_22 Node0_19_23 77.0
R_0_19_22_2 Node0_19_22 Node0_20_22 77.0
R_0_19_22_3 Node0_19_22 Node1_19_22 12.320000000000002
C_0_19_22 Node0_19_22 GND 3.609375e-06
I_0_19_23 GND Node0_19_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_23_1 Node0_19_23 Node0_19_24 77.0
R_0_19_23_2 Node0_19_23 Node0_20_23 77.0
R_0_19_23_3 Node0_19_23 Node1_19_23 12.320000000000002
C_0_19_23 Node0_19_23 GND 3.609375e-06
I_0_19_24 GND Node0_19_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_24_1 Node0_19_24 Node0_19_25 77.0
R_0_19_24_2 Node0_19_24 Node0_20_24 77.0
R_0_19_24_3 Node0_19_24 Node1_19_24 12.320000000000002
C_0_19_24 Node0_19_24 GND 3.609375e-06
I_0_19_25 GND Node0_19_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_25_1 Node0_19_25 Node0_19_26 77.0
R_0_19_25_2 Node0_19_25 Node0_20_25 77.0
R_0_19_25_3 Node0_19_25 Node1_19_25 12.320000000000002
C_0_19_25 Node0_19_25 GND 3.609375e-06
I_0_19_26 GND Node0_19_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_26_1 Node0_19_26 Node0_19_27 77.0
R_0_19_26_2 Node0_19_26 Node0_20_26 77.0
R_0_19_26_3 Node0_19_26 Node1_19_26 12.320000000000002
C_0_19_26 Node0_19_26 GND 3.609375e-06
I_0_19_27 GND Node0_19_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_27_1 Node0_19_27 Node0_19_28 77.0
R_0_19_27_2 Node0_19_27 Node0_20_27 77.0
R_0_19_27_3 Node0_19_27 Node1_19_27 12.320000000000002
C_0_19_27 Node0_19_27 GND 3.609375e-06
I_0_19_28 GND Node0_19_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_28_1 Node0_19_28 Node0_19_29 77.0
R_0_19_28_2 Node0_19_28 Node0_20_28 77.0
R_0_19_28_3 Node0_19_28 Node1_19_28 12.320000000000002
C_0_19_28 Node0_19_28 GND 3.609375e-06
I_0_19_29 GND Node0_19_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_29_1 Node0_19_29 Node0_19_30 77.0
R_0_19_29_2 Node0_19_29 Node0_20_29 77.0
R_0_19_29_3 Node0_19_29 Node1_19_29 12.320000000000002
C_0_19_29 Node0_19_29 GND 3.609375e-06
I_0_19_30 GND Node0_19_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_30_1 Node0_19_30 Node0_19_31 77.0
R_0_19_30_2 Node0_19_30 Node0_20_30 77.0
R_0_19_30_3 Node0_19_30 Node1_19_30 12.320000000000002
C_0_19_30 Node0_19_30 GND 3.609375e-06
I_0_19_31 GND Node0_19_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_31_1 Node0_19_31 Node0_19_32 77.0
R_0_19_31_2 Node0_19_31 Node0_20_31 77.0
R_0_19_31_3 Node0_19_31 Node1_19_31 12.320000000000002
C_0_19_31 Node0_19_31 GND 3.609375e-06
I_0_19_32 GND Node0_19_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_32_1 Node0_19_32 Node0_19_33 77.0
R_0_19_32_2 Node0_19_32 Node0_20_32 77.0
R_0_19_32_3 Node0_19_32 Node1_19_32 12.320000000000002
C_0_19_32 Node0_19_32 GND 3.609375e-06
I_0_19_33 GND Node0_19_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_33_1 Node0_19_33 Node0_19_34 77.0
R_0_19_33_2 Node0_19_33 Node0_20_33 77.0
R_0_19_33_3 Node0_19_33 Node1_19_33 12.320000000000002
C_0_19_33 Node0_19_33 GND 3.609375e-06
I_0_19_34 GND Node0_19_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_34_1 Node0_19_34 Node0_19_35 77.0
R_0_19_34_2 Node0_19_34 Node0_20_34 77.0
R_0_19_34_3 Node0_19_34 Node1_19_34 12.320000000000002
C_0_19_34 Node0_19_34 GND 3.609375e-06
I_0_19_35 GND Node0_19_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_35_1 Node0_19_35 Node0_19_36 77.0
R_0_19_35_2 Node0_19_35 Node0_20_35 77.0
R_0_19_35_3 Node0_19_35 Node1_19_35 12.320000000000002
C_0_19_35 Node0_19_35 GND 3.609375e-06
I_0_19_36 GND Node0_19_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_36_1 Node0_19_36 Node0_19_37 77.0
R_0_19_36_2 Node0_19_36 Node0_20_36 77.0
R_0_19_36_3 Node0_19_36 Node1_19_36 12.320000000000002
C_0_19_36 Node0_19_36 GND 3.609375e-06
I_0_19_37 GND Node0_19_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_37_1 Node0_19_37 Node0_19_38 77.0
R_0_19_37_2 Node0_19_37 Node0_20_37 77.0
R_0_19_37_3 Node0_19_37 Node1_19_37 12.320000000000002
C_0_19_37 Node0_19_37 GND 3.609375e-06
I_0_19_38 GND Node0_19_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_38_1 Node0_19_38 Node0_19_39 77.0
R_0_19_38_2 Node0_19_38 Node0_20_38 77.0
R_0_19_38_3 Node0_19_38 Node1_19_38 12.320000000000002
C_0_19_38 Node0_19_38 GND 3.609375e-06
I_0_19_39 GND Node0_19_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_19_39_2 Node0_19_39 Node0_20_39 77.0
R_0_19_39_3 Node0_19_39 Node1_19_39 12.320000000000002
C_0_19_39 Node0_19_39 GND 3.609375e-06
I_0_20_0 GND Node0_20_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_0_1 Node0_20_0 Node0_20_1 77.0
R_0_20_0_2 Node0_20_0 Node0_21_0 77.0
R_0_20_0_3 Node0_20_0 Node1_20_0 12.320000000000002
C_0_20_0 Node0_20_0 GND 3.609375e-06
I_0_20_1 GND Node0_20_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_1_1 Node0_20_1 Node0_20_2 77.0
R_0_20_1_2 Node0_20_1 Node0_21_1 77.0
R_0_20_1_3 Node0_20_1 Node1_20_1 12.320000000000002
C_0_20_1 Node0_20_1 GND 3.609375e-06
I_0_20_2 GND Node0_20_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_2_1 Node0_20_2 Node0_20_3 77.0
R_0_20_2_2 Node0_20_2 Node0_21_2 77.0
R_0_20_2_3 Node0_20_2 Node1_20_2 12.320000000000002
C_0_20_2 Node0_20_2 GND 3.609375e-06
I_0_20_3 GND Node0_20_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_3_1 Node0_20_3 Node0_20_4 77.0
R_0_20_3_2 Node0_20_3 Node0_21_3 77.0
R_0_20_3_3 Node0_20_3 Node1_20_3 12.320000000000002
C_0_20_3 Node0_20_3 GND 3.609375e-06
I_0_20_4 GND Node0_20_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_4_1 Node0_20_4 Node0_20_5 77.0
R_0_20_4_2 Node0_20_4 Node0_21_4 77.0
R_0_20_4_3 Node0_20_4 Node1_20_4 12.320000000000002
C_0_20_4 Node0_20_4 GND 3.609375e-06
I_0_20_5 GND Node0_20_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_5_1 Node0_20_5 Node0_20_6 77.0
R_0_20_5_2 Node0_20_5 Node0_21_5 77.0
R_0_20_5_3 Node0_20_5 Node1_20_5 12.320000000000002
C_0_20_5 Node0_20_5 GND 3.609375e-06
I_0_20_6 GND Node0_20_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_6_1 Node0_20_6 Node0_20_7 77.0
R_0_20_6_2 Node0_20_6 Node0_21_6 77.0
R_0_20_6_3 Node0_20_6 Node1_20_6 12.320000000000002
C_0_20_6 Node0_20_6 GND 3.609375e-06
I_0_20_7 GND Node0_20_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_7_1 Node0_20_7 Node0_20_8 77.0
R_0_20_7_2 Node0_20_7 Node0_21_7 77.0
R_0_20_7_3 Node0_20_7 Node1_20_7 12.320000000000002
C_0_20_7 Node0_20_7 GND 3.609375e-06
I_0_20_8 GND Node0_20_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_8_1 Node0_20_8 Node0_20_9 77.0
R_0_20_8_2 Node0_20_8 Node0_21_8 77.0
R_0_20_8_3 Node0_20_8 Node1_20_8 12.320000000000002
C_0_20_8 Node0_20_8 GND 3.609375e-06
I_0_20_9 GND Node0_20_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_9_1 Node0_20_9 Node0_20_10 77.0
R_0_20_9_2 Node0_20_9 Node0_21_9 77.0
R_0_20_9_3 Node0_20_9 Node1_20_9 12.320000000000002
C_0_20_9 Node0_20_9 GND 3.609375e-06
I_0_20_10 GND Node0_20_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_10_1 Node0_20_10 Node0_20_11 77.0
R_0_20_10_2 Node0_20_10 Node0_21_10 77.0
R_0_20_10_3 Node0_20_10 Node1_20_10 12.320000000000002
C_0_20_10 Node0_20_10 GND 3.609375e-06
I_0_20_11 GND Node0_20_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_11_1 Node0_20_11 Node0_20_12 77.0
R_0_20_11_2 Node0_20_11 Node0_21_11 77.0
R_0_20_11_3 Node0_20_11 Node1_20_11 12.320000000000002
C_0_20_11 Node0_20_11 GND 3.609375e-06
I_0_20_12 GND Node0_20_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_12_1 Node0_20_12 Node0_20_13 77.0
R_0_20_12_2 Node0_20_12 Node0_21_12 77.0
R_0_20_12_3 Node0_20_12 Node1_20_12 12.320000000000002
C_0_20_12 Node0_20_12 GND 3.609375e-06
I_0_20_13 GND Node0_20_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_13_1 Node0_20_13 Node0_20_14 77.0
R_0_20_13_2 Node0_20_13 Node0_21_13 77.0
R_0_20_13_3 Node0_20_13 Node1_20_13 12.320000000000002
C_0_20_13 Node0_20_13 GND 3.609375e-06
I_0_20_14 GND Node0_20_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_14_1 Node0_20_14 Node0_20_15 77.0
R_0_20_14_2 Node0_20_14 Node0_21_14 77.0
R_0_20_14_3 Node0_20_14 Node1_20_14 12.320000000000002
C_0_20_14 Node0_20_14 GND 3.609375e-06
I_0_20_15 GND Node0_20_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_15_1 Node0_20_15 Node0_20_16 77.0
R_0_20_15_2 Node0_20_15 Node0_21_15 77.0
R_0_20_15_3 Node0_20_15 Node1_20_15 12.320000000000002
C_0_20_15 Node0_20_15 GND 3.609375e-06
I_0_20_16 GND Node0_20_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_16_1 Node0_20_16 Node0_20_17 77.0
R_0_20_16_2 Node0_20_16 Node0_21_16 77.0
R_0_20_16_3 Node0_20_16 Node1_20_16 12.320000000000002
C_0_20_16 Node0_20_16 GND 3.609375e-06
I_0_20_17 GND Node0_20_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_17_1 Node0_20_17 Node0_20_18 77.0
R_0_20_17_2 Node0_20_17 Node0_21_17 77.0
R_0_20_17_3 Node0_20_17 Node1_20_17 12.320000000000002
C_0_20_17 Node0_20_17 GND 3.609375e-06
I_0_20_18 GND Node0_20_18 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_18_1 Node0_20_18 Node0_20_19 77.0
R_0_20_18_2 Node0_20_18 Node0_21_18 77.0
R_0_20_18_3 Node0_20_18 Node1_20_18 12.320000000000002
C_0_20_18 Node0_20_18 GND 3.609375e-06
I_0_20_19 GND Node0_20_19 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_19_1 Node0_20_19 Node0_20_20 77.0
R_0_20_19_2 Node0_20_19 Node0_21_19 77.0
R_0_20_19_3 Node0_20_19 Node1_20_19 12.320000000000002
C_0_20_19 Node0_20_19 GND 3.609375e-06
I_0_20_20 GND Node0_20_20 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_20_1 Node0_20_20 Node0_20_21 77.0
R_0_20_20_2 Node0_20_20 Node0_21_20 77.0
R_0_20_20_3 Node0_20_20 Node1_20_20 12.320000000000002
C_0_20_20 Node0_20_20 GND 3.609375e-06
I_0_20_21 GND Node0_20_21 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_21_1 Node0_20_21 Node0_20_22 77.0
R_0_20_21_2 Node0_20_21 Node0_21_21 77.0
R_0_20_21_3 Node0_20_21 Node1_20_21 12.320000000000002
C_0_20_21 Node0_20_21 GND 3.609375e-06
I_0_20_22 GND Node0_20_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_22_1 Node0_20_22 Node0_20_23 77.0
R_0_20_22_2 Node0_20_22 Node0_21_22 77.0
R_0_20_22_3 Node0_20_22 Node1_20_22 12.320000000000002
C_0_20_22 Node0_20_22 GND 3.609375e-06
I_0_20_23 GND Node0_20_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_23_1 Node0_20_23 Node0_20_24 77.0
R_0_20_23_2 Node0_20_23 Node0_21_23 77.0
R_0_20_23_3 Node0_20_23 Node1_20_23 12.320000000000002
C_0_20_23 Node0_20_23 GND 3.609375e-06
I_0_20_24 GND Node0_20_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_24_1 Node0_20_24 Node0_20_25 77.0
R_0_20_24_2 Node0_20_24 Node0_21_24 77.0
R_0_20_24_3 Node0_20_24 Node1_20_24 12.320000000000002
C_0_20_24 Node0_20_24 GND 3.609375e-06
I_0_20_25 GND Node0_20_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_25_1 Node0_20_25 Node0_20_26 77.0
R_0_20_25_2 Node0_20_25 Node0_21_25 77.0
R_0_20_25_3 Node0_20_25 Node1_20_25 12.320000000000002
C_0_20_25 Node0_20_25 GND 3.609375e-06
I_0_20_26 GND Node0_20_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_26_1 Node0_20_26 Node0_20_27 77.0
R_0_20_26_2 Node0_20_26 Node0_21_26 77.0
R_0_20_26_3 Node0_20_26 Node1_20_26 12.320000000000002
C_0_20_26 Node0_20_26 GND 3.609375e-06
I_0_20_27 GND Node0_20_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_27_1 Node0_20_27 Node0_20_28 77.0
R_0_20_27_2 Node0_20_27 Node0_21_27 77.0
R_0_20_27_3 Node0_20_27 Node1_20_27 12.320000000000002
C_0_20_27 Node0_20_27 GND 3.609375e-06
I_0_20_28 GND Node0_20_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_28_1 Node0_20_28 Node0_20_29 77.0
R_0_20_28_2 Node0_20_28 Node0_21_28 77.0
R_0_20_28_3 Node0_20_28 Node1_20_28 12.320000000000002
C_0_20_28 Node0_20_28 GND 3.609375e-06
I_0_20_29 GND Node0_20_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_29_1 Node0_20_29 Node0_20_30 77.0
R_0_20_29_2 Node0_20_29 Node0_21_29 77.0
R_0_20_29_3 Node0_20_29 Node1_20_29 12.320000000000002
C_0_20_29 Node0_20_29 GND 3.609375e-06
I_0_20_30 GND Node0_20_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_30_1 Node0_20_30 Node0_20_31 77.0
R_0_20_30_2 Node0_20_30 Node0_21_30 77.0
R_0_20_30_3 Node0_20_30 Node1_20_30 12.320000000000002
C_0_20_30 Node0_20_30 GND 3.609375e-06
I_0_20_31 GND Node0_20_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_31_1 Node0_20_31 Node0_20_32 77.0
R_0_20_31_2 Node0_20_31 Node0_21_31 77.0
R_0_20_31_3 Node0_20_31 Node1_20_31 12.320000000000002
C_0_20_31 Node0_20_31 GND 3.609375e-06
I_0_20_32 GND Node0_20_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_32_1 Node0_20_32 Node0_20_33 77.0
R_0_20_32_2 Node0_20_32 Node0_21_32 77.0
R_0_20_32_3 Node0_20_32 Node1_20_32 12.320000000000002
C_0_20_32 Node0_20_32 GND 3.609375e-06
I_0_20_33 GND Node0_20_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_33_1 Node0_20_33 Node0_20_34 77.0
R_0_20_33_2 Node0_20_33 Node0_21_33 77.0
R_0_20_33_3 Node0_20_33 Node1_20_33 12.320000000000002
C_0_20_33 Node0_20_33 GND 3.609375e-06
I_0_20_34 GND Node0_20_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_34_1 Node0_20_34 Node0_20_35 77.0
R_0_20_34_2 Node0_20_34 Node0_21_34 77.0
R_0_20_34_3 Node0_20_34 Node1_20_34 12.320000000000002
C_0_20_34 Node0_20_34 GND 3.609375e-06
I_0_20_35 GND Node0_20_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_35_1 Node0_20_35 Node0_20_36 77.0
R_0_20_35_2 Node0_20_35 Node0_21_35 77.0
R_0_20_35_3 Node0_20_35 Node1_20_35 12.320000000000002
C_0_20_35 Node0_20_35 GND 3.609375e-06
I_0_20_36 GND Node0_20_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_36_1 Node0_20_36 Node0_20_37 77.0
R_0_20_36_2 Node0_20_36 Node0_21_36 77.0
R_0_20_36_3 Node0_20_36 Node1_20_36 12.320000000000002
C_0_20_36 Node0_20_36 GND 3.609375e-06
I_0_20_37 GND Node0_20_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_37_1 Node0_20_37 Node0_20_38 77.0
R_0_20_37_2 Node0_20_37 Node0_21_37 77.0
R_0_20_37_3 Node0_20_37 Node1_20_37 12.320000000000002
C_0_20_37 Node0_20_37 GND 3.609375e-06
I_0_20_38 GND Node0_20_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_38_1 Node0_20_38 Node0_20_39 77.0
R_0_20_38_2 Node0_20_38 Node0_21_38 77.0
R_0_20_38_3 Node0_20_38 Node1_20_38 12.320000000000002
C_0_20_38 Node0_20_38 GND 3.609375e-06
I_0_20_39 GND Node0_20_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_20_39_2 Node0_20_39 Node0_21_39 77.0
R_0_20_39_3 Node0_20_39 Node1_20_39 12.320000000000002
C_0_20_39 Node0_20_39 GND 3.609375e-06
I_0_21_0 GND Node0_21_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_0_1 Node0_21_0 Node0_21_1 77.0
R_0_21_0_2 Node0_21_0 Node0_22_0 77.0
R_0_21_0_3 Node0_21_0 Node1_21_0 12.320000000000002
C_0_21_0 Node0_21_0 GND 3.609375e-06
I_0_21_1 GND Node0_21_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_1_1 Node0_21_1 Node0_21_2 77.0
R_0_21_1_2 Node0_21_1 Node0_22_1 77.0
R_0_21_1_3 Node0_21_1 Node1_21_1 12.320000000000002
C_0_21_1 Node0_21_1 GND 3.609375e-06
I_0_21_2 GND Node0_21_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_2_1 Node0_21_2 Node0_21_3 77.0
R_0_21_2_2 Node0_21_2 Node0_22_2 77.0
R_0_21_2_3 Node0_21_2 Node1_21_2 12.320000000000002
C_0_21_2 Node0_21_2 GND 3.609375e-06
I_0_21_3 GND Node0_21_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_3_1 Node0_21_3 Node0_21_4 77.0
R_0_21_3_2 Node0_21_3 Node0_22_3 77.0
R_0_21_3_3 Node0_21_3 Node1_21_3 12.320000000000002
C_0_21_3 Node0_21_3 GND 3.609375e-06
I_0_21_4 GND Node0_21_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_4_1 Node0_21_4 Node0_21_5 77.0
R_0_21_4_2 Node0_21_4 Node0_22_4 77.0
R_0_21_4_3 Node0_21_4 Node1_21_4 12.320000000000002
C_0_21_4 Node0_21_4 GND 3.609375e-06
I_0_21_5 GND Node0_21_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_5_1 Node0_21_5 Node0_21_6 77.0
R_0_21_5_2 Node0_21_5 Node0_22_5 77.0
R_0_21_5_3 Node0_21_5 Node1_21_5 12.320000000000002
C_0_21_5 Node0_21_5 GND 3.609375e-06
I_0_21_6 GND Node0_21_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_6_1 Node0_21_6 Node0_21_7 77.0
R_0_21_6_2 Node0_21_6 Node0_22_6 77.0
R_0_21_6_3 Node0_21_6 Node1_21_6 12.320000000000002
C_0_21_6 Node0_21_6 GND 3.609375e-06
I_0_21_7 GND Node0_21_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_7_1 Node0_21_7 Node0_21_8 77.0
R_0_21_7_2 Node0_21_7 Node0_22_7 77.0
R_0_21_7_3 Node0_21_7 Node1_21_7 12.320000000000002
C_0_21_7 Node0_21_7 GND 3.609375e-06
I_0_21_8 GND Node0_21_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_8_1 Node0_21_8 Node0_21_9 77.0
R_0_21_8_2 Node0_21_8 Node0_22_8 77.0
R_0_21_8_3 Node0_21_8 Node1_21_8 12.320000000000002
C_0_21_8 Node0_21_8 GND 3.609375e-06
I_0_21_9 GND Node0_21_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_9_1 Node0_21_9 Node0_21_10 77.0
R_0_21_9_2 Node0_21_9 Node0_22_9 77.0
R_0_21_9_3 Node0_21_9 Node1_21_9 12.320000000000002
C_0_21_9 Node0_21_9 GND 3.609375e-06
I_0_21_10 GND Node0_21_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_10_1 Node0_21_10 Node0_21_11 77.0
R_0_21_10_2 Node0_21_10 Node0_22_10 77.0
R_0_21_10_3 Node0_21_10 Node1_21_10 12.320000000000002
C_0_21_10 Node0_21_10 GND 3.609375e-06
I_0_21_11 GND Node0_21_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_11_1 Node0_21_11 Node0_21_12 77.0
R_0_21_11_2 Node0_21_11 Node0_22_11 77.0
R_0_21_11_3 Node0_21_11 Node1_21_11 12.320000000000002
C_0_21_11 Node0_21_11 GND 3.609375e-06
I_0_21_12 GND Node0_21_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_12_1 Node0_21_12 Node0_21_13 77.0
R_0_21_12_2 Node0_21_12 Node0_22_12 77.0
R_0_21_12_3 Node0_21_12 Node1_21_12 12.320000000000002
C_0_21_12 Node0_21_12 GND 3.609375e-06
I_0_21_13 GND Node0_21_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_13_1 Node0_21_13 Node0_21_14 77.0
R_0_21_13_2 Node0_21_13 Node0_22_13 77.0
R_0_21_13_3 Node0_21_13 Node1_21_13 12.320000000000002
C_0_21_13 Node0_21_13 GND 3.609375e-06
I_0_21_14 GND Node0_21_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_14_1 Node0_21_14 Node0_21_15 77.0
R_0_21_14_2 Node0_21_14 Node0_22_14 77.0
R_0_21_14_3 Node0_21_14 Node1_21_14 12.320000000000002
C_0_21_14 Node0_21_14 GND 3.609375e-06
I_0_21_15 GND Node0_21_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_15_1 Node0_21_15 Node0_21_16 77.0
R_0_21_15_2 Node0_21_15 Node0_22_15 77.0
R_0_21_15_3 Node0_21_15 Node1_21_15 12.320000000000002
C_0_21_15 Node0_21_15 GND 3.609375e-06
I_0_21_16 GND Node0_21_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_16_1 Node0_21_16 Node0_21_17 77.0
R_0_21_16_2 Node0_21_16 Node0_22_16 77.0
R_0_21_16_3 Node0_21_16 Node1_21_16 12.320000000000002
C_0_21_16 Node0_21_16 GND 3.609375e-06
I_0_21_17 GND Node0_21_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_17_1 Node0_21_17 Node0_21_18 77.0
R_0_21_17_2 Node0_21_17 Node0_22_17 77.0
R_0_21_17_3 Node0_21_17 Node1_21_17 12.320000000000002
C_0_21_17 Node0_21_17 GND 3.609375e-06
I_0_21_18 GND Node0_21_18 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_18_1 Node0_21_18 Node0_21_19 77.0
R_0_21_18_2 Node0_21_18 Node0_22_18 77.0
R_0_21_18_3 Node0_21_18 Node1_21_18 12.320000000000002
C_0_21_18 Node0_21_18 GND 3.609375e-06
I_0_21_19 GND Node0_21_19 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_19_1 Node0_21_19 Node0_21_20 77.0
R_0_21_19_2 Node0_21_19 Node0_22_19 77.0
R_0_21_19_3 Node0_21_19 Node1_21_19 12.320000000000002
C_0_21_19 Node0_21_19 GND 3.609375e-06
I_0_21_20 GND Node0_21_20 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_20_1 Node0_21_20 Node0_21_21 77.0
R_0_21_20_2 Node0_21_20 Node0_22_20 77.0
R_0_21_20_3 Node0_21_20 Node1_21_20 12.320000000000002
C_0_21_20 Node0_21_20 GND 3.609375e-06
I_0_21_21 GND Node0_21_21 PULSE(0 0.9375A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_21_1 Node0_21_21 Node0_21_22 77.0
R_0_21_21_2 Node0_21_21 Node0_22_21 77.0
R_0_21_21_3 Node0_21_21 Node1_21_21 12.320000000000002
C_0_21_21 Node0_21_21 GND 3.609375e-06
I_0_21_22 GND Node0_21_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_22_1 Node0_21_22 Node0_21_23 77.0
R_0_21_22_2 Node0_21_22 Node0_22_22 77.0
R_0_21_22_3 Node0_21_22 Node1_21_22 12.320000000000002
C_0_21_22 Node0_21_22 GND 3.609375e-06
I_0_21_23 GND Node0_21_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_23_1 Node0_21_23 Node0_21_24 77.0
R_0_21_23_2 Node0_21_23 Node0_22_23 77.0
R_0_21_23_3 Node0_21_23 Node1_21_23 12.320000000000002
C_0_21_23 Node0_21_23 GND 3.609375e-06
I_0_21_24 GND Node0_21_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_24_1 Node0_21_24 Node0_21_25 77.0
R_0_21_24_2 Node0_21_24 Node0_22_24 77.0
R_0_21_24_3 Node0_21_24 Node1_21_24 12.320000000000002
C_0_21_24 Node0_21_24 GND 3.609375e-06
I_0_21_25 GND Node0_21_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_25_1 Node0_21_25 Node0_21_26 77.0
R_0_21_25_2 Node0_21_25 Node0_22_25 77.0
R_0_21_25_3 Node0_21_25 Node1_21_25 12.320000000000002
C_0_21_25 Node0_21_25 GND 3.609375e-06
I_0_21_26 GND Node0_21_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_26_1 Node0_21_26 Node0_21_27 77.0
R_0_21_26_2 Node0_21_26 Node0_22_26 77.0
R_0_21_26_3 Node0_21_26 Node1_21_26 12.320000000000002
C_0_21_26 Node0_21_26 GND 3.609375e-06
I_0_21_27 GND Node0_21_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_27_1 Node0_21_27 Node0_21_28 77.0
R_0_21_27_2 Node0_21_27 Node0_22_27 77.0
R_0_21_27_3 Node0_21_27 Node1_21_27 12.320000000000002
C_0_21_27 Node0_21_27 GND 3.609375e-06
I_0_21_28 GND Node0_21_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_28_1 Node0_21_28 Node0_21_29 77.0
R_0_21_28_2 Node0_21_28 Node0_22_28 77.0
R_0_21_28_3 Node0_21_28 Node1_21_28 12.320000000000002
C_0_21_28 Node0_21_28 GND 3.609375e-06
I_0_21_29 GND Node0_21_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_29_1 Node0_21_29 Node0_21_30 77.0
R_0_21_29_2 Node0_21_29 Node0_22_29 77.0
R_0_21_29_3 Node0_21_29 Node1_21_29 12.320000000000002
C_0_21_29 Node0_21_29 GND 3.609375e-06
I_0_21_30 GND Node0_21_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_30_1 Node0_21_30 Node0_21_31 77.0
R_0_21_30_2 Node0_21_30 Node0_22_30 77.0
R_0_21_30_3 Node0_21_30 Node1_21_30 12.320000000000002
C_0_21_30 Node0_21_30 GND 3.609375e-06
I_0_21_31 GND Node0_21_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_31_1 Node0_21_31 Node0_21_32 77.0
R_0_21_31_2 Node0_21_31 Node0_22_31 77.0
R_0_21_31_3 Node0_21_31 Node1_21_31 12.320000000000002
C_0_21_31 Node0_21_31 GND 3.609375e-06
I_0_21_32 GND Node0_21_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_32_1 Node0_21_32 Node0_21_33 77.0
R_0_21_32_2 Node0_21_32 Node0_22_32 77.0
R_0_21_32_3 Node0_21_32 Node1_21_32 12.320000000000002
C_0_21_32 Node0_21_32 GND 3.609375e-06
I_0_21_33 GND Node0_21_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_33_1 Node0_21_33 Node0_21_34 77.0
R_0_21_33_2 Node0_21_33 Node0_22_33 77.0
R_0_21_33_3 Node0_21_33 Node1_21_33 12.320000000000002
C_0_21_33 Node0_21_33 GND 3.609375e-06
I_0_21_34 GND Node0_21_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_34_1 Node0_21_34 Node0_21_35 77.0
R_0_21_34_2 Node0_21_34 Node0_22_34 77.0
R_0_21_34_3 Node0_21_34 Node1_21_34 12.320000000000002
C_0_21_34 Node0_21_34 GND 3.609375e-06
I_0_21_35 GND Node0_21_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_35_1 Node0_21_35 Node0_21_36 77.0
R_0_21_35_2 Node0_21_35 Node0_22_35 77.0
R_0_21_35_3 Node0_21_35 Node1_21_35 12.320000000000002
C_0_21_35 Node0_21_35 GND 3.609375e-06
I_0_21_36 GND Node0_21_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_36_1 Node0_21_36 Node0_21_37 77.0
R_0_21_36_2 Node0_21_36 Node0_22_36 77.0
R_0_21_36_3 Node0_21_36 Node1_21_36 12.320000000000002
C_0_21_36 Node0_21_36 GND 3.609375e-06
I_0_21_37 GND Node0_21_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_37_1 Node0_21_37 Node0_21_38 77.0
R_0_21_37_2 Node0_21_37 Node0_22_37 77.0
R_0_21_37_3 Node0_21_37 Node1_21_37 12.320000000000002
C_0_21_37 Node0_21_37 GND 3.609375e-06
I_0_21_38 GND Node0_21_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_38_1 Node0_21_38 Node0_21_39 77.0
R_0_21_38_2 Node0_21_38 Node0_22_38 77.0
R_0_21_38_3 Node0_21_38 Node1_21_38 12.320000000000002
C_0_21_38 Node0_21_38 GND 3.609375e-06
I_0_21_39 GND Node0_21_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_21_39_2 Node0_21_39 Node0_22_39 77.0
R_0_21_39_3 Node0_21_39 Node1_21_39 12.320000000000002
C_0_21_39 Node0_21_39 GND 3.609375e-06
I_0_22_0 GND Node0_22_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_0_1 Node0_22_0 Node0_22_1 77.0
R_0_22_0_2 Node0_22_0 Node0_23_0 77.0
R_0_22_0_3 Node0_22_0 Node1_22_0 12.320000000000002
C_0_22_0 Node0_22_0 GND 3.609375e-06
I_0_22_1 GND Node0_22_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_1_1 Node0_22_1 Node0_22_2 77.0
R_0_22_1_2 Node0_22_1 Node0_23_1 77.0
R_0_22_1_3 Node0_22_1 Node1_22_1 12.320000000000002
C_0_22_1 Node0_22_1 GND 3.609375e-06
I_0_22_2 GND Node0_22_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_2_1 Node0_22_2 Node0_22_3 77.0
R_0_22_2_2 Node0_22_2 Node0_23_2 77.0
R_0_22_2_3 Node0_22_2 Node1_22_2 12.320000000000002
C_0_22_2 Node0_22_2 GND 3.609375e-06
I_0_22_3 GND Node0_22_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_3_1 Node0_22_3 Node0_22_4 77.0
R_0_22_3_2 Node0_22_3 Node0_23_3 77.0
R_0_22_3_3 Node0_22_3 Node1_22_3 12.320000000000002
C_0_22_3 Node0_22_3 GND 3.609375e-06
I_0_22_4 GND Node0_22_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_4_1 Node0_22_4 Node0_22_5 77.0
R_0_22_4_2 Node0_22_4 Node0_23_4 77.0
R_0_22_4_3 Node0_22_4 Node1_22_4 12.320000000000002
C_0_22_4 Node0_22_4 GND 3.609375e-06
I_0_22_5 GND Node0_22_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_5_1 Node0_22_5 Node0_22_6 77.0
R_0_22_5_2 Node0_22_5 Node0_23_5 77.0
R_0_22_5_3 Node0_22_5 Node1_22_5 12.320000000000002
C_0_22_5 Node0_22_5 GND 3.609375e-06
I_0_22_6 GND Node0_22_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_6_1 Node0_22_6 Node0_22_7 77.0
R_0_22_6_2 Node0_22_6 Node0_23_6 77.0
R_0_22_6_3 Node0_22_6 Node1_22_6 12.320000000000002
C_0_22_6 Node0_22_6 GND 3.609375e-06
I_0_22_7 GND Node0_22_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_7_1 Node0_22_7 Node0_22_8 77.0
R_0_22_7_2 Node0_22_7 Node0_23_7 77.0
R_0_22_7_3 Node0_22_7 Node1_22_7 12.320000000000002
C_0_22_7 Node0_22_7 GND 3.609375e-06
I_0_22_8 GND Node0_22_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_8_1 Node0_22_8 Node0_22_9 77.0
R_0_22_8_2 Node0_22_8 Node0_23_8 77.0
R_0_22_8_3 Node0_22_8 Node1_22_8 12.320000000000002
C_0_22_8 Node0_22_8 GND 3.609375e-06
I_0_22_9 GND Node0_22_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_9_1 Node0_22_9 Node0_22_10 77.0
R_0_22_9_2 Node0_22_9 Node0_23_9 77.0
R_0_22_9_3 Node0_22_9 Node1_22_9 12.320000000000002
C_0_22_9 Node0_22_9 GND 3.609375e-06
I_0_22_10 GND Node0_22_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_10_1 Node0_22_10 Node0_22_11 77.0
R_0_22_10_2 Node0_22_10 Node0_23_10 77.0
R_0_22_10_3 Node0_22_10 Node1_22_10 12.320000000000002
C_0_22_10 Node0_22_10 GND 3.609375e-06
I_0_22_11 GND Node0_22_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_11_1 Node0_22_11 Node0_22_12 77.0
R_0_22_11_2 Node0_22_11 Node0_23_11 77.0
R_0_22_11_3 Node0_22_11 Node1_22_11 12.320000000000002
C_0_22_11 Node0_22_11 GND 3.609375e-06
I_0_22_12 GND Node0_22_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_12_1 Node0_22_12 Node0_22_13 77.0
R_0_22_12_2 Node0_22_12 Node0_23_12 77.0
R_0_22_12_3 Node0_22_12 Node1_22_12 12.320000000000002
C_0_22_12 Node0_22_12 GND 3.609375e-06
I_0_22_13 GND Node0_22_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_13_1 Node0_22_13 Node0_22_14 77.0
R_0_22_13_2 Node0_22_13 Node0_23_13 77.0
R_0_22_13_3 Node0_22_13 Node1_22_13 12.320000000000002
C_0_22_13 Node0_22_13 GND 3.609375e-06
I_0_22_14 GND Node0_22_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_14_1 Node0_22_14 Node0_22_15 77.0
R_0_22_14_2 Node0_22_14 Node0_23_14 77.0
R_0_22_14_3 Node0_22_14 Node1_22_14 12.320000000000002
C_0_22_14 Node0_22_14 GND 3.609375e-06
I_0_22_15 GND Node0_22_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_15_1 Node0_22_15 Node0_22_16 77.0
R_0_22_15_2 Node0_22_15 Node0_23_15 77.0
R_0_22_15_3 Node0_22_15 Node1_22_15 12.320000000000002
C_0_22_15 Node0_22_15 GND 3.609375e-06
I_0_22_16 GND Node0_22_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_16_1 Node0_22_16 Node0_22_17 77.0
R_0_22_16_2 Node0_22_16 Node0_23_16 77.0
R_0_22_16_3 Node0_22_16 Node1_22_16 12.320000000000002
C_0_22_16 Node0_22_16 GND 3.609375e-06
I_0_22_17 GND Node0_22_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_17_1 Node0_22_17 Node0_22_18 77.0
R_0_22_17_2 Node0_22_17 Node0_23_17 77.0
R_0_22_17_3 Node0_22_17 Node1_22_17 12.320000000000002
C_0_22_17 Node0_22_17 GND 3.609375e-06
I_0_22_18 GND Node0_22_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_18_1 Node0_22_18 Node0_22_19 77.0
R_0_22_18_2 Node0_22_18 Node0_23_18 77.0
R_0_22_18_3 Node0_22_18 Node1_22_18 12.320000000000002
C_0_22_18 Node0_22_18 GND 3.609375e-06
I_0_22_19 GND Node0_22_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_19_1 Node0_22_19 Node0_22_20 77.0
R_0_22_19_2 Node0_22_19 Node0_23_19 77.0
R_0_22_19_3 Node0_22_19 Node1_22_19 12.320000000000002
C_0_22_19 Node0_22_19 GND 3.609375e-06
I_0_22_20 GND Node0_22_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_20_1 Node0_22_20 Node0_22_21 77.0
R_0_22_20_2 Node0_22_20 Node0_23_20 77.0
R_0_22_20_3 Node0_22_20 Node1_22_20 12.320000000000002
C_0_22_20 Node0_22_20 GND 3.609375e-06
I_0_22_21 GND Node0_22_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_21_1 Node0_22_21 Node0_22_22 77.0
R_0_22_21_2 Node0_22_21 Node0_23_21 77.0
R_0_22_21_3 Node0_22_21 Node1_22_21 12.320000000000002
C_0_22_21 Node0_22_21 GND 3.609375e-06
I_0_22_22 GND Node0_22_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_22_1 Node0_22_22 Node0_22_23 77.0
R_0_22_22_2 Node0_22_22 Node0_23_22 77.0
R_0_22_22_3 Node0_22_22 Node1_22_22 12.320000000000002
C_0_22_22 Node0_22_22 GND 3.609375e-06
I_0_22_23 GND Node0_22_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_23_1 Node0_22_23 Node0_22_24 77.0
R_0_22_23_2 Node0_22_23 Node0_23_23 77.0
R_0_22_23_3 Node0_22_23 Node1_22_23 12.320000000000002
C_0_22_23 Node0_22_23 GND 3.609375e-06
I_0_22_24 GND Node0_22_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_24_1 Node0_22_24 Node0_22_25 77.0
R_0_22_24_2 Node0_22_24 Node0_23_24 77.0
R_0_22_24_3 Node0_22_24 Node1_22_24 12.320000000000002
C_0_22_24 Node0_22_24 GND 3.609375e-06
I_0_22_25 GND Node0_22_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_25_1 Node0_22_25 Node0_22_26 77.0
R_0_22_25_2 Node0_22_25 Node0_23_25 77.0
R_0_22_25_3 Node0_22_25 Node1_22_25 12.320000000000002
C_0_22_25 Node0_22_25 GND 3.609375e-06
I_0_22_26 GND Node0_22_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_26_1 Node0_22_26 Node0_22_27 77.0
R_0_22_26_2 Node0_22_26 Node0_23_26 77.0
R_0_22_26_3 Node0_22_26 Node1_22_26 12.320000000000002
C_0_22_26 Node0_22_26 GND 3.609375e-06
I_0_22_27 GND Node0_22_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_27_1 Node0_22_27 Node0_22_28 77.0
R_0_22_27_2 Node0_22_27 Node0_23_27 77.0
R_0_22_27_3 Node0_22_27 Node1_22_27 12.320000000000002
C_0_22_27 Node0_22_27 GND 3.609375e-06
I_0_22_28 GND Node0_22_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_28_1 Node0_22_28 Node0_22_29 77.0
R_0_22_28_2 Node0_22_28 Node0_23_28 77.0
R_0_22_28_3 Node0_22_28 Node1_22_28 12.320000000000002
C_0_22_28 Node0_22_28 GND 3.609375e-06
I_0_22_29 GND Node0_22_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_29_1 Node0_22_29 Node0_22_30 77.0
R_0_22_29_2 Node0_22_29 Node0_23_29 77.0
R_0_22_29_3 Node0_22_29 Node1_22_29 12.320000000000002
C_0_22_29 Node0_22_29 GND 3.609375e-06
I_0_22_30 GND Node0_22_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_30_1 Node0_22_30 Node0_22_31 77.0
R_0_22_30_2 Node0_22_30 Node0_23_30 77.0
R_0_22_30_3 Node0_22_30 Node1_22_30 12.320000000000002
C_0_22_30 Node0_22_30 GND 3.609375e-06
I_0_22_31 GND Node0_22_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_31_1 Node0_22_31 Node0_22_32 77.0
R_0_22_31_2 Node0_22_31 Node0_23_31 77.0
R_0_22_31_3 Node0_22_31 Node1_22_31 12.320000000000002
C_0_22_31 Node0_22_31 GND 3.609375e-06
I_0_22_32 GND Node0_22_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_32_1 Node0_22_32 Node0_22_33 77.0
R_0_22_32_2 Node0_22_32 Node0_23_32 77.0
R_0_22_32_3 Node0_22_32 Node1_22_32 12.320000000000002
C_0_22_32 Node0_22_32 GND 3.609375e-06
I_0_22_33 GND Node0_22_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_33_1 Node0_22_33 Node0_22_34 77.0
R_0_22_33_2 Node0_22_33 Node0_23_33 77.0
R_0_22_33_3 Node0_22_33 Node1_22_33 12.320000000000002
C_0_22_33 Node0_22_33 GND 3.609375e-06
I_0_22_34 GND Node0_22_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_34_1 Node0_22_34 Node0_22_35 77.0
R_0_22_34_2 Node0_22_34 Node0_23_34 77.0
R_0_22_34_3 Node0_22_34 Node1_22_34 12.320000000000002
C_0_22_34 Node0_22_34 GND 3.609375e-06
I_0_22_35 GND Node0_22_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_35_1 Node0_22_35 Node0_22_36 77.0
R_0_22_35_2 Node0_22_35 Node0_23_35 77.0
R_0_22_35_3 Node0_22_35 Node1_22_35 12.320000000000002
C_0_22_35 Node0_22_35 GND 3.609375e-06
I_0_22_36 GND Node0_22_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_36_1 Node0_22_36 Node0_22_37 77.0
R_0_22_36_2 Node0_22_36 Node0_23_36 77.0
R_0_22_36_3 Node0_22_36 Node1_22_36 12.320000000000002
C_0_22_36 Node0_22_36 GND 3.609375e-06
I_0_22_37 GND Node0_22_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_37_1 Node0_22_37 Node0_22_38 77.0
R_0_22_37_2 Node0_22_37 Node0_23_37 77.0
R_0_22_37_3 Node0_22_37 Node1_22_37 12.320000000000002
C_0_22_37 Node0_22_37 GND 3.609375e-06
I_0_22_38 GND Node0_22_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_38_1 Node0_22_38 Node0_22_39 77.0
R_0_22_38_2 Node0_22_38 Node0_23_38 77.0
R_0_22_38_3 Node0_22_38 Node1_22_38 12.320000000000002
C_0_22_38 Node0_22_38 GND 3.609375e-06
I_0_22_39 GND Node0_22_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_22_39_2 Node0_22_39 Node0_23_39 77.0
R_0_22_39_3 Node0_22_39 Node1_22_39 12.320000000000002
C_0_22_39 Node0_22_39 GND 3.609375e-06
I_0_23_0 GND Node0_23_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_0_1 Node0_23_0 Node0_23_1 77.0
R_0_23_0_2 Node0_23_0 Node0_24_0 77.0
R_0_23_0_3 Node0_23_0 Node1_23_0 12.320000000000002
C_0_23_0 Node0_23_0 GND 3.609375e-06
I_0_23_1 GND Node0_23_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_1_1 Node0_23_1 Node0_23_2 77.0
R_0_23_1_2 Node0_23_1 Node0_24_1 77.0
R_0_23_1_3 Node0_23_1 Node1_23_1 12.320000000000002
C_0_23_1 Node0_23_1 GND 3.609375e-06
I_0_23_2 GND Node0_23_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_2_1 Node0_23_2 Node0_23_3 77.0
R_0_23_2_2 Node0_23_2 Node0_24_2 77.0
R_0_23_2_3 Node0_23_2 Node1_23_2 12.320000000000002
C_0_23_2 Node0_23_2 GND 3.609375e-06
I_0_23_3 GND Node0_23_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_3_1 Node0_23_3 Node0_23_4 77.0
R_0_23_3_2 Node0_23_3 Node0_24_3 77.0
R_0_23_3_3 Node0_23_3 Node1_23_3 12.320000000000002
C_0_23_3 Node0_23_3 GND 3.609375e-06
I_0_23_4 GND Node0_23_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_4_1 Node0_23_4 Node0_23_5 77.0
R_0_23_4_2 Node0_23_4 Node0_24_4 77.0
R_0_23_4_3 Node0_23_4 Node1_23_4 12.320000000000002
C_0_23_4 Node0_23_4 GND 3.609375e-06
I_0_23_5 GND Node0_23_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_5_1 Node0_23_5 Node0_23_6 77.0
R_0_23_5_2 Node0_23_5 Node0_24_5 77.0
R_0_23_5_3 Node0_23_5 Node1_23_5 12.320000000000002
C_0_23_5 Node0_23_5 GND 3.609375e-06
I_0_23_6 GND Node0_23_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_6_1 Node0_23_6 Node0_23_7 77.0
R_0_23_6_2 Node0_23_6 Node0_24_6 77.0
R_0_23_6_3 Node0_23_6 Node1_23_6 12.320000000000002
C_0_23_6 Node0_23_6 GND 3.609375e-06
I_0_23_7 GND Node0_23_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_7_1 Node0_23_7 Node0_23_8 77.0
R_0_23_7_2 Node0_23_7 Node0_24_7 77.0
R_0_23_7_3 Node0_23_7 Node1_23_7 12.320000000000002
C_0_23_7 Node0_23_7 GND 3.609375e-06
I_0_23_8 GND Node0_23_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_8_1 Node0_23_8 Node0_23_9 77.0
R_0_23_8_2 Node0_23_8 Node0_24_8 77.0
R_0_23_8_3 Node0_23_8 Node1_23_8 12.320000000000002
C_0_23_8 Node0_23_8 GND 3.609375e-06
I_0_23_9 GND Node0_23_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_9_1 Node0_23_9 Node0_23_10 77.0
R_0_23_9_2 Node0_23_9 Node0_24_9 77.0
R_0_23_9_3 Node0_23_9 Node1_23_9 12.320000000000002
C_0_23_9 Node0_23_9 GND 3.609375e-06
I_0_23_10 GND Node0_23_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_10_1 Node0_23_10 Node0_23_11 77.0
R_0_23_10_2 Node0_23_10 Node0_24_10 77.0
R_0_23_10_3 Node0_23_10 Node1_23_10 12.320000000000002
C_0_23_10 Node0_23_10 GND 3.609375e-06
I_0_23_11 GND Node0_23_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_11_1 Node0_23_11 Node0_23_12 77.0
R_0_23_11_2 Node0_23_11 Node0_24_11 77.0
R_0_23_11_3 Node0_23_11 Node1_23_11 12.320000000000002
C_0_23_11 Node0_23_11 GND 3.609375e-06
I_0_23_12 GND Node0_23_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_12_1 Node0_23_12 Node0_23_13 77.0
R_0_23_12_2 Node0_23_12 Node0_24_12 77.0
R_0_23_12_3 Node0_23_12 Node1_23_12 12.320000000000002
C_0_23_12 Node0_23_12 GND 3.609375e-06
I_0_23_13 GND Node0_23_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_13_1 Node0_23_13 Node0_23_14 77.0
R_0_23_13_2 Node0_23_13 Node0_24_13 77.0
R_0_23_13_3 Node0_23_13 Node1_23_13 12.320000000000002
C_0_23_13 Node0_23_13 GND 3.609375e-06
I_0_23_14 GND Node0_23_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_14_1 Node0_23_14 Node0_23_15 77.0
R_0_23_14_2 Node0_23_14 Node0_24_14 77.0
R_0_23_14_3 Node0_23_14 Node1_23_14 12.320000000000002
C_0_23_14 Node0_23_14 GND 3.609375e-06
I_0_23_15 GND Node0_23_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_15_1 Node0_23_15 Node0_23_16 77.0
R_0_23_15_2 Node0_23_15 Node0_24_15 77.0
R_0_23_15_3 Node0_23_15 Node1_23_15 12.320000000000002
C_0_23_15 Node0_23_15 GND 3.609375e-06
I_0_23_16 GND Node0_23_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_16_1 Node0_23_16 Node0_23_17 77.0
R_0_23_16_2 Node0_23_16 Node0_24_16 77.0
R_0_23_16_3 Node0_23_16 Node1_23_16 12.320000000000002
C_0_23_16 Node0_23_16 GND 3.609375e-06
I_0_23_17 GND Node0_23_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_17_1 Node0_23_17 Node0_23_18 77.0
R_0_23_17_2 Node0_23_17 Node0_24_17 77.0
R_0_23_17_3 Node0_23_17 Node1_23_17 12.320000000000002
C_0_23_17 Node0_23_17 GND 3.609375e-06
I_0_23_18 GND Node0_23_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_18_1 Node0_23_18 Node0_23_19 77.0
R_0_23_18_2 Node0_23_18 Node0_24_18 77.0
R_0_23_18_3 Node0_23_18 Node1_23_18 12.320000000000002
C_0_23_18 Node0_23_18 GND 3.609375e-06
I_0_23_19 GND Node0_23_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_19_1 Node0_23_19 Node0_23_20 77.0
R_0_23_19_2 Node0_23_19 Node0_24_19 77.0
R_0_23_19_3 Node0_23_19 Node1_23_19 12.320000000000002
C_0_23_19 Node0_23_19 GND 3.609375e-06
I_0_23_20 GND Node0_23_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_20_1 Node0_23_20 Node0_23_21 77.0
R_0_23_20_2 Node0_23_20 Node0_24_20 77.0
R_0_23_20_3 Node0_23_20 Node1_23_20 12.320000000000002
C_0_23_20 Node0_23_20 GND 3.609375e-06
I_0_23_21 GND Node0_23_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_21_1 Node0_23_21 Node0_23_22 77.0
R_0_23_21_2 Node0_23_21 Node0_24_21 77.0
R_0_23_21_3 Node0_23_21 Node1_23_21 12.320000000000002
C_0_23_21 Node0_23_21 GND 3.609375e-06
I_0_23_22 GND Node0_23_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_22_1 Node0_23_22 Node0_23_23 77.0
R_0_23_22_2 Node0_23_22 Node0_24_22 77.0
R_0_23_22_3 Node0_23_22 Node1_23_22 12.320000000000002
C_0_23_22 Node0_23_22 GND 3.609375e-06
I_0_23_23 GND Node0_23_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_23_1 Node0_23_23 Node0_23_24 77.0
R_0_23_23_2 Node0_23_23 Node0_24_23 77.0
R_0_23_23_3 Node0_23_23 Node1_23_23 12.320000000000002
C_0_23_23 Node0_23_23 GND 3.609375e-06
I_0_23_24 GND Node0_23_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_24_1 Node0_23_24 Node0_23_25 77.0
R_0_23_24_2 Node0_23_24 Node0_24_24 77.0
R_0_23_24_3 Node0_23_24 Node1_23_24 12.320000000000002
C_0_23_24 Node0_23_24 GND 3.609375e-06
I_0_23_25 GND Node0_23_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_25_1 Node0_23_25 Node0_23_26 77.0
R_0_23_25_2 Node0_23_25 Node0_24_25 77.0
R_0_23_25_3 Node0_23_25 Node1_23_25 12.320000000000002
C_0_23_25 Node0_23_25 GND 3.609375e-06
I_0_23_26 GND Node0_23_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_26_1 Node0_23_26 Node0_23_27 77.0
R_0_23_26_2 Node0_23_26 Node0_24_26 77.0
R_0_23_26_3 Node0_23_26 Node1_23_26 12.320000000000002
C_0_23_26 Node0_23_26 GND 3.609375e-06
I_0_23_27 GND Node0_23_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_27_1 Node0_23_27 Node0_23_28 77.0
R_0_23_27_2 Node0_23_27 Node0_24_27 77.0
R_0_23_27_3 Node0_23_27 Node1_23_27 12.320000000000002
C_0_23_27 Node0_23_27 GND 3.609375e-06
I_0_23_28 GND Node0_23_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_28_1 Node0_23_28 Node0_23_29 77.0
R_0_23_28_2 Node0_23_28 Node0_24_28 77.0
R_0_23_28_3 Node0_23_28 Node1_23_28 12.320000000000002
C_0_23_28 Node0_23_28 GND 3.609375e-06
I_0_23_29 GND Node0_23_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_29_1 Node0_23_29 Node0_23_30 77.0
R_0_23_29_2 Node0_23_29 Node0_24_29 77.0
R_0_23_29_3 Node0_23_29 Node1_23_29 12.320000000000002
C_0_23_29 Node0_23_29 GND 3.609375e-06
I_0_23_30 GND Node0_23_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_30_1 Node0_23_30 Node0_23_31 77.0
R_0_23_30_2 Node0_23_30 Node0_24_30 77.0
R_0_23_30_3 Node0_23_30 Node1_23_30 12.320000000000002
C_0_23_30 Node0_23_30 GND 3.609375e-06
I_0_23_31 GND Node0_23_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_31_1 Node0_23_31 Node0_23_32 77.0
R_0_23_31_2 Node0_23_31 Node0_24_31 77.0
R_0_23_31_3 Node0_23_31 Node1_23_31 12.320000000000002
C_0_23_31 Node0_23_31 GND 3.609375e-06
I_0_23_32 GND Node0_23_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_32_1 Node0_23_32 Node0_23_33 77.0
R_0_23_32_2 Node0_23_32 Node0_24_32 77.0
R_0_23_32_3 Node0_23_32 Node1_23_32 12.320000000000002
C_0_23_32 Node0_23_32 GND 3.609375e-06
I_0_23_33 GND Node0_23_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_33_1 Node0_23_33 Node0_23_34 77.0
R_0_23_33_2 Node0_23_33 Node0_24_33 77.0
R_0_23_33_3 Node0_23_33 Node1_23_33 12.320000000000002
C_0_23_33 Node0_23_33 GND 3.609375e-06
I_0_23_34 GND Node0_23_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_34_1 Node0_23_34 Node0_23_35 77.0
R_0_23_34_2 Node0_23_34 Node0_24_34 77.0
R_0_23_34_3 Node0_23_34 Node1_23_34 12.320000000000002
C_0_23_34 Node0_23_34 GND 3.609375e-06
I_0_23_35 GND Node0_23_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_35_1 Node0_23_35 Node0_23_36 77.0
R_0_23_35_2 Node0_23_35 Node0_24_35 77.0
R_0_23_35_3 Node0_23_35 Node1_23_35 12.320000000000002
C_0_23_35 Node0_23_35 GND 3.609375e-06
I_0_23_36 GND Node0_23_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_36_1 Node0_23_36 Node0_23_37 77.0
R_0_23_36_2 Node0_23_36 Node0_24_36 77.0
R_0_23_36_3 Node0_23_36 Node1_23_36 12.320000000000002
C_0_23_36 Node0_23_36 GND 3.609375e-06
I_0_23_37 GND Node0_23_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_37_1 Node0_23_37 Node0_23_38 77.0
R_0_23_37_2 Node0_23_37 Node0_24_37 77.0
R_0_23_37_3 Node0_23_37 Node1_23_37 12.320000000000002
C_0_23_37 Node0_23_37 GND 3.609375e-06
I_0_23_38 GND Node0_23_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_38_1 Node0_23_38 Node0_23_39 77.0
R_0_23_38_2 Node0_23_38 Node0_24_38 77.0
R_0_23_38_3 Node0_23_38 Node1_23_38 12.320000000000002
C_0_23_38 Node0_23_38 GND 3.609375e-06
I_0_23_39 GND Node0_23_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_23_39_2 Node0_23_39 Node0_24_39 77.0
R_0_23_39_3 Node0_23_39 Node1_23_39 12.320000000000002
C_0_23_39 Node0_23_39 GND 3.609375e-06
I_0_24_0 GND Node0_24_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_0_1 Node0_24_0 Node0_24_1 77.0
R_0_24_0_2 Node0_24_0 Node0_25_0 77.0
R_0_24_0_3 Node0_24_0 Node1_24_0 12.320000000000002
C_0_24_0 Node0_24_0 GND 3.609375e-06
I_0_24_1 GND Node0_24_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_1_1 Node0_24_1 Node0_24_2 77.0
R_0_24_1_2 Node0_24_1 Node0_25_1 77.0
R_0_24_1_3 Node0_24_1 Node1_24_1 12.320000000000002
C_0_24_1 Node0_24_1 GND 3.609375e-06
I_0_24_2 GND Node0_24_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_2_1 Node0_24_2 Node0_24_3 77.0
R_0_24_2_2 Node0_24_2 Node0_25_2 77.0
R_0_24_2_3 Node0_24_2 Node1_24_2 12.320000000000002
C_0_24_2 Node0_24_2 GND 3.609375e-06
I_0_24_3 GND Node0_24_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_3_1 Node0_24_3 Node0_24_4 77.0
R_0_24_3_2 Node0_24_3 Node0_25_3 77.0
R_0_24_3_3 Node0_24_3 Node1_24_3 12.320000000000002
C_0_24_3 Node0_24_3 GND 3.609375e-06
I_0_24_4 GND Node0_24_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_4_1 Node0_24_4 Node0_24_5 77.0
R_0_24_4_2 Node0_24_4 Node0_25_4 77.0
R_0_24_4_3 Node0_24_4 Node1_24_4 12.320000000000002
C_0_24_4 Node0_24_4 GND 3.609375e-06
I_0_24_5 GND Node0_24_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_5_1 Node0_24_5 Node0_24_6 77.0
R_0_24_5_2 Node0_24_5 Node0_25_5 77.0
R_0_24_5_3 Node0_24_5 Node1_24_5 12.320000000000002
C_0_24_5 Node0_24_5 GND 3.609375e-06
I_0_24_6 GND Node0_24_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_6_1 Node0_24_6 Node0_24_7 77.0
R_0_24_6_2 Node0_24_6 Node0_25_6 77.0
R_0_24_6_3 Node0_24_6 Node1_24_6 12.320000000000002
C_0_24_6 Node0_24_6 GND 3.609375e-06
I_0_24_7 GND Node0_24_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_7_1 Node0_24_7 Node0_24_8 77.0
R_0_24_7_2 Node0_24_7 Node0_25_7 77.0
R_0_24_7_3 Node0_24_7 Node1_24_7 12.320000000000002
C_0_24_7 Node0_24_7 GND 3.609375e-06
I_0_24_8 GND Node0_24_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_8_1 Node0_24_8 Node0_24_9 77.0
R_0_24_8_2 Node0_24_8 Node0_25_8 77.0
R_0_24_8_3 Node0_24_8 Node1_24_8 12.320000000000002
C_0_24_8 Node0_24_8 GND 3.609375e-06
I_0_24_9 GND Node0_24_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_9_1 Node0_24_9 Node0_24_10 77.0
R_0_24_9_2 Node0_24_9 Node0_25_9 77.0
R_0_24_9_3 Node0_24_9 Node1_24_9 12.320000000000002
C_0_24_9 Node0_24_9 GND 3.609375e-06
I_0_24_10 GND Node0_24_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_10_1 Node0_24_10 Node0_24_11 77.0
R_0_24_10_2 Node0_24_10 Node0_25_10 77.0
R_0_24_10_3 Node0_24_10 Node1_24_10 12.320000000000002
C_0_24_10 Node0_24_10 GND 3.609375e-06
I_0_24_11 GND Node0_24_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_11_1 Node0_24_11 Node0_24_12 77.0
R_0_24_11_2 Node0_24_11 Node0_25_11 77.0
R_0_24_11_3 Node0_24_11 Node1_24_11 12.320000000000002
C_0_24_11 Node0_24_11 GND 3.609375e-06
I_0_24_12 GND Node0_24_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_12_1 Node0_24_12 Node0_24_13 77.0
R_0_24_12_2 Node0_24_12 Node0_25_12 77.0
R_0_24_12_3 Node0_24_12 Node1_24_12 12.320000000000002
C_0_24_12 Node0_24_12 GND 3.609375e-06
I_0_24_13 GND Node0_24_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_13_1 Node0_24_13 Node0_24_14 77.0
R_0_24_13_2 Node0_24_13 Node0_25_13 77.0
R_0_24_13_3 Node0_24_13 Node1_24_13 12.320000000000002
C_0_24_13 Node0_24_13 GND 3.609375e-06
I_0_24_14 GND Node0_24_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_14_1 Node0_24_14 Node0_24_15 77.0
R_0_24_14_2 Node0_24_14 Node0_25_14 77.0
R_0_24_14_3 Node0_24_14 Node1_24_14 12.320000000000002
C_0_24_14 Node0_24_14 GND 3.609375e-06
I_0_24_15 GND Node0_24_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_15_1 Node0_24_15 Node0_24_16 77.0
R_0_24_15_2 Node0_24_15 Node0_25_15 77.0
R_0_24_15_3 Node0_24_15 Node1_24_15 12.320000000000002
C_0_24_15 Node0_24_15 GND 3.609375e-06
I_0_24_16 GND Node0_24_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_16_1 Node0_24_16 Node0_24_17 77.0
R_0_24_16_2 Node0_24_16 Node0_25_16 77.0
R_0_24_16_3 Node0_24_16 Node1_24_16 12.320000000000002
C_0_24_16 Node0_24_16 GND 3.609375e-06
I_0_24_17 GND Node0_24_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_17_1 Node0_24_17 Node0_24_18 77.0
R_0_24_17_2 Node0_24_17 Node0_25_17 77.0
R_0_24_17_3 Node0_24_17 Node1_24_17 12.320000000000002
C_0_24_17 Node0_24_17 GND 3.609375e-06
I_0_24_18 GND Node0_24_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_18_1 Node0_24_18 Node0_24_19 77.0
R_0_24_18_2 Node0_24_18 Node0_25_18 77.0
R_0_24_18_3 Node0_24_18 Node1_24_18 12.320000000000002
C_0_24_18 Node0_24_18 GND 3.609375e-06
I_0_24_19 GND Node0_24_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_19_1 Node0_24_19 Node0_24_20 77.0
R_0_24_19_2 Node0_24_19 Node0_25_19 77.0
R_0_24_19_3 Node0_24_19 Node1_24_19 12.320000000000002
C_0_24_19 Node0_24_19 GND 3.609375e-06
I_0_24_20 GND Node0_24_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_20_1 Node0_24_20 Node0_24_21 77.0
R_0_24_20_2 Node0_24_20 Node0_25_20 77.0
R_0_24_20_3 Node0_24_20 Node1_24_20 12.320000000000002
C_0_24_20 Node0_24_20 GND 3.609375e-06
I_0_24_21 GND Node0_24_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_21_1 Node0_24_21 Node0_24_22 77.0
R_0_24_21_2 Node0_24_21 Node0_25_21 77.0
R_0_24_21_3 Node0_24_21 Node1_24_21 12.320000000000002
C_0_24_21 Node0_24_21 GND 3.609375e-06
I_0_24_22 GND Node0_24_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_22_1 Node0_24_22 Node0_24_23 77.0
R_0_24_22_2 Node0_24_22 Node0_25_22 77.0
R_0_24_22_3 Node0_24_22 Node1_24_22 12.320000000000002
C_0_24_22 Node0_24_22 GND 3.609375e-06
I_0_24_23 GND Node0_24_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_23_1 Node0_24_23 Node0_24_24 77.0
R_0_24_23_2 Node0_24_23 Node0_25_23 77.0
R_0_24_23_3 Node0_24_23 Node1_24_23 12.320000000000002
C_0_24_23 Node0_24_23 GND 3.609375e-06
I_0_24_24 GND Node0_24_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_24_1 Node0_24_24 Node0_24_25 77.0
R_0_24_24_2 Node0_24_24 Node0_25_24 77.0
R_0_24_24_3 Node0_24_24 Node1_24_24 12.320000000000002
C_0_24_24 Node0_24_24 GND 3.609375e-06
I_0_24_25 GND Node0_24_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_25_1 Node0_24_25 Node0_24_26 77.0
R_0_24_25_2 Node0_24_25 Node0_25_25 77.0
R_0_24_25_3 Node0_24_25 Node1_24_25 12.320000000000002
C_0_24_25 Node0_24_25 GND 3.609375e-06
I_0_24_26 GND Node0_24_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_26_1 Node0_24_26 Node0_24_27 77.0
R_0_24_26_2 Node0_24_26 Node0_25_26 77.0
R_0_24_26_3 Node0_24_26 Node1_24_26 12.320000000000002
C_0_24_26 Node0_24_26 GND 3.609375e-06
I_0_24_27 GND Node0_24_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_27_1 Node0_24_27 Node0_24_28 77.0
R_0_24_27_2 Node0_24_27 Node0_25_27 77.0
R_0_24_27_3 Node0_24_27 Node1_24_27 12.320000000000002
C_0_24_27 Node0_24_27 GND 3.609375e-06
I_0_24_28 GND Node0_24_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_28_1 Node0_24_28 Node0_24_29 77.0
R_0_24_28_2 Node0_24_28 Node0_25_28 77.0
R_0_24_28_3 Node0_24_28 Node1_24_28 12.320000000000002
C_0_24_28 Node0_24_28 GND 3.609375e-06
I_0_24_29 GND Node0_24_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_29_1 Node0_24_29 Node0_24_30 77.0
R_0_24_29_2 Node0_24_29 Node0_25_29 77.0
R_0_24_29_3 Node0_24_29 Node1_24_29 12.320000000000002
C_0_24_29 Node0_24_29 GND 3.609375e-06
I_0_24_30 GND Node0_24_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_30_1 Node0_24_30 Node0_24_31 77.0
R_0_24_30_2 Node0_24_30 Node0_25_30 77.0
R_0_24_30_3 Node0_24_30 Node1_24_30 12.320000000000002
C_0_24_30 Node0_24_30 GND 3.609375e-06
I_0_24_31 GND Node0_24_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_31_1 Node0_24_31 Node0_24_32 77.0
R_0_24_31_2 Node0_24_31 Node0_25_31 77.0
R_0_24_31_3 Node0_24_31 Node1_24_31 12.320000000000002
C_0_24_31 Node0_24_31 GND 3.609375e-06
I_0_24_32 GND Node0_24_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_32_1 Node0_24_32 Node0_24_33 77.0
R_0_24_32_2 Node0_24_32 Node0_25_32 77.0
R_0_24_32_3 Node0_24_32 Node1_24_32 12.320000000000002
C_0_24_32 Node0_24_32 GND 3.609375e-06
I_0_24_33 GND Node0_24_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_33_1 Node0_24_33 Node0_24_34 77.0
R_0_24_33_2 Node0_24_33 Node0_25_33 77.0
R_0_24_33_3 Node0_24_33 Node1_24_33 12.320000000000002
C_0_24_33 Node0_24_33 GND 3.609375e-06
I_0_24_34 GND Node0_24_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_34_1 Node0_24_34 Node0_24_35 77.0
R_0_24_34_2 Node0_24_34 Node0_25_34 77.0
R_0_24_34_3 Node0_24_34 Node1_24_34 12.320000000000002
C_0_24_34 Node0_24_34 GND 3.609375e-06
I_0_24_35 GND Node0_24_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_35_1 Node0_24_35 Node0_24_36 77.0
R_0_24_35_2 Node0_24_35 Node0_25_35 77.0
R_0_24_35_3 Node0_24_35 Node1_24_35 12.320000000000002
C_0_24_35 Node0_24_35 GND 3.609375e-06
I_0_24_36 GND Node0_24_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_36_1 Node0_24_36 Node0_24_37 77.0
R_0_24_36_2 Node0_24_36 Node0_25_36 77.0
R_0_24_36_3 Node0_24_36 Node1_24_36 12.320000000000002
C_0_24_36 Node0_24_36 GND 3.609375e-06
I_0_24_37 GND Node0_24_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_37_1 Node0_24_37 Node0_24_38 77.0
R_0_24_37_2 Node0_24_37 Node0_25_37 77.0
R_0_24_37_3 Node0_24_37 Node1_24_37 12.320000000000002
C_0_24_37 Node0_24_37 GND 3.609375e-06
I_0_24_38 GND Node0_24_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_38_1 Node0_24_38 Node0_24_39 77.0
R_0_24_38_2 Node0_24_38 Node0_25_38 77.0
R_0_24_38_3 Node0_24_38 Node1_24_38 12.320000000000002
C_0_24_38 Node0_24_38 GND 3.609375e-06
I_0_24_39 GND Node0_24_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_24_39_2 Node0_24_39 Node0_25_39 77.0
R_0_24_39_3 Node0_24_39 Node1_24_39 12.320000000000002
C_0_24_39 Node0_24_39 GND 3.609375e-06
I_0_25_0 GND Node0_25_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_0_1 Node0_25_0 Node0_25_1 77.0
R_0_25_0_2 Node0_25_0 Node0_26_0 77.0
R_0_25_0_3 Node0_25_0 Node1_25_0 12.320000000000002
C_0_25_0 Node0_25_0 GND 3.609375e-06
I_0_25_1 GND Node0_25_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_1_1 Node0_25_1 Node0_25_2 77.0
R_0_25_1_2 Node0_25_1 Node0_26_1 77.0
R_0_25_1_3 Node0_25_1 Node1_25_1 12.320000000000002
C_0_25_1 Node0_25_1 GND 3.609375e-06
I_0_25_2 GND Node0_25_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_2_1 Node0_25_2 Node0_25_3 77.0
R_0_25_2_2 Node0_25_2 Node0_26_2 77.0
R_0_25_2_3 Node0_25_2 Node1_25_2 12.320000000000002
C_0_25_2 Node0_25_2 GND 3.609375e-06
I_0_25_3 GND Node0_25_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_3_1 Node0_25_3 Node0_25_4 77.0
R_0_25_3_2 Node0_25_3 Node0_26_3 77.0
R_0_25_3_3 Node0_25_3 Node1_25_3 12.320000000000002
C_0_25_3 Node0_25_3 GND 3.609375e-06
I_0_25_4 GND Node0_25_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_4_1 Node0_25_4 Node0_25_5 77.0
R_0_25_4_2 Node0_25_4 Node0_26_4 77.0
R_0_25_4_3 Node0_25_4 Node1_25_4 12.320000000000002
C_0_25_4 Node0_25_4 GND 3.609375e-06
I_0_25_5 GND Node0_25_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_5_1 Node0_25_5 Node0_25_6 77.0
R_0_25_5_2 Node0_25_5 Node0_26_5 77.0
R_0_25_5_3 Node0_25_5 Node1_25_5 12.320000000000002
C_0_25_5 Node0_25_5 GND 3.609375e-06
I_0_25_6 GND Node0_25_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_6_1 Node0_25_6 Node0_25_7 77.0
R_0_25_6_2 Node0_25_6 Node0_26_6 77.0
R_0_25_6_3 Node0_25_6 Node1_25_6 12.320000000000002
C_0_25_6 Node0_25_6 GND 3.609375e-06
I_0_25_7 GND Node0_25_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_7_1 Node0_25_7 Node0_25_8 77.0
R_0_25_7_2 Node0_25_7 Node0_26_7 77.0
R_0_25_7_3 Node0_25_7 Node1_25_7 12.320000000000002
C_0_25_7 Node0_25_7 GND 3.609375e-06
I_0_25_8 GND Node0_25_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_8_1 Node0_25_8 Node0_25_9 77.0
R_0_25_8_2 Node0_25_8 Node0_26_8 77.0
R_0_25_8_3 Node0_25_8 Node1_25_8 12.320000000000002
C_0_25_8 Node0_25_8 GND 3.609375e-06
I_0_25_9 GND Node0_25_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_9_1 Node0_25_9 Node0_25_10 77.0
R_0_25_9_2 Node0_25_9 Node0_26_9 77.0
R_0_25_9_3 Node0_25_9 Node1_25_9 12.320000000000002
C_0_25_9 Node0_25_9 GND 3.609375e-06
I_0_25_10 GND Node0_25_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_10_1 Node0_25_10 Node0_25_11 77.0
R_0_25_10_2 Node0_25_10 Node0_26_10 77.0
R_0_25_10_3 Node0_25_10 Node1_25_10 12.320000000000002
C_0_25_10 Node0_25_10 GND 3.609375e-06
I_0_25_11 GND Node0_25_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_11_1 Node0_25_11 Node0_25_12 77.0
R_0_25_11_2 Node0_25_11 Node0_26_11 77.0
R_0_25_11_3 Node0_25_11 Node1_25_11 12.320000000000002
C_0_25_11 Node0_25_11 GND 3.609375e-06
I_0_25_12 GND Node0_25_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_12_1 Node0_25_12 Node0_25_13 77.0
R_0_25_12_2 Node0_25_12 Node0_26_12 77.0
R_0_25_12_3 Node0_25_12 Node1_25_12 12.320000000000002
C_0_25_12 Node0_25_12 GND 3.609375e-06
I_0_25_13 GND Node0_25_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_13_1 Node0_25_13 Node0_25_14 77.0
R_0_25_13_2 Node0_25_13 Node0_26_13 77.0
R_0_25_13_3 Node0_25_13 Node1_25_13 12.320000000000002
C_0_25_13 Node0_25_13 GND 3.609375e-06
I_0_25_14 GND Node0_25_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_14_1 Node0_25_14 Node0_25_15 77.0
R_0_25_14_2 Node0_25_14 Node0_26_14 77.0
R_0_25_14_3 Node0_25_14 Node1_25_14 12.320000000000002
C_0_25_14 Node0_25_14 GND 3.609375e-06
I_0_25_15 GND Node0_25_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_15_1 Node0_25_15 Node0_25_16 77.0
R_0_25_15_2 Node0_25_15 Node0_26_15 77.0
R_0_25_15_3 Node0_25_15 Node1_25_15 12.320000000000002
C_0_25_15 Node0_25_15 GND 3.609375e-06
I_0_25_16 GND Node0_25_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_16_1 Node0_25_16 Node0_25_17 77.0
R_0_25_16_2 Node0_25_16 Node0_26_16 77.0
R_0_25_16_3 Node0_25_16 Node1_25_16 12.320000000000002
C_0_25_16 Node0_25_16 GND 3.609375e-06
I_0_25_17 GND Node0_25_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_17_1 Node0_25_17 Node0_25_18 77.0
R_0_25_17_2 Node0_25_17 Node0_26_17 77.0
R_0_25_17_3 Node0_25_17 Node1_25_17 12.320000000000002
C_0_25_17 Node0_25_17 GND 3.609375e-06
I_0_25_18 GND Node0_25_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_18_1 Node0_25_18 Node0_25_19 77.0
R_0_25_18_2 Node0_25_18 Node0_26_18 77.0
R_0_25_18_3 Node0_25_18 Node1_25_18 12.320000000000002
C_0_25_18 Node0_25_18 GND 3.609375e-06
I_0_25_19 GND Node0_25_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_19_1 Node0_25_19 Node0_25_20 77.0
R_0_25_19_2 Node0_25_19 Node0_26_19 77.0
R_0_25_19_3 Node0_25_19 Node1_25_19 12.320000000000002
C_0_25_19 Node0_25_19 GND 3.609375e-06
I_0_25_20 GND Node0_25_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_20_1 Node0_25_20 Node0_25_21 77.0
R_0_25_20_2 Node0_25_20 Node0_26_20 77.0
R_0_25_20_3 Node0_25_20 Node1_25_20 12.320000000000002
C_0_25_20 Node0_25_20 GND 3.609375e-06
I_0_25_21 GND Node0_25_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_21_1 Node0_25_21 Node0_25_22 77.0
R_0_25_21_2 Node0_25_21 Node0_26_21 77.0
R_0_25_21_3 Node0_25_21 Node1_25_21 12.320000000000002
C_0_25_21 Node0_25_21 GND 3.609375e-06
I_0_25_22 GND Node0_25_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_22_1 Node0_25_22 Node0_25_23 77.0
R_0_25_22_2 Node0_25_22 Node0_26_22 77.0
R_0_25_22_3 Node0_25_22 Node1_25_22 12.320000000000002
C_0_25_22 Node0_25_22 GND 3.609375e-06
I_0_25_23 GND Node0_25_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_23_1 Node0_25_23 Node0_25_24 77.0
R_0_25_23_2 Node0_25_23 Node0_26_23 77.0
R_0_25_23_3 Node0_25_23 Node1_25_23 12.320000000000002
C_0_25_23 Node0_25_23 GND 3.609375e-06
I_0_25_24 GND Node0_25_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_24_1 Node0_25_24 Node0_25_25 77.0
R_0_25_24_2 Node0_25_24 Node0_26_24 77.0
R_0_25_24_3 Node0_25_24 Node1_25_24 12.320000000000002
C_0_25_24 Node0_25_24 GND 3.609375e-06
I_0_25_25 GND Node0_25_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_25_1 Node0_25_25 Node0_25_26 77.0
R_0_25_25_2 Node0_25_25 Node0_26_25 77.0
R_0_25_25_3 Node0_25_25 Node1_25_25 12.320000000000002
C_0_25_25 Node0_25_25 GND 3.609375e-06
I_0_25_26 GND Node0_25_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_26_1 Node0_25_26 Node0_25_27 77.0
R_0_25_26_2 Node0_25_26 Node0_26_26 77.0
R_0_25_26_3 Node0_25_26 Node1_25_26 12.320000000000002
C_0_25_26 Node0_25_26 GND 3.609375e-06
I_0_25_27 GND Node0_25_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_27_1 Node0_25_27 Node0_25_28 77.0
R_0_25_27_2 Node0_25_27 Node0_26_27 77.0
R_0_25_27_3 Node0_25_27 Node1_25_27 12.320000000000002
C_0_25_27 Node0_25_27 GND 3.609375e-06
I_0_25_28 GND Node0_25_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_28_1 Node0_25_28 Node0_25_29 77.0
R_0_25_28_2 Node0_25_28 Node0_26_28 77.0
R_0_25_28_3 Node0_25_28 Node1_25_28 12.320000000000002
C_0_25_28 Node0_25_28 GND 3.609375e-06
I_0_25_29 GND Node0_25_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_29_1 Node0_25_29 Node0_25_30 77.0
R_0_25_29_2 Node0_25_29 Node0_26_29 77.0
R_0_25_29_3 Node0_25_29 Node1_25_29 12.320000000000002
C_0_25_29 Node0_25_29 GND 3.609375e-06
I_0_25_30 GND Node0_25_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_30_1 Node0_25_30 Node0_25_31 77.0
R_0_25_30_2 Node0_25_30 Node0_26_30 77.0
R_0_25_30_3 Node0_25_30 Node1_25_30 12.320000000000002
C_0_25_30 Node0_25_30 GND 3.609375e-06
I_0_25_31 GND Node0_25_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_31_1 Node0_25_31 Node0_25_32 77.0
R_0_25_31_2 Node0_25_31 Node0_26_31 77.0
R_0_25_31_3 Node0_25_31 Node1_25_31 12.320000000000002
C_0_25_31 Node0_25_31 GND 3.609375e-06
I_0_25_32 GND Node0_25_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_32_1 Node0_25_32 Node0_25_33 77.0
R_0_25_32_2 Node0_25_32 Node0_26_32 77.0
R_0_25_32_3 Node0_25_32 Node1_25_32 12.320000000000002
C_0_25_32 Node0_25_32 GND 3.609375e-06
I_0_25_33 GND Node0_25_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_33_1 Node0_25_33 Node0_25_34 77.0
R_0_25_33_2 Node0_25_33 Node0_26_33 77.0
R_0_25_33_3 Node0_25_33 Node1_25_33 12.320000000000002
C_0_25_33 Node0_25_33 GND 3.609375e-06
I_0_25_34 GND Node0_25_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_34_1 Node0_25_34 Node0_25_35 77.0
R_0_25_34_2 Node0_25_34 Node0_26_34 77.0
R_0_25_34_3 Node0_25_34 Node1_25_34 12.320000000000002
C_0_25_34 Node0_25_34 GND 3.609375e-06
I_0_25_35 GND Node0_25_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_35_1 Node0_25_35 Node0_25_36 77.0
R_0_25_35_2 Node0_25_35 Node0_26_35 77.0
R_0_25_35_3 Node0_25_35 Node1_25_35 12.320000000000002
C_0_25_35 Node0_25_35 GND 3.609375e-06
I_0_25_36 GND Node0_25_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_36_1 Node0_25_36 Node0_25_37 77.0
R_0_25_36_2 Node0_25_36 Node0_26_36 77.0
R_0_25_36_3 Node0_25_36 Node1_25_36 12.320000000000002
C_0_25_36 Node0_25_36 GND 3.609375e-06
I_0_25_37 GND Node0_25_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_37_1 Node0_25_37 Node0_25_38 77.0
R_0_25_37_2 Node0_25_37 Node0_26_37 77.0
R_0_25_37_3 Node0_25_37 Node1_25_37 12.320000000000002
C_0_25_37 Node0_25_37 GND 3.609375e-06
I_0_25_38 GND Node0_25_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_38_1 Node0_25_38 Node0_25_39 77.0
R_0_25_38_2 Node0_25_38 Node0_26_38 77.0
R_0_25_38_3 Node0_25_38 Node1_25_38 12.320000000000002
C_0_25_38 Node0_25_38 GND 3.609375e-06
I_0_25_39 GND Node0_25_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_25_39_2 Node0_25_39 Node0_26_39 77.0
R_0_25_39_3 Node0_25_39 Node1_25_39 12.320000000000002
C_0_25_39 Node0_25_39 GND 3.609375e-06
I_0_26_0 GND Node0_26_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_0_1 Node0_26_0 Node0_26_1 77.0
R_0_26_0_2 Node0_26_0 Node0_27_0 77.0
R_0_26_0_3 Node0_26_0 Node1_26_0 12.320000000000002
C_0_26_0 Node0_26_0 GND 3.609375e-06
I_0_26_1 GND Node0_26_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_1_1 Node0_26_1 Node0_26_2 77.0
R_0_26_1_2 Node0_26_1 Node0_27_1 77.0
R_0_26_1_3 Node0_26_1 Node1_26_1 12.320000000000002
C_0_26_1 Node0_26_1 GND 3.609375e-06
I_0_26_2 GND Node0_26_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_2_1 Node0_26_2 Node0_26_3 77.0
R_0_26_2_2 Node0_26_2 Node0_27_2 77.0
R_0_26_2_3 Node0_26_2 Node1_26_2 12.320000000000002
C_0_26_2 Node0_26_2 GND 3.609375e-06
I_0_26_3 GND Node0_26_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_3_1 Node0_26_3 Node0_26_4 77.0
R_0_26_3_2 Node0_26_3 Node0_27_3 77.0
R_0_26_3_3 Node0_26_3 Node1_26_3 12.320000000000002
C_0_26_3 Node0_26_3 GND 3.609375e-06
I_0_26_4 GND Node0_26_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_4_1 Node0_26_4 Node0_26_5 77.0
R_0_26_4_2 Node0_26_4 Node0_27_4 77.0
R_0_26_4_3 Node0_26_4 Node1_26_4 12.320000000000002
C_0_26_4 Node0_26_4 GND 3.609375e-06
I_0_26_5 GND Node0_26_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_5_1 Node0_26_5 Node0_26_6 77.0
R_0_26_5_2 Node0_26_5 Node0_27_5 77.0
R_0_26_5_3 Node0_26_5 Node1_26_5 12.320000000000002
C_0_26_5 Node0_26_5 GND 3.609375e-06
I_0_26_6 GND Node0_26_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_6_1 Node0_26_6 Node0_26_7 77.0
R_0_26_6_2 Node0_26_6 Node0_27_6 77.0
R_0_26_6_3 Node0_26_6 Node1_26_6 12.320000000000002
C_0_26_6 Node0_26_6 GND 3.609375e-06
I_0_26_7 GND Node0_26_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_7_1 Node0_26_7 Node0_26_8 77.0
R_0_26_7_2 Node0_26_7 Node0_27_7 77.0
R_0_26_7_3 Node0_26_7 Node1_26_7 12.320000000000002
C_0_26_7 Node0_26_7 GND 3.609375e-06
I_0_26_8 GND Node0_26_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_8_1 Node0_26_8 Node0_26_9 77.0
R_0_26_8_2 Node0_26_8 Node0_27_8 77.0
R_0_26_8_3 Node0_26_8 Node1_26_8 12.320000000000002
C_0_26_8 Node0_26_8 GND 3.609375e-06
I_0_26_9 GND Node0_26_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_9_1 Node0_26_9 Node0_26_10 77.0
R_0_26_9_2 Node0_26_9 Node0_27_9 77.0
R_0_26_9_3 Node0_26_9 Node1_26_9 12.320000000000002
C_0_26_9 Node0_26_9 GND 3.609375e-06
I_0_26_10 GND Node0_26_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_10_1 Node0_26_10 Node0_26_11 77.0
R_0_26_10_2 Node0_26_10 Node0_27_10 77.0
R_0_26_10_3 Node0_26_10 Node1_26_10 12.320000000000002
C_0_26_10 Node0_26_10 GND 3.609375e-06
I_0_26_11 GND Node0_26_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_11_1 Node0_26_11 Node0_26_12 77.0
R_0_26_11_2 Node0_26_11 Node0_27_11 77.0
R_0_26_11_3 Node0_26_11 Node1_26_11 12.320000000000002
C_0_26_11 Node0_26_11 GND 3.609375e-06
I_0_26_12 GND Node0_26_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_12_1 Node0_26_12 Node0_26_13 77.0
R_0_26_12_2 Node0_26_12 Node0_27_12 77.0
R_0_26_12_3 Node0_26_12 Node1_26_12 12.320000000000002
C_0_26_12 Node0_26_12 GND 3.609375e-06
I_0_26_13 GND Node0_26_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_13_1 Node0_26_13 Node0_26_14 77.0
R_0_26_13_2 Node0_26_13 Node0_27_13 77.0
R_0_26_13_3 Node0_26_13 Node1_26_13 12.320000000000002
C_0_26_13 Node0_26_13 GND 3.609375e-06
I_0_26_14 GND Node0_26_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_14_1 Node0_26_14 Node0_26_15 77.0
R_0_26_14_2 Node0_26_14 Node0_27_14 77.0
R_0_26_14_3 Node0_26_14 Node1_26_14 12.320000000000002
C_0_26_14 Node0_26_14 GND 3.609375e-06
I_0_26_15 GND Node0_26_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_15_1 Node0_26_15 Node0_26_16 77.0
R_0_26_15_2 Node0_26_15 Node0_27_15 77.0
R_0_26_15_3 Node0_26_15 Node1_26_15 12.320000000000002
C_0_26_15 Node0_26_15 GND 3.609375e-06
I_0_26_16 GND Node0_26_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_16_1 Node0_26_16 Node0_26_17 77.0
R_0_26_16_2 Node0_26_16 Node0_27_16 77.0
R_0_26_16_3 Node0_26_16 Node1_26_16 12.320000000000002
C_0_26_16 Node0_26_16 GND 3.609375e-06
I_0_26_17 GND Node0_26_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_17_1 Node0_26_17 Node0_26_18 77.0
R_0_26_17_2 Node0_26_17 Node0_27_17 77.0
R_0_26_17_3 Node0_26_17 Node1_26_17 12.320000000000002
C_0_26_17 Node0_26_17 GND 3.609375e-06
I_0_26_18 GND Node0_26_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_18_1 Node0_26_18 Node0_26_19 77.0
R_0_26_18_2 Node0_26_18 Node0_27_18 77.0
R_0_26_18_3 Node0_26_18 Node1_26_18 12.320000000000002
C_0_26_18 Node0_26_18 GND 3.609375e-06
I_0_26_19 GND Node0_26_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_19_1 Node0_26_19 Node0_26_20 77.0
R_0_26_19_2 Node0_26_19 Node0_27_19 77.0
R_0_26_19_3 Node0_26_19 Node1_26_19 12.320000000000002
C_0_26_19 Node0_26_19 GND 3.609375e-06
I_0_26_20 GND Node0_26_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_20_1 Node0_26_20 Node0_26_21 77.0
R_0_26_20_2 Node0_26_20 Node0_27_20 77.0
R_0_26_20_3 Node0_26_20 Node1_26_20 12.320000000000002
C_0_26_20 Node0_26_20 GND 3.609375e-06
I_0_26_21 GND Node0_26_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_21_1 Node0_26_21 Node0_26_22 77.0
R_0_26_21_2 Node0_26_21 Node0_27_21 77.0
R_0_26_21_3 Node0_26_21 Node1_26_21 12.320000000000002
C_0_26_21 Node0_26_21 GND 3.609375e-06
I_0_26_22 GND Node0_26_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_22_1 Node0_26_22 Node0_26_23 77.0
R_0_26_22_2 Node0_26_22 Node0_27_22 77.0
R_0_26_22_3 Node0_26_22 Node1_26_22 12.320000000000002
C_0_26_22 Node0_26_22 GND 3.609375e-06
I_0_26_23 GND Node0_26_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_23_1 Node0_26_23 Node0_26_24 77.0
R_0_26_23_2 Node0_26_23 Node0_27_23 77.0
R_0_26_23_3 Node0_26_23 Node1_26_23 12.320000000000002
C_0_26_23 Node0_26_23 GND 3.609375e-06
I_0_26_24 GND Node0_26_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_24_1 Node0_26_24 Node0_26_25 77.0
R_0_26_24_2 Node0_26_24 Node0_27_24 77.0
R_0_26_24_3 Node0_26_24 Node1_26_24 12.320000000000002
C_0_26_24 Node0_26_24 GND 3.609375e-06
I_0_26_25 GND Node0_26_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_25_1 Node0_26_25 Node0_26_26 77.0
R_0_26_25_2 Node0_26_25 Node0_27_25 77.0
R_0_26_25_3 Node0_26_25 Node1_26_25 12.320000000000002
C_0_26_25 Node0_26_25 GND 3.609375e-06
I_0_26_26 GND Node0_26_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_26_1 Node0_26_26 Node0_26_27 77.0
R_0_26_26_2 Node0_26_26 Node0_27_26 77.0
R_0_26_26_3 Node0_26_26 Node1_26_26 12.320000000000002
C_0_26_26 Node0_26_26 GND 3.609375e-06
I_0_26_27 GND Node0_26_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_27_1 Node0_26_27 Node0_26_28 77.0
R_0_26_27_2 Node0_26_27 Node0_27_27 77.0
R_0_26_27_3 Node0_26_27 Node1_26_27 12.320000000000002
C_0_26_27 Node0_26_27 GND 3.609375e-06
I_0_26_28 GND Node0_26_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_28_1 Node0_26_28 Node0_26_29 77.0
R_0_26_28_2 Node0_26_28 Node0_27_28 77.0
R_0_26_28_3 Node0_26_28 Node1_26_28 12.320000000000002
C_0_26_28 Node0_26_28 GND 3.609375e-06
I_0_26_29 GND Node0_26_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_29_1 Node0_26_29 Node0_26_30 77.0
R_0_26_29_2 Node0_26_29 Node0_27_29 77.0
R_0_26_29_3 Node0_26_29 Node1_26_29 12.320000000000002
C_0_26_29 Node0_26_29 GND 3.609375e-06
I_0_26_30 GND Node0_26_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_30_1 Node0_26_30 Node0_26_31 77.0
R_0_26_30_2 Node0_26_30 Node0_27_30 77.0
R_0_26_30_3 Node0_26_30 Node1_26_30 12.320000000000002
C_0_26_30 Node0_26_30 GND 3.609375e-06
I_0_26_31 GND Node0_26_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_31_1 Node0_26_31 Node0_26_32 77.0
R_0_26_31_2 Node0_26_31 Node0_27_31 77.0
R_0_26_31_3 Node0_26_31 Node1_26_31 12.320000000000002
C_0_26_31 Node0_26_31 GND 3.609375e-06
I_0_26_32 GND Node0_26_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_32_1 Node0_26_32 Node0_26_33 77.0
R_0_26_32_2 Node0_26_32 Node0_27_32 77.0
R_0_26_32_3 Node0_26_32 Node1_26_32 12.320000000000002
C_0_26_32 Node0_26_32 GND 3.609375e-06
I_0_26_33 GND Node0_26_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_33_1 Node0_26_33 Node0_26_34 77.0
R_0_26_33_2 Node0_26_33 Node0_27_33 77.0
R_0_26_33_3 Node0_26_33 Node1_26_33 12.320000000000002
C_0_26_33 Node0_26_33 GND 3.609375e-06
I_0_26_34 GND Node0_26_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_34_1 Node0_26_34 Node0_26_35 77.0
R_0_26_34_2 Node0_26_34 Node0_27_34 77.0
R_0_26_34_3 Node0_26_34 Node1_26_34 12.320000000000002
C_0_26_34 Node0_26_34 GND 3.609375e-06
I_0_26_35 GND Node0_26_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_35_1 Node0_26_35 Node0_26_36 77.0
R_0_26_35_2 Node0_26_35 Node0_27_35 77.0
R_0_26_35_3 Node0_26_35 Node1_26_35 12.320000000000002
C_0_26_35 Node0_26_35 GND 3.609375e-06
I_0_26_36 GND Node0_26_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_36_1 Node0_26_36 Node0_26_37 77.0
R_0_26_36_2 Node0_26_36 Node0_27_36 77.0
R_0_26_36_3 Node0_26_36 Node1_26_36 12.320000000000002
C_0_26_36 Node0_26_36 GND 3.609375e-06
I_0_26_37 GND Node0_26_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_37_1 Node0_26_37 Node0_26_38 77.0
R_0_26_37_2 Node0_26_37 Node0_27_37 77.0
R_0_26_37_3 Node0_26_37 Node1_26_37 12.320000000000002
C_0_26_37 Node0_26_37 GND 3.609375e-06
I_0_26_38 GND Node0_26_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_38_1 Node0_26_38 Node0_26_39 77.0
R_0_26_38_2 Node0_26_38 Node0_27_38 77.0
R_0_26_38_3 Node0_26_38 Node1_26_38 12.320000000000002
C_0_26_38 Node0_26_38 GND 3.609375e-06
I_0_26_39 GND Node0_26_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_26_39_2 Node0_26_39 Node0_27_39 77.0
R_0_26_39_3 Node0_26_39 Node1_26_39 12.320000000000002
C_0_26_39 Node0_26_39 GND 3.609375e-06
I_0_27_0 GND Node0_27_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_0_1 Node0_27_0 Node0_27_1 77.0
R_0_27_0_2 Node0_27_0 Node0_28_0 77.0
R_0_27_0_3 Node0_27_0 Node1_27_0 12.320000000000002
C_0_27_0 Node0_27_0 GND 3.609375e-06
I_0_27_1 GND Node0_27_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_1_1 Node0_27_1 Node0_27_2 77.0
R_0_27_1_2 Node0_27_1 Node0_28_1 77.0
R_0_27_1_3 Node0_27_1 Node1_27_1 12.320000000000002
C_0_27_1 Node0_27_1 GND 3.609375e-06
I_0_27_2 GND Node0_27_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_2_1 Node0_27_2 Node0_27_3 77.0
R_0_27_2_2 Node0_27_2 Node0_28_2 77.0
R_0_27_2_3 Node0_27_2 Node1_27_2 12.320000000000002
C_0_27_2 Node0_27_2 GND 3.609375e-06
I_0_27_3 GND Node0_27_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_3_1 Node0_27_3 Node0_27_4 77.0
R_0_27_3_2 Node0_27_3 Node0_28_3 77.0
R_0_27_3_3 Node0_27_3 Node1_27_3 12.320000000000002
C_0_27_3 Node0_27_3 GND 3.609375e-06
I_0_27_4 GND Node0_27_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_4_1 Node0_27_4 Node0_27_5 77.0
R_0_27_4_2 Node0_27_4 Node0_28_4 77.0
R_0_27_4_3 Node0_27_4 Node1_27_4 12.320000000000002
C_0_27_4 Node0_27_4 GND 3.609375e-06
I_0_27_5 GND Node0_27_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_5_1 Node0_27_5 Node0_27_6 77.0
R_0_27_5_2 Node0_27_5 Node0_28_5 77.0
R_0_27_5_3 Node0_27_5 Node1_27_5 12.320000000000002
C_0_27_5 Node0_27_5 GND 3.609375e-06
I_0_27_6 GND Node0_27_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_6_1 Node0_27_6 Node0_27_7 77.0
R_0_27_6_2 Node0_27_6 Node0_28_6 77.0
R_0_27_6_3 Node0_27_6 Node1_27_6 12.320000000000002
C_0_27_6 Node0_27_6 GND 3.609375e-06
I_0_27_7 GND Node0_27_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_7_1 Node0_27_7 Node0_27_8 77.0
R_0_27_7_2 Node0_27_7 Node0_28_7 77.0
R_0_27_7_3 Node0_27_7 Node1_27_7 12.320000000000002
C_0_27_7 Node0_27_7 GND 3.609375e-06
I_0_27_8 GND Node0_27_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_8_1 Node0_27_8 Node0_27_9 77.0
R_0_27_8_2 Node0_27_8 Node0_28_8 77.0
R_0_27_8_3 Node0_27_8 Node1_27_8 12.320000000000002
C_0_27_8 Node0_27_8 GND 3.609375e-06
I_0_27_9 GND Node0_27_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_9_1 Node0_27_9 Node0_27_10 77.0
R_0_27_9_2 Node0_27_9 Node0_28_9 77.0
R_0_27_9_3 Node0_27_9 Node1_27_9 12.320000000000002
C_0_27_9 Node0_27_9 GND 3.609375e-06
I_0_27_10 GND Node0_27_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_10_1 Node0_27_10 Node0_27_11 77.0
R_0_27_10_2 Node0_27_10 Node0_28_10 77.0
R_0_27_10_3 Node0_27_10 Node1_27_10 12.320000000000002
C_0_27_10 Node0_27_10 GND 3.609375e-06
I_0_27_11 GND Node0_27_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_11_1 Node0_27_11 Node0_27_12 77.0
R_0_27_11_2 Node0_27_11 Node0_28_11 77.0
R_0_27_11_3 Node0_27_11 Node1_27_11 12.320000000000002
C_0_27_11 Node0_27_11 GND 3.609375e-06
I_0_27_12 GND Node0_27_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_12_1 Node0_27_12 Node0_27_13 77.0
R_0_27_12_2 Node0_27_12 Node0_28_12 77.0
R_0_27_12_3 Node0_27_12 Node1_27_12 12.320000000000002
C_0_27_12 Node0_27_12 GND 3.609375e-06
I_0_27_13 GND Node0_27_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_13_1 Node0_27_13 Node0_27_14 77.0
R_0_27_13_2 Node0_27_13 Node0_28_13 77.0
R_0_27_13_3 Node0_27_13 Node1_27_13 12.320000000000002
C_0_27_13 Node0_27_13 GND 3.609375e-06
I_0_27_14 GND Node0_27_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_14_1 Node0_27_14 Node0_27_15 77.0
R_0_27_14_2 Node0_27_14 Node0_28_14 77.0
R_0_27_14_3 Node0_27_14 Node1_27_14 12.320000000000002
C_0_27_14 Node0_27_14 GND 3.609375e-06
I_0_27_15 GND Node0_27_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_15_1 Node0_27_15 Node0_27_16 77.0
R_0_27_15_2 Node0_27_15 Node0_28_15 77.0
R_0_27_15_3 Node0_27_15 Node1_27_15 12.320000000000002
C_0_27_15 Node0_27_15 GND 3.609375e-06
I_0_27_16 GND Node0_27_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_16_1 Node0_27_16 Node0_27_17 77.0
R_0_27_16_2 Node0_27_16 Node0_28_16 77.0
R_0_27_16_3 Node0_27_16 Node1_27_16 12.320000000000002
C_0_27_16 Node0_27_16 GND 3.609375e-06
I_0_27_17 GND Node0_27_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_17_1 Node0_27_17 Node0_27_18 77.0
R_0_27_17_2 Node0_27_17 Node0_28_17 77.0
R_0_27_17_3 Node0_27_17 Node1_27_17 12.320000000000002
C_0_27_17 Node0_27_17 GND 3.609375e-06
I_0_27_18 GND Node0_27_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_18_1 Node0_27_18 Node0_27_19 77.0
R_0_27_18_2 Node0_27_18 Node0_28_18 77.0
R_0_27_18_3 Node0_27_18 Node1_27_18 12.320000000000002
C_0_27_18 Node0_27_18 GND 3.609375e-06
I_0_27_19 GND Node0_27_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_19_1 Node0_27_19 Node0_27_20 77.0
R_0_27_19_2 Node0_27_19 Node0_28_19 77.0
R_0_27_19_3 Node0_27_19 Node1_27_19 12.320000000000002
C_0_27_19 Node0_27_19 GND 3.609375e-06
I_0_27_20 GND Node0_27_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_20_1 Node0_27_20 Node0_27_21 77.0
R_0_27_20_2 Node0_27_20 Node0_28_20 77.0
R_0_27_20_3 Node0_27_20 Node1_27_20 12.320000000000002
C_0_27_20 Node0_27_20 GND 3.609375e-06
I_0_27_21 GND Node0_27_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_21_1 Node0_27_21 Node0_27_22 77.0
R_0_27_21_2 Node0_27_21 Node0_28_21 77.0
R_0_27_21_3 Node0_27_21 Node1_27_21 12.320000000000002
C_0_27_21 Node0_27_21 GND 3.609375e-06
I_0_27_22 GND Node0_27_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_22_1 Node0_27_22 Node0_27_23 77.0
R_0_27_22_2 Node0_27_22 Node0_28_22 77.0
R_0_27_22_3 Node0_27_22 Node1_27_22 12.320000000000002
C_0_27_22 Node0_27_22 GND 3.609375e-06
I_0_27_23 GND Node0_27_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_23_1 Node0_27_23 Node0_27_24 77.0
R_0_27_23_2 Node0_27_23 Node0_28_23 77.0
R_0_27_23_3 Node0_27_23 Node1_27_23 12.320000000000002
C_0_27_23 Node0_27_23 GND 3.609375e-06
I_0_27_24 GND Node0_27_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_24_1 Node0_27_24 Node0_27_25 77.0
R_0_27_24_2 Node0_27_24 Node0_28_24 77.0
R_0_27_24_3 Node0_27_24 Node1_27_24 12.320000000000002
C_0_27_24 Node0_27_24 GND 3.609375e-06
I_0_27_25 GND Node0_27_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_25_1 Node0_27_25 Node0_27_26 77.0
R_0_27_25_2 Node0_27_25 Node0_28_25 77.0
R_0_27_25_3 Node0_27_25 Node1_27_25 12.320000000000002
C_0_27_25 Node0_27_25 GND 3.609375e-06
I_0_27_26 GND Node0_27_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_26_1 Node0_27_26 Node0_27_27 77.0
R_0_27_26_2 Node0_27_26 Node0_28_26 77.0
R_0_27_26_3 Node0_27_26 Node1_27_26 12.320000000000002
C_0_27_26 Node0_27_26 GND 3.609375e-06
I_0_27_27 GND Node0_27_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_27_1 Node0_27_27 Node0_27_28 77.0
R_0_27_27_2 Node0_27_27 Node0_28_27 77.0
R_0_27_27_3 Node0_27_27 Node1_27_27 12.320000000000002
C_0_27_27 Node0_27_27 GND 3.609375e-06
I_0_27_28 GND Node0_27_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_28_1 Node0_27_28 Node0_27_29 77.0
R_0_27_28_2 Node0_27_28 Node0_28_28 77.0
R_0_27_28_3 Node0_27_28 Node1_27_28 12.320000000000002
C_0_27_28 Node0_27_28 GND 3.609375e-06
I_0_27_29 GND Node0_27_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_29_1 Node0_27_29 Node0_27_30 77.0
R_0_27_29_2 Node0_27_29 Node0_28_29 77.0
R_0_27_29_3 Node0_27_29 Node1_27_29 12.320000000000002
C_0_27_29 Node0_27_29 GND 3.609375e-06
I_0_27_30 GND Node0_27_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_30_1 Node0_27_30 Node0_27_31 77.0
R_0_27_30_2 Node0_27_30 Node0_28_30 77.0
R_0_27_30_3 Node0_27_30 Node1_27_30 12.320000000000002
C_0_27_30 Node0_27_30 GND 3.609375e-06
I_0_27_31 GND Node0_27_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_31_1 Node0_27_31 Node0_27_32 77.0
R_0_27_31_2 Node0_27_31 Node0_28_31 77.0
R_0_27_31_3 Node0_27_31 Node1_27_31 12.320000000000002
C_0_27_31 Node0_27_31 GND 3.609375e-06
I_0_27_32 GND Node0_27_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_32_1 Node0_27_32 Node0_27_33 77.0
R_0_27_32_2 Node0_27_32 Node0_28_32 77.0
R_0_27_32_3 Node0_27_32 Node1_27_32 12.320000000000002
C_0_27_32 Node0_27_32 GND 3.609375e-06
I_0_27_33 GND Node0_27_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_33_1 Node0_27_33 Node0_27_34 77.0
R_0_27_33_2 Node0_27_33 Node0_28_33 77.0
R_0_27_33_3 Node0_27_33 Node1_27_33 12.320000000000002
C_0_27_33 Node0_27_33 GND 3.609375e-06
I_0_27_34 GND Node0_27_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_34_1 Node0_27_34 Node0_27_35 77.0
R_0_27_34_2 Node0_27_34 Node0_28_34 77.0
R_0_27_34_3 Node0_27_34 Node1_27_34 12.320000000000002
C_0_27_34 Node0_27_34 GND 3.609375e-06
I_0_27_35 GND Node0_27_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_35_1 Node0_27_35 Node0_27_36 77.0
R_0_27_35_2 Node0_27_35 Node0_28_35 77.0
R_0_27_35_3 Node0_27_35 Node1_27_35 12.320000000000002
C_0_27_35 Node0_27_35 GND 3.609375e-06
I_0_27_36 GND Node0_27_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_36_1 Node0_27_36 Node0_27_37 77.0
R_0_27_36_2 Node0_27_36 Node0_28_36 77.0
R_0_27_36_3 Node0_27_36 Node1_27_36 12.320000000000002
C_0_27_36 Node0_27_36 GND 3.609375e-06
I_0_27_37 GND Node0_27_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_37_1 Node0_27_37 Node0_27_38 77.0
R_0_27_37_2 Node0_27_37 Node0_28_37 77.0
R_0_27_37_3 Node0_27_37 Node1_27_37 12.320000000000002
C_0_27_37 Node0_27_37 GND 3.609375e-06
I_0_27_38 GND Node0_27_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_38_1 Node0_27_38 Node0_27_39 77.0
R_0_27_38_2 Node0_27_38 Node0_28_38 77.0
R_0_27_38_3 Node0_27_38 Node1_27_38 12.320000000000002
C_0_27_38 Node0_27_38 GND 3.609375e-06
I_0_27_39 GND Node0_27_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_27_39_2 Node0_27_39 Node0_28_39 77.0
R_0_27_39_3 Node0_27_39 Node1_27_39 12.320000000000002
C_0_27_39 Node0_27_39 GND 3.609375e-06
I_0_28_0 GND Node0_28_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_0_1 Node0_28_0 Node0_28_1 77.0
R_0_28_0_2 Node0_28_0 Node0_29_0 77.0
R_0_28_0_3 Node0_28_0 Node1_28_0 12.320000000000002
C_0_28_0 Node0_28_0 GND 3.609375e-06
I_0_28_1 GND Node0_28_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_1_1 Node0_28_1 Node0_28_2 77.0
R_0_28_1_2 Node0_28_1 Node0_29_1 77.0
R_0_28_1_3 Node0_28_1 Node1_28_1 12.320000000000002
C_0_28_1 Node0_28_1 GND 3.609375e-06
I_0_28_2 GND Node0_28_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_2_1 Node0_28_2 Node0_28_3 77.0
R_0_28_2_2 Node0_28_2 Node0_29_2 77.0
R_0_28_2_3 Node0_28_2 Node1_28_2 12.320000000000002
C_0_28_2 Node0_28_2 GND 3.609375e-06
I_0_28_3 GND Node0_28_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_3_1 Node0_28_3 Node0_28_4 77.0
R_0_28_3_2 Node0_28_3 Node0_29_3 77.0
R_0_28_3_3 Node0_28_3 Node1_28_3 12.320000000000002
C_0_28_3 Node0_28_3 GND 3.609375e-06
I_0_28_4 GND Node0_28_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_4_1 Node0_28_4 Node0_28_5 77.0
R_0_28_4_2 Node0_28_4 Node0_29_4 77.0
R_0_28_4_3 Node0_28_4 Node1_28_4 12.320000000000002
C_0_28_4 Node0_28_4 GND 3.609375e-06
I_0_28_5 GND Node0_28_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_5_1 Node0_28_5 Node0_28_6 77.0
R_0_28_5_2 Node0_28_5 Node0_29_5 77.0
R_0_28_5_3 Node0_28_5 Node1_28_5 12.320000000000002
C_0_28_5 Node0_28_5 GND 3.609375e-06
I_0_28_6 GND Node0_28_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_6_1 Node0_28_6 Node0_28_7 77.0
R_0_28_6_2 Node0_28_6 Node0_29_6 77.0
R_0_28_6_3 Node0_28_6 Node1_28_6 12.320000000000002
C_0_28_6 Node0_28_6 GND 3.609375e-06
I_0_28_7 GND Node0_28_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_7_1 Node0_28_7 Node0_28_8 77.0
R_0_28_7_2 Node0_28_7 Node0_29_7 77.0
R_0_28_7_3 Node0_28_7 Node1_28_7 12.320000000000002
C_0_28_7 Node0_28_7 GND 3.609375e-06
I_0_28_8 GND Node0_28_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_8_1 Node0_28_8 Node0_28_9 77.0
R_0_28_8_2 Node0_28_8 Node0_29_8 77.0
R_0_28_8_3 Node0_28_8 Node1_28_8 12.320000000000002
C_0_28_8 Node0_28_8 GND 3.609375e-06
I_0_28_9 GND Node0_28_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_9_1 Node0_28_9 Node0_28_10 77.0
R_0_28_9_2 Node0_28_9 Node0_29_9 77.0
R_0_28_9_3 Node0_28_9 Node1_28_9 12.320000000000002
C_0_28_9 Node0_28_9 GND 3.609375e-06
I_0_28_10 GND Node0_28_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_10_1 Node0_28_10 Node0_28_11 77.0
R_0_28_10_2 Node0_28_10 Node0_29_10 77.0
R_0_28_10_3 Node0_28_10 Node1_28_10 12.320000000000002
C_0_28_10 Node0_28_10 GND 3.609375e-06
I_0_28_11 GND Node0_28_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_11_1 Node0_28_11 Node0_28_12 77.0
R_0_28_11_2 Node0_28_11 Node0_29_11 77.0
R_0_28_11_3 Node0_28_11 Node1_28_11 12.320000000000002
C_0_28_11 Node0_28_11 GND 3.609375e-06
I_0_28_12 GND Node0_28_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_12_1 Node0_28_12 Node0_28_13 77.0
R_0_28_12_2 Node0_28_12 Node0_29_12 77.0
R_0_28_12_3 Node0_28_12 Node1_28_12 12.320000000000002
C_0_28_12 Node0_28_12 GND 3.609375e-06
I_0_28_13 GND Node0_28_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_13_1 Node0_28_13 Node0_28_14 77.0
R_0_28_13_2 Node0_28_13 Node0_29_13 77.0
R_0_28_13_3 Node0_28_13 Node1_28_13 12.320000000000002
C_0_28_13 Node0_28_13 GND 3.609375e-06
I_0_28_14 GND Node0_28_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_14_1 Node0_28_14 Node0_28_15 77.0
R_0_28_14_2 Node0_28_14 Node0_29_14 77.0
R_0_28_14_3 Node0_28_14 Node1_28_14 12.320000000000002
C_0_28_14 Node0_28_14 GND 3.609375e-06
I_0_28_15 GND Node0_28_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_15_1 Node0_28_15 Node0_28_16 77.0
R_0_28_15_2 Node0_28_15 Node0_29_15 77.0
R_0_28_15_3 Node0_28_15 Node1_28_15 12.320000000000002
C_0_28_15 Node0_28_15 GND 3.609375e-06
I_0_28_16 GND Node0_28_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_16_1 Node0_28_16 Node0_28_17 77.0
R_0_28_16_2 Node0_28_16 Node0_29_16 77.0
R_0_28_16_3 Node0_28_16 Node1_28_16 12.320000000000002
C_0_28_16 Node0_28_16 GND 3.609375e-06
I_0_28_17 GND Node0_28_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_17_1 Node0_28_17 Node0_28_18 77.0
R_0_28_17_2 Node0_28_17 Node0_29_17 77.0
R_0_28_17_3 Node0_28_17 Node1_28_17 12.320000000000002
C_0_28_17 Node0_28_17 GND 3.609375e-06
I_0_28_18 GND Node0_28_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_18_1 Node0_28_18 Node0_28_19 77.0
R_0_28_18_2 Node0_28_18 Node0_29_18 77.0
R_0_28_18_3 Node0_28_18 Node1_28_18 12.320000000000002
C_0_28_18 Node0_28_18 GND 3.609375e-06
I_0_28_19 GND Node0_28_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_19_1 Node0_28_19 Node0_28_20 77.0
R_0_28_19_2 Node0_28_19 Node0_29_19 77.0
R_0_28_19_3 Node0_28_19 Node1_28_19 12.320000000000002
C_0_28_19 Node0_28_19 GND 3.609375e-06
I_0_28_20 GND Node0_28_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_20_1 Node0_28_20 Node0_28_21 77.0
R_0_28_20_2 Node0_28_20 Node0_29_20 77.0
R_0_28_20_3 Node0_28_20 Node1_28_20 12.320000000000002
C_0_28_20 Node0_28_20 GND 3.609375e-06
I_0_28_21 GND Node0_28_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_21_1 Node0_28_21 Node0_28_22 77.0
R_0_28_21_2 Node0_28_21 Node0_29_21 77.0
R_0_28_21_3 Node0_28_21 Node1_28_21 12.320000000000002
C_0_28_21 Node0_28_21 GND 3.609375e-06
I_0_28_22 GND Node0_28_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_22_1 Node0_28_22 Node0_28_23 77.0
R_0_28_22_2 Node0_28_22 Node0_29_22 77.0
R_0_28_22_3 Node0_28_22 Node1_28_22 12.320000000000002
C_0_28_22 Node0_28_22 GND 3.609375e-06
I_0_28_23 GND Node0_28_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_23_1 Node0_28_23 Node0_28_24 77.0
R_0_28_23_2 Node0_28_23 Node0_29_23 77.0
R_0_28_23_3 Node0_28_23 Node1_28_23 12.320000000000002
C_0_28_23 Node0_28_23 GND 3.609375e-06
I_0_28_24 GND Node0_28_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_24_1 Node0_28_24 Node0_28_25 77.0
R_0_28_24_2 Node0_28_24 Node0_29_24 77.0
R_0_28_24_3 Node0_28_24 Node1_28_24 12.320000000000002
C_0_28_24 Node0_28_24 GND 3.609375e-06
I_0_28_25 GND Node0_28_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_25_1 Node0_28_25 Node0_28_26 77.0
R_0_28_25_2 Node0_28_25 Node0_29_25 77.0
R_0_28_25_3 Node0_28_25 Node1_28_25 12.320000000000002
C_0_28_25 Node0_28_25 GND 3.609375e-06
I_0_28_26 GND Node0_28_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_26_1 Node0_28_26 Node0_28_27 77.0
R_0_28_26_2 Node0_28_26 Node0_29_26 77.0
R_0_28_26_3 Node0_28_26 Node1_28_26 12.320000000000002
C_0_28_26 Node0_28_26 GND 3.609375e-06
I_0_28_27 GND Node0_28_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_27_1 Node0_28_27 Node0_28_28 77.0
R_0_28_27_2 Node0_28_27 Node0_29_27 77.0
R_0_28_27_3 Node0_28_27 Node1_28_27 12.320000000000002
C_0_28_27 Node0_28_27 GND 3.609375e-06
I_0_28_28 GND Node0_28_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_28_1 Node0_28_28 Node0_28_29 77.0
R_0_28_28_2 Node0_28_28 Node0_29_28 77.0
R_0_28_28_3 Node0_28_28 Node1_28_28 12.320000000000002
C_0_28_28 Node0_28_28 GND 3.609375e-06
I_0_28_29 GND Node0_28_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_29_1 Node0_28_29 Node0_28_30 77.0
R_0_28_29_2 Node0_28_29 Node0_29_29 77.0
R_0_28_29_3 Node0_28_29 Node1_28_29 12.320000000000002
C_0_28_29 Node0_28_29 GND 3.609375e-06
I_0_28_30 GND Node0_28_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_30_1 Node0_28_30 Node0_28_31 77.0
R_0_28_30_2 Node0_28_30 Node0_29_30 77.0
R_0_28_30_3 Node0_28_30 Node1_28_30 12.320000000000002
C_0_28_30 Node0_28_30 GND 3.609375e-06
I_0_28_31 GND Node0_28_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_31_1 Node0_28_31 Node0_28_32 77.0
R_0_28_31_2 Node0_28_31 Node0_29_31 77.0
R_0_28_31_3 Node0_28_31 Node1_28_31 12.320000000000002
C_0_28_31 Node0_28_31 GND 3.609375e-06
I_0_28_32 GND Node0_28_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_32_1 Node0_28_32 Node0_28_33 77.0
R_0_28_32_2 Node0_28_32 Node0_29_32 77.0
R_0_28_32_3 Node0_28_32 Node1_28_32 12.320000000000002
C_0_28_32 Node0_28_32 GND 3.609375e-06
I_0_28_33 GND Node0_28_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_33_1 Node0_28_33 Node0_28_34 77.0
R_0_28_33_2 Node0_28_33 Node0_29_33 77.0
R_0_28_33_3 Node0_28_33 Node1_28_33 12.320000000000002
C_0_28_33 Node0_28_33 GND 3.609375e-06
I_0_28_34 GND Node0_28_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_34_1 Node0_28_34 Node0_28_35 77.0
R_0_28_34_2 Node0_28_34 Node0_29_34 77.0
R_0_28_34_3 Node0_28_34 Node1_28_34 12.320000000000002
C_0_28_34 Node0_28_34 GND 3.609375e-06
I_0_28_35 GND Node0_28_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_35_1 Node0_28_35 Node0_28_36 77.0
R_0_28_35_2 Node0_28_35 Node0_29_35 77.0
R_0_28_35_3 Node0_28_35 Node1_28_35 12.320000000000002
C_0_28_35 Node0_28_35 GND 3.609375e-06
I_0_28_36 GND Node0_28_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_36_1 Node0_28_36 Node0_28_37 77.0
R_0_28_36_2 Node0_28_36 Node0_29_36 77.0
R_0_28_36_3 Node0_28_36 Node1_28_36 12.320000000000002
C_0_28_36 Node0_28_36 GND 3.609375e-06
I_0_28_37 GND Node0_28_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_37_1 Node0_28_37 Node0_28_38 77.0
R_0_28_37_2 Node0_28_37 Node0_29_37 77.0
R_0_28_37_3 Node0_28_37 Node1_28_37 12.320000000000002
C_0_28_37 Node0_28_37 GND 3.609375e-06
I_0_28_38 GND Node0_28_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_38_1 Node0_28_38 Node0_28_39 77.0
R_0_28_38_2 Node0_28_38 Node0_29_38 77.0
R_0_28_38_3 Node0_28_38 Node1_28_38 12.320000000000002
C_0_28_38 Node0_28_38 GND 3.609375e-06
I_0_28_39 GND Node0_28_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_28_39_2 Node0_28_39 Node0_29_39 77.0
R_0_28_39_3 Node0_28_39 Node1_28_39 12.320000000000002
C_0_28_39 Node0_28_39 GND 3.609375e-06
I_0_29_0 GND Node0_29_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_0_1 Node0_29_0 Node0_29_1 77.0
R_0_29_0_2 Node0_29_0 Node0_30_0 77.0
R_0_29_0_3 Node0_29_0 Node1_29_0 12.320000000000002
C_0_29_0 Node0_29_0 GND 3.609375e-06
I_0_29_1 GND Node0_29_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_1_1 Node0_29_1 Node0_29_2 77.0
R_0_29_1_2 Node0_29_1 Node0_30_1 77.0
R_0_29_1_3 Node0_29_1 Node1_29_1 12.320000000000002
C_0_29_1 Node0_29_1 GND 3.609375e-06
I_0_29_2 GND Node0_29_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_2_1 Node0_29_2 Node0_29_3 77.0
R_0_29_2_2 Node0_29_2 Node0_30_2 77.0
R_0_29_2_3 Node0_29_2 Node1_29_2 12.320000000000002
C_0_29_2 Node0_29_2 GND 3.609375e-06
I_0_29_3 GND Node0_29_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_3_1 Node0_29_3 Node0_29_4 77.0
R_0_29_3_2 Node0_29_3 Node0_30_3 77.0
R_0_29_3_3 Node0_29_3 Node1_29_3 12.320000000000002
C_0_29_3 Node0_29_3 GND 3.609375e-06
I_0_29_4 GND Node0_29_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_4_1 Node0_29_4 Node0_29_5 77.0
R_0_29_4_2 Node0_29_4 Node0_30_4 77.0
R_0_29_4_3 Node0_29_4 Node1_29_4 12.320000000000002
C_0_29_4 Node0_29_4 GND 3.609375e-06
I_0_29_5 GND Node0_29_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_5_1 Node0_29_5 Node0_29_6 77.0
R_0_29_5_2 Node0_29_5 Node0_30_5 77.0
R_0_29_5_3 Node0_29_5 Node1_29_5 12.320000000000002
C_0_29_5 Node0_29_5 GND 3.609375e-06
I_0_29_6 GND Node0_29_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_6_1 Node0_29_6 Node0_29_7 77.0
R_0_29_6_2 Node0_29_6 Node0_30_6 77.0
R_0_29_6_3 Node0_29_6 Node1_29_6 12.320000000000002
C_0_29_6 Node0_29_6 GND 3.609375e-06
I_0_29_7 GND Node0_29_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_7_1 Node0_29_7 Node0_29_8 77.0
R_0_29_7_2 Node0_29_7 Node0_30_7 77.0
R_0_29_7_3 Node0_29_7 Node1_29_7 12.320000000000002
C_0_29_7 Node0_29_7 GND 3.609375e-06
I_0_29_8 GND Node0_29_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_8_1 Node0_29_8 Node0_29_9 77.0
R_0_29_8_2 Node0_29_8 Node0_30_8 77.0
R_0_29_8_3 Node0_29_8 Node1_29_8 12.320000000000002
C_0_29_8 Node0_29_8 GND 3.609375e-06
I_0_29_9 GND Node0_29_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_9_1 Node0_29_9 Node0_29_10 77.0
R_0_29_9_2 Node0_29_9 Node0_30_9 77.0
R_0_29_9_3 Node0_29_9 Node1_29_9 12.320000000000002
C_0_29_9 Node0_29_9 GND 3.609375e-06
I_0_29_10 GND Node0_29_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_10_1 Node0_29_10 Node0_29_11 77.0
R_0_29_10_2 Node0_29_10 Node0_30_10 77.0
R_0_29_10_3 Node0_29_10 Node1_29_10 12.320000000000002
C_0_29_10 Node0_29_10 GND 3.609375e-06
I_0_29_11 GND Node0_29_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_11_1 Node0_29_11 Node0_29_12 77.0
R_0_29_11_2 Node0_29_11 Node0_30_11 77.0
R_0_29_11_3 Node0_29_11 Node1_29_11 12.320000000000002
C_0_29_11 Node0_29_11 GND 3.609375e-06
I_0_29_12 GND Node0_29_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_12_1 Node0_29_12 Node0_29_13 77.0
R_0_29_12_2 Node0_29_12 Node0_30_12 77.0
R_0_29_12_3 Node0_29_12 Node1_29_12 12.320000000000002
C_0_29_12 Node0_29_12 GND 3.609375e-06
I_0_29_13 GND Node0_29_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_13_1 Node0_29_13 Node0_29_14 77.0
R_0_29_13_2 Node0_29_13 Node0_30_13 77.0
R_0_29_13_3 Node0_29_13 Node1_29_13 12.320000000000002
C_0_29_13 Node0_29_13 GND 3.609375e-06
I_0_29_14 GND Node0_29_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_14_1 Node0_29_14 Node0_29_15 77.0
R_0_29_14_2 Node0_29_14 Node0_30_14 77.0
R_0_29_14_3 Node0_29_14 Node1_29_14 12.320000000000002
C_0_29_14 Node0_29_14 GND 3.609375e-06
I_0_29_15 GND Node0_29_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_15_1 Node0_29_15 Node0_29_16 77.0
R_0_29_15_2 Node0_29_15 Node0_30_15 77.0
R_0_29_15_3 Node0_29_15 Node1_29_15 12.320000000000002
C_0_29_15 Node0_29_15 GND 3.609375e-06
I_0_29_16 GND Node0_29_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_16_1 Node0_29_16 Node0_29_17 77.0
R_0_29_16_2 Node0_29_16 Node0_30_16 77.0
R_0_29_16_3 Node0_29_16 Node1_29_16 12.320000000000002
C_0_29_16 Node0_29_16 GND 3.609375e-06
I_0_29_17 GND Node0_29_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_17_1 Node0_29_17 Node0_29_18 77.0
R_0_29_17_2 Node0_29_17 Node0_30_17 77.0
R_0_29_17_3 Node0_29_17 Node1_29_17 12.320000000000002
C_0_29_17 Node0_29_17 GND 3.609375e-06
I_0_29_18 GND Node0_29_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_18_1 Node0_29_18 Node0_29_19 77.0
R_0_29_18_2 Node0_29_18 Node0_30_18 77.0
R_0_29_18_3 Node0_29_18 Node1_29_18 12.320000000000002
C_0_29_18 Node0_29_18 GND 3.609375e-06
I_0_29_19 GND Node0_29_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_19_1 Node0_29_19 Node0_29_20 77.0
R_0_29_19_2 Node0_29_19 Node0_30_19 77.0
R_0_29_19_3 Node0_29_19 Node1_29_19 12.320000000000002
C_0_29_19 Node0_29_19 GND 3.609375e-06
I_0_29_20 GND Node0_29_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_20_1 Node0_29_20 Node0_29_21 77.0
R_0_29_20_2 Node0_29_20 Node0_30_20 77.0
R_0_29_20_3 Node0_29_20 Node1_29_20 12.320000000000002
C_0_29_20 Node0_29_20 GND 3.609375e-06
I_0_29_21 GND Node0_29_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_21_1 Node0_29_21 Node0_29_22 77.0
R_0_29_21_2 Node0_29_21 Node0_30_21 77.0
R_0_29_21_3 Node0_29_21 Node1_29_21 12.320000000000002
C_0_29_21 Node0_29_21 GND 3.609375e-06
I_0_29_22 GND Node0_29_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_22_1 Node0_29_22 Node0_29_23 77.0
R_0_29_22_2 Node0_29_22 Node0_30_22 77.0
R_0_29_22_3 Node0_29_22 Node1_29_22 12.320000000000002
C_0_29_22 Node0_29_22 GND 3.609375e-06
I_0_29_23 GND Node0_29_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_23_1 Node0_29_23 Node0_29_24 77.0
R_0_29_23_2 Node0_29_23 Node0_30_23 77.0
R_0_29_23_3 Node0_29_23 Node1_29_23 12.320000000000002
C_0_29_23 Node0_29_23 GND 3.609375e-06
I_0_29_24 GND Node0_29_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_24_1 Node0_29_24 Node0_29_25 77.0
R_0_29_24_2 Node0_29_24 Node0_30_24 77.0
R_0_29_24_3 Node0_29_24 Node1_29_24 12.320000000000002
C_0_29_24 Node0_29_24 GND 3.609375e-06
I_0_29_25 GND Node0_29_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_25_1 Node0_29_25 Node0_29_26 77.0
R_0_29_25_2 Node0_29_25 Node0_30_25 77.0
R_0_29_25_3 Node0_29_25 Node1_29_25 12.320000000000002
C_0_29_25 Node0_29_25 GND 3.609375e-06
I_0_29_26 GND Node0_29_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_26_1 Node0_29_26 Node0_29_27 77.0
R_0_29_26_2 Node0_29_26 Node0_30_26 77.0
R_0_29_26_3 Node0_29_26 Node1_29_26 12.320000000000002
C_0_29_26 Node0_29_26 GND 3.609375e-06
I_0_29_27 GND Node0_29_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_27_1 Node0_29_27 Node0_29_28 77.0
R_0_29_27_2 Node0_29_27 Node0_30_27 77.0
R_0_29_27_3 Node0_29_27 Node1_29_27 12.320000000000002
C_0_29_27 Node0_29_27 GND 3.609375e-06
I_0_29_28 GND Node0_29_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_28_1 Node0_29_28 Node0_29_29 77.0
R_0_29_28_2 Node0_29_28 Node0_30_28 77.0
R_0_29_28_3 Node0_29_28 Node1_29_28 12.320000000000002
C_0_29_28 Node0_29_28 GND 3.609375e-06
I_0_29_29 GND Node0_29_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_29_1 Node0_29_29 Node0_29_30 77.0
R_0_29_29_2 Node0_29_29 Node0_30_29 77.0
R_0_29_29_3 Node0_29_29 Node1_29_29 12.320000000000002
C_0_29_29 Node0_29_29 GND 3.609375e-06
I_0_29_30 GND Node0_29_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_30_1 Node0_29_30 Node0_29_31 77.0
R_0_29_30_2 Node0_29_30 Node0_30_30 77.0
R_0_29_30_3 Node0_29_30 Node1_29_30 12.320000000000002
C_0_29_30 Node0_29_30 GND 3.609375e-06
I_0_29_31 GND Node0_29_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_31_1 Node0_29_31 Node0_29_32 77.0
R_0_29_31_2 Node0_29_31 Node0_30_31 77.0
R_0_29_31_3 Node0_29_31 Node1_29_31 12.320000000000002
C_0_29_31 Node0_29_31 GND 3.609375e-06
I_0_29_32 GND Node0_29_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_32_1 Node0_29_32 Node0_29_33 77.0
R_0_29_32_2 Node0_29_32 Node0_30_32 77.0
R_0_29_32_3 Node0_29_32 Node1_29_32 12.320000000000002
C_0_29_32 Node0_29_32 GND 3.609375e-06
I_0_29_33 GND Node0_29_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_33_1 Node0_29_33 Node0_29_34 77.0
R_0_29_33_2 Node0_29_33 Node0_30_33 77.0
R_0_29_33_3 Node0_29_33 Node1_29_33 12.320000000000002
C_0_29_33 Node0_29_33 GND 3.609375e-06
I_0_29_34 GND Node0_29_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_34_1 Node0_29_34 Node0_29_35 77.0
R_0_29_34_2 Node0_29_34 Node0_30_34 77.0
R_0_29_34_3 Node0_29_34 Node1_29_34 12.320000000000002
C_0_29_34 Node0_29_34 GND 3.609375e-06
I_0_29_35 GND Node0_29_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_35_1 Node0_29_35 Node0_29_36 77.0
R_0_29_35_2 Node0_29_35 Node0_30_35 77.0
R_0_29_35_3 Node0_29_35 Node1_29_35 12.320000000000002
C_0_29_35 Node0_29_35 GND 3.609375e-06
I_0_29_36 GND Node0_29_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_36_1 Node0_29_36 Node0_29_37 77.0
R_0_29_36_2 Node0_29_36 Node0_30_36 77.0
R_0_29_36_3 Node0_29_36 Node1_29_36 12.320000000000002
C_0_29_36 Node0_29_36 GND 3.609375e-06
I_0_29_37 GND Node0_29_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_37_1 Node0_29_37 Node0_29_38 77.0
R_0_29_37_2 Node0_29_37 Node0_30_37 77.0
R_0_29_37_3 Node0_29_37 Node1_29_37 12.320000000000002
C_0_29_37 Node0_29_37 GND 3.609375e-06
I_0_29_38 GND Node0_29_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_38_1 Node0_29_38 Node0_29_39 77.0
R_0_29_38_2 Node0_29_38 Node0_30_38 77.0
R_0_29_38_3 Node0_29_38 Node1_29_38 12.320000000000002
C_0_29_38 Node0_29_38 GND 3.609375e-06
I_0_29_39 GND Node0_29_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_29_39_2 Node0_29_39 Node0_30_39 77.0
R_0_29_39_3 Node0_29_39 Node1_29_39 12.320000000000002
C_0_29_39 Node0_29_39 GND 3.609375e-06
I_0_30_0 GND Node0_30_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_0_1 Node0_30_0 Node0_30_1 77.0
R_0_30_0_2 Node0_30_0 Node0_31_0 77.0
R_0_30_0_3 Node0_30_0 Node1_30_0 12.320000000000002
C_0_30_0 Node0_30_0 GND 3.609375e-06
I_0_30_1 GND Node0_30_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_1_1 Node0_30_1 Node0_30_2 77.0
R_0_30_1_2 Node0_30_1 Node0_31_1 77.0
R_0_30_1_3 Node0_30_1 Node1_30_1 12.320000000000002
C_0_30_1 Node0_30_1 GND 3.609375e-06
I_0_30_2 GND Node0_30_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_2_1 Node0_30_2 Node0_30_3 77.0
R_0_30_2_2 Node0_30_2 Node0_31_2 77.0
R_0_30_2_3 Node0_30_2 Node1_30_2 12.320000000000002
C_0_30_2 Node0_30_2 GND 3.609375e-06
I_0_30_3 GND Node0_30_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_3_1 Node0_30_3 Node0_30_4 77.0
R_0_30_3_2 Node0_30_3 Node0_31_3 77.0
R_0_30_3_3 Node0_30_3 Node1_30_3 12.320000000000002
C_0_30_3 Node0_30_3 GND 3.609375e-06
I_0_30_4 GND Node0_30_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_4_1 Node0_30_4 Node0_30_5 77.0
R_0_30_4_2 Node0_30_4 Node0_31_4 77.0
R_0_30_4_3 Node0_30_4 Node1_30_4 12.320000000000002
C_0_30_4 Node0_30_4 GND 3.609375e-06
I_0_30_5 GND Node0_30_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_5_1 Node0_30_5 Node0_30_6 77.0
R_0_30_5_2 Node0_30_5 Node0_31_5 77.0
R_0_30_5_3 Node0_30_5 Node1_30_5 12.320000000000002
C_0_30_5 Node0_30_5 GND 3.609375e-06
I_0_30_6 GND Node0_30_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_6_1 Node0_30_6 Node0_30_7 77.0
R_0_30_6_2 Node0_30_6 Node0_31_6 77.0
R_0_30_6_3 Node0_30_6 Node1_30_6 12.320000000000002
C_0_30_6 Node0_30_6 GND 3.609375e-06
I_0_30_7 GND Node0_30_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_7_1 Node0_30_7 Node0_30_8 77.0
R_0_30_7_2 Node0_30_7 Node0_31_7 77.0
R_0_30_7_3 Node0_30_7 Node1_30_7 12.320000000000002
C_0_30_7 Node0_30_7 GND 3.609375e-06
I_0_30_8 GND Node0_30_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_8_1 Node0_30_8 Node0_30_9 77.0
R_0_30_8_2 Node0_30_8 Node0_31_8 77.0
R_0_30_8_3 Node0_30_8 Node1_30_8 12.320000000000002
C_0_30_8 Node0_30_8 GND 3.609375e-06
I_0_30_9 GND Node0_30_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_9_1 Node0_30_9 Node0_30_10 77.0
R_0_30_9_2 Node0_30_9 Node0_31_9 77.0
R_0_30_9_3 Node0_30_9 Node1_30_9 12.320000000000002
C_0_30_9 Node0_30_9 GND 3.609375e-06
I_0_30_10 GND Node0_30_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_10_1 Node0_30_10 Node0_30_11 77.0
R_0_30_10_2 Node0_30_10 Node0_31_10 77.0
R_0_30_10_3 Node0_30_10 Node1_30_10 12.320000000000002
C_0_30_10 Node0_30_10 GND 3.609375e-06
I_0_30_11 GND Node0_30_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_11_1 Node0_30_11 Node0_30_12 77.0
R_0_30_11_2 Node0_30_11 Node0_31_11 77.0
R_0_30_11_3 Node0_30_11 Node1_30_11 12.320000000000002
C_0_30_11 Node0_30_11 GND 3.609375e-06
I_0_30_12 GND Node0_30_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_12_1 Node0_30_12 Node0_30_13 77.0
R_0_30_12_2 Node0_30_12 Node0_31_12 77.0
R_0_30_12_3 Node0_30_12 Node1_30_12 12.320000000000002
C_0_30_12 Node0_30_12 GND 3.609375e-06
I_0_30_13 GND Node0_30_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_13_1 Node0_30_13 Node0_30_14 77.0
R_0_30_13_2 Node0_30_13 Node0_31_13 77.0
R_0_30_13_3 Node0_30_13 Node1_30_13 12.320000000000002
C_0_30_13 Node0_30_13 GND 3.609375e-06
I_0_30_14 GND Node0_30_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_14_1 Node0_30_14 Node0_30_15 77.0
R_0_30_14_2 Node0_30_14 Node0_31_14 77.0
R_0_30_14_3 Node0_30_14 Node1_30_14 12.320000000000002
C_0_30_14 Node0_30_14 GND 3.609375e-06
I_0_30_15 GND Node0_30_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_15_1 Node0_30_15 Node0_30_16 77.0
R_0_30_15_2 Node0_30_15 Node0_31_15 77.0
R_0_30_15_3 Node0_30_15 Node1_30_15 12.320000000000002
C_0_30_15 Node0_30_15 GND 3.609375e-06
I_0_30_16 GND Node0_30_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_16_1 Node0_30_16 Node0_30_17 77.0
R_0_30_16_2 Node0_30_16 Node0_31_16 77.0
R_0_30_16_3 Node0_30_16 Node1_30_16 12.320000000000002
C_0_30_16 Node0_30_16 GND 3.609375e-06
I_0_30_17 GND Node0_30_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_17_1 Node0_30_17 Node0_30_18 77.0
R_0_30_17_2 Node0_30_17 Node0_31_17 77.0
R_0_30_17_3 Node0_30_17 Node1_30_17 12.320000000000002
C_0_30_17 Node0_30_17 GND 3.609375e-06
I_0_30_18 GND Node0_30_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_18_1 Node0_30_18 Node0_30_19 77.0
R_0_30_18_2 Node0_30_18 Node0_31_18 77.0
R_0_30_18_3 Node0_30_18 Node1_30_18 12.320000000000002
C_0_30_18 Node0_30_18 GND 3.609375e-06
I_0_30_19 GND Node0_30_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_19_1 Node0_30_19 Node0_30_20 77.0
R_0_30_19_2 Node0_30_19 Node0_31_19 77.0
R_0_30_19_3 Node0_30_19 Node1_30_19 12.320000000000002
C_0_30_19 Node0_30_19 GND 3.609375e-06
I_0_30_20 GND Node0_30_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_20_1 Node0_30_20 Node0_30_21 77.0
R_0_30_20_2 Node0_30_20 Node0_31_20 77.0
R_0_30_20_3 Node0_30_20 Node1_30_20 12.320000000000002
C_0_30_20 Node0_30_20 GND 3.609375e-06
I_0_30_21 GND Node0_30_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_21_1 Node0_30_21 Node0_30_22 77.0
R_0_30_21_2 Node0_30_21 Node0_31_21 77.0
R_0_30_21_3 Node0_30_21 Node1_30_21 12.320000000000002
C_0_30_21 Node0_30_21 GND 3.609375e-06
I_0_30_22 GND Node0_30_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_22_1 Node0_30_22 Node0_30_23 77.0
R_0_30_22_2 Node0_30_22 Node0_31_22 77.0
R_0_30_22_3 Node0_30_22 Node1_30_22 12.320000000000002
C_0_30_22 Node0_30_22 GND 3.609375e-06
I_0_30_23 GND Node0_30_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_23_1 Node0_30_23 Node0_30_24 77.0
R_0_30_23_2 Node0_30_23 Node0_31_23 77.0
R_0_30_23_3 Node0_30_23 Node1_30_23 12.320000000000002
C_0_30_23 Node0_30_23 GND 3.609375e-06
I_0_30_24 GND Node0_30_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_24_1 Node0_30_24 Node0_30_25 77.0
R_0_30_24_2 Node0_30_24 Node0_31_24 77.0
R_0_30_24_3 Node0_30_24 Node1_30_24 12.320000000000002
C_0_30_24 Node0_30_24 GND 3.609375e-06
I_0_30_25 GND Node0_30_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_25_1 Node0_30_25 Node0_30_26 77.0
R_0_30_25_2 Node0_30_25 Node0_31_25 77.0
R_0_30_25_3 Node0_30_25 Node1_30_25 12.320000000000002
C_0_30_25 Node0_30_25 GND 3.609375e-06
I_0_30_26 GND Node0_30_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_26_1 Node0_30_26 Node0_30_27 77.0
R_0_30_26_2 Node0_30_26 Node0_31_26 77.0
R_0_30_26_3 Node0_30_26 Node1_30_26 12.320000000000002
C_0_30_26 Node0_30_26 GND 3.609375e-06
I_0_30_27 GND Node0_30_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_27_1 Node0_30_27 Node0_30_28 77.0
R_0_30_27_2 Node0_30_27 Node0_31_27 77.0
R_0_30_27_3 Node0_30_27 Node1_30_27 12.320000000000002
C_0_30_27 Node0_30_27 GND 3.609375e-06
I_0_30_28 GND Node0_30_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_28_1 Node0_30_28 Node0_30_29 77.0
R_0_30_28_2 Node0_30_28 Node0_31_28 77.0
R_0_30_28_3 Node0_30_28 Node1_30_28 12.320000000000002
C_0_30_28 Node0_30_28 GND 3.609375e-06
I_0_30_29 GND Node0_30_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_29_1 Node0_30_29 Node0_30_30 77.0
R_0_30_29_2 Node0_30_29 Node0_31_29 77.0
R_0_30_29_3 Node0_30_29 Node1_30_29 12.320000000000002
C_0_30_29 Node0_30_29 GND 3.609375e-06
I_0_30_30 GND Node0_30_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_30_1 Node0_30_30 Node0_30_31 77.0
R_0_30_30_2 Node0_30_30 Node0_31_30 77.0
R_0_30_30_3 Node0_30_30 Node1_30_30 12.320000000000002
C_0_30_30 Node0_30_30 GND 3.609375e-06
I_0_30_31 GND Node0_30_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_31_1 Node0_30_31 Node0_30_32 77.0
R_0_30_31_2 Node0_30_31 Node0_31_31 77.0
R_0_30_31_3 Node0_30_31 Node1_30_31 12.320000000000002
C_0_30_31 Node0_30_31 GND 3.609375e-06
I_0_30_32 GND Node0_30_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_32_1 Node0_30_32 Node0_30_33 77.0
R_0_30_32_2 Node0_30_32 Node0_31_32 77.0
R_0_30_32_3 Node0_30_32 Node1_30_32 12.320000000000002
C_0_30_32 Node0_30_32 GND 3.609375e-06
I_0_30_33 GND Node0_30_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_33_1 Node0_30_33 Node0_30_34 77.0
R_0_30_33_2 Node0_30_33 Node0_31_33 77.0
R_0_30_33_3 Node0_30_33 Node1_30_33 12.320000000000002
C_0_30_33 Node0_30_33 GND 3.609375e-06
I_0_30_34 GND Node0_30_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_34_1 Node0_30_34 Node0_30_35 77.0
R_0_30_34_2 Node0_30_34 Node0_31_34 77.0
R_0_30_34_3 Node0_30_34 Node1_30_34 12.320000000000002
C_0_30_34 Node0_30_34 GND 3.609375e-06
I_0_30_35 GND Node0_30_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_35_1 Node0_30_35 Node0_30_36 77.0
R_0_30_35_2 Node0_30_35 Node0_31_35 77.0
R_0_30_35_3 Node0_30_35 Node1_30_35 12.320000000000002
C_0_30_35 Node0_30_35 GND 3.609375e-06
I_0_30_36 GND Node0_30_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_36_1 Node0_30_36 Node0_30_37 77.0
R_0_30_36_2 Node0_30_36 Node0_31_36 77.0
R_0_30_36_3 Node0_30_36 Node1_30_36 12.320000000000002
C_0_30_36 Node0_30_36 GND 3.609375e-06
I_0_30_37 GND Node0_30_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_37_1 Node0_30_37 Node0_30_38 77.0
R_0_30_37_2 Node0_30_37 Node0_31_37 77.0
R_0_30_37_3 Node0_30_37 Node1_30_37 12.320000000000002
C_0_30_37 Node0_30_37 GND 3.609375e-06
I_0_30_38 GND Node0_30_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_38_1 Node0_30_38 Node0_30_39 77.0
R_0_30_38_2 Node0_30_38 Node0_31_38 77.0
R_0_30_38_3 Node0_30_38 Node1_30_38 12.320000000000002
C_0_30_38 Node0_30_38 GND 3.609375e-06
I_0_30_39 GND Node0_30_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_30_39_2 Node0_30_39 Node0_31_39 77.0
R_0_30_39_3 Node0_30_39 Node1_30_39 12.320000000000002
C_0_30_39 Node0_30_39 GND 3.609375e-06
I_0_31_0 GND Node0_31_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_0_1 Node0_31_0 Node0_31_1 77.0
R_0_31_0_2 Node0_31_0 Node0_32_0 77.0
R_0_31_0_3 Node0_31_0 Node1_31_0 12.320000000000002
C_0_31_0 Node0_31_0 GND 3.609375e-06
I_0_31_1 GND Node0_31_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_1_1 Node0_31_1 Node0_31_2 77.0
R_0_31_1_2 Node0_31_1 Node0_32_1 77.0
R_0_31_1_3 Node0_31_1 Node1_31_1 12.320000000000002
C_0_31_1 Node0_31_1 GND 3.609375e-06
I_0_31_2 GND Node0_31_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_2_1 Node0_31_2 Node0_31_3 77.0
R_0_31_2_2 Node0_31_2 Node0_32_2 77.0
R_0_31_2_3 Node0_31_2 Node1_31_2 12.320000000000002
C_0_31_2 Node0_31_2 GND 3.609375e-06
I_0_31_3 GND Node0_31_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_3_1 Node0_31_3 Node0_31_4 77.0
R_0_31_3_2 Node0_31_3 Node0_32_3 77.0
R_0_31_3_3 Node0_31_3 Node1_31_3 12.320000000000002
C_0_31_3 Node0_31_3 GND 3.609375e-06
I_0_31_4 GND Node0_31_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_4_1 Node0_31_4 Node0_31_5 77.0
R_0_31_4_2 Node0_31_4 Node0_32_4 77.0
R_0_31_4_3 Node0_31_4 Node1_31_4 12.320000000000002
C_0_31_4 Node0_31_4 GND 3.609375e-06
I_0_31_5 GND Node0_31_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_5_1 Node0_31_5 Node0_31_6 77.0
R_0_31_5_2 Node0_31_5 Node0_32_5 77.0
R_0_31_5_3 Node0_31_5 Node1_31_5 12.320000000000002
C_0_31_5 Node0_31_5 GND 3.609375e-06
I_0_31_6 GND Node0_31_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_6_1 Node0_31_6 Node0_31_7 77.0
R_0_31_6_2 Node0_31_6 Node0_32_6 77.0
R_0_31_6_3 Node0_31_6 Node1_31_6 12.320000000000002
C_0_31_6 Node0_31_6 GND 3.609375e-06
I_0_31_7 GND Node0_31_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_7_1 Node0_31_7 Node0_31_8 77.0
R_0_31_7_2 Node0_31_7 Node0_32_7 77.0
R_0_31_7_3 Node0_31_7 Node1_31_7 12.320000000000002
C_0_31_7 Node0_31_7 GND 3.609375e-06
I_0_31_8 GND Node0_31_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_8_1 Node0_31_8 Node0_31_9 77.0
R_0_31_8_2 Node0_31_8 Node0_32_8 77.0
R_0_31_8_3 Node0_31_8 Node1_31_8 12.320000000000002
C_0_31_8 Node0_31_8 GND 3.609375e-06
I_0_31_9 GND Node0_31_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_9_1 Node0_31_9 Node0_31_10 77.0
R_0_31_9_2 Node0_31_9 Node0_32_9 77.0
R_0_31_9_3 Node0_31_9 Node1_31_9 12.320000000000002
C_0_31_9 Node0_31_9 GND 3.609375e-06
I_0_31_10 GND Node0_31_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_10_1 Node0_31_10 Node0_31_11 77.0
R_0_31_10_2 Node0_31_10 Node0_32_10 77.0
R_0_31_10_3 Node0_31_10 Node1_31_10 12.320000000000002
C_0_31_10 Node0_31_10 GND 3.609375e-06
I_0_31_11 GND Node0_31_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_11_1 Node0_31_11 Node0_31_12 77.0
R_0_31_11_2 Node0_31_11 Node0_32_11 77.0
R_0_31_11_3 Node0_31_11 Node1_31_11 12.320000000000002
C_0_31_11 Node0_31_11 GND 3.609375e-06
I_0_31_12 GND Node0_31_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_12_1 Node0_31_12 Node0_31_13 77.0
R_0_31_12_2 Node0_31_12 Node0_32_12 77.0
R_0_31_12_3 Node0_31_12 Node1_31_12 12.320000000000002
C_0_31_12 Node0_31_12 GND 3.609375e-06
I_0_31_13 GND Node0_31_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_13_1 Node0_31_13 Node0_31_14 77.0
R_0_31_13_2 Node0_31_13 Node0_32_13 77.0
R_0_31_13_3 Node0_31_13 Node1_31_13 12.320000000000002
C_0_31_13 Node0_31_13 GND 3.609375e-06
I_0_31_14 GND Node0_31_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_14_1 Node0_31_14 Node0_31_15 77.0
R_0_31_14_2 Node0_31_14 Node0_32_14 77.0
R_0_31_14_3 Node0_31_14 Node1_31_14 12.320000000000002
C_0_31_14 Node0_31_14 GND 3.609375e-06
I_0_31_15 GND Node0_31_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_15_1 Node0_31_15 Node0_31_16 77.0
R_0_31_15_2 Node0_31_15 Node0_32_15 77.0
R_0_31_15_3 Node0_31_15 Node1_31_15 12.320000000000002
C_0_31_15 Node0_31_15 GND 3.609375e-06
I_0_31_16 GND Node0_31_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_16_1 Node0_31_16 Node0_31_17 77.0
R_0_31_16_2 Node0_31_16 Node0_32_16 77.0
R_0_31_16_3 Node0_31_16 Node1_31_16 12.320000000000002
C_0_31_16 Node0_31_16 GND 3.609375e-06
I_0_31_17 GND Node0_31_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_17_1 Node0_31_17 Node0_31_18 77.0
R_0_31_17_2 Node0_31_17 Node0_32_17 77.0
R_0_31_17_3 Node0_31_17 Node1_31_17 12.320000000000002
C_0_31_17 Node0_31_17 GND 3.609375e-06
I_0_31_18 GND Node0_31_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_18_1 Node0_31_18 Node0_31_19 77.0
R_0_31_18_2 Node0_31_18 Node0_32_18 77.0
R_0_31_18_3 Node0_31_18 Node1_31_18 12.320000000000002
C_0_31_18 Node0_31_18 GND 3.609375e-06
I_0_31_19 GND Node0_31_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_19_1 Node0_31_19 Node0_31_20 77.0
R_0_31_19_2 Node0_31_19 Node0_32_19 77.0
R_0_31_19_3 Node0_31_19 Node1_31_19 12.320000000000002
C_0_31_19 Node0_31_19 GND 3.609375e-06
I_0_31_20 GND Node0_31_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_20_1 Node0_31_20 Node0_31_21 77.0
R_0_31_20_2 Node0_31_20 Node0_32_20 77.0
R_0_31_20_3 Node0_31_20 Node1_31_20 12.320000000000002
C_0_31_20 Node0_31_20 GND 3.609375e-06
I_0_31_21 GND Node0_31_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_21_1 Node0_31_21 Node0_31_22 77.0
R_0_31_21_2 Node0_31_21 Node0_32_21 77.0
R_0_31_21_3 Node0_31_21 Node1_31_21 12.320000000000002
C_0_31_21 Node0_31_21 GND 3.609375e-06
I_0_31_22 GND Node0_31_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_22_1 Node0_31_22 Node0_31_23 77.0
R_0_31_22_2 Node0_31_22 Node0_32_22 77.0
R_0_31_22_3 Node0_31_22 Node1_31_22 12.320000000000002
C_0_31_22 Node0_31_22 GND 3.609375e-06
I_0_31_23 GND Node0_31_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_23_1 Node0_31_23 Node0_31_24 77.0
R_0_31_23_2 Node0_31_23 Node0_32_23 77.0
R_0_31_23_3 Node0_31_23 Node1_31_23 12.320000000000002
C_0_31_23 Node0_31_23 GND 3.609375e-06
I_0_31_24 GND Node0_31_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_24_1 Node0_31_24 Node0_31_25 77.0
R_0_31_24_2 Node0_31_24 Node0_32_24 77.0
R_0_31_24_3 Node0_31_24 Node1_31_24 12.320000000000002
C_0_31_24 Node0_31_24 GND 3.609375e-06
I_0_31_25 GND Node0_31_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_25_1 Node0_31_25 Node0_31_26 77.0
R_0_31_25_2 Node0_31_25 Node0_32_25 77.0
R_0_31_25_3 Node0_31_25 Node1_31_25 12.320000000000002
C_0_31_25 Node0_31_25 GND 3.609375e-06
I_0_31_26 GND Node0_31_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_26_1 Node0_31_26 Node0_31_27 77.0
R_0_31_26_2 Node0_31_26 Node0_32_26 77.0
R_0_31_26_3 Node0_31_26 Node1_31_26 12.320000000000002
C_0_31_26 Node0_31_26 GND 3.609375e-06
I_0_31_27 GND Node0_31_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_27_1 Node0_31_27 Node0_31_28 77.0
R_0_31_27_2 Node0_31_27 Node0_32_27 77.0
R_0_31_27_3 Node0_31_27 Node1_31_27 12.320000000000002
C_0_31_27 Node0_31_27 GND 3.609375e-06
I_0_31_28 GND Node0_31_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_28_1 Node0_31_28 Node0_31_29 77.0
R_0_31_28_2 Node0_31_28 Node0_32_28 77.0
R_0_31_28_3 Node0_31_28 Node1_31_28 12.320000000000002
C_0_31_28 Node0_31_28 GND 3.609375e-06
I_0_31_29 GND Node0_31_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_29_1 Node0_31_29 Node0_31_30 77.0
R_0_31_29_2 Node0_31_29 Node0_32_29 77.0
R_0_31_29_3 Node0_31_29 Node1_31_29 12.320000000000002
C_0_31_29 Node0_31_29 GND 3.609375e-06
I_0_31_30 GND Node0_31_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_30_1 Node0_31_30 Node0_31_31 77.0
R_0_31_30_2 Node0_31_30 Node0_32_30 77.0
R_0_31_30_3 Node0_31_30 Node1_31_30 12.320000000000002
C_0_31_30 Node0_31_30 GND 3.609375e-06
I_0_31_31 GND Node0_31_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_31_1 Node0_31_31 Node0_31_32 77.0
R_0_31_31_2 Node0_31_31 Node0_32_31 77.0
R_0_31_31_3 Node0_31_31 Node1_31_31 12.320000000000002
C_0_31_31 Node0_31_31 GND 3.609375e-06
I_0_31_32 GND Node0_31_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_32_1 Node0_31_32 Node0_31_33 77.0
R_0_31_32_2 Node0_31_32 Node0_32_32 77.0
R_0_31_32_3 Node0_31_32 Node1_31_32 12.320000000000002
C_0_31_32 Node0_31_32 GND 3.609375e-06
I_0_31_33 GND Node0_31_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_33_1 Node0_31_33 Node0_31_34 77.0
R_0_31_33_2 Node0_31_33 Node0_32_33 77.0
R_0_31_33_3 Node0_31_33 Node1_31_33 12.320000000000002
C_0_31_33 Node0_31_33 GND 3.609375e-06
I_0_31_34 GND Node0_31_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_34_1 Node0_31_34 Node0_31_35 77.0
R_0_31_34_2 Node0_31_34 Node0_32_34 77.0
R_0_31_34_3 Node0_31_34 Node1_31_34 12.320000000000002
C_0_31_34 Node0_31_34 GND 3.609375e-06
I_0_31_35 GND Node0_31_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_35_1 Node0_31_35 Node0_31_36 77.0
R_0_31_35_2 Node0_31_35 Node0_32_35 77.0
R_0_31_35_3 Node0_31_35 Node1_31_35 12.320000000000002
C_0_31_35 Node0_31_35 GND 3.609375e-06
I_0_31_36 GND Node0_31_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_36_1 Node0_31_36 Node0_31_37 77.0
R_0_31_36_2 Node0_31_36 Node0_32_36 77.0
R_0_31_36_3 Node0_31_36 Node1_31_36 12.320000000000002
C_0_31_36 Node0_31_36 GND 3.609375e-06
I_0_31_37 GND Node0_31_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_37_1 Node0_31_37 Node0_31_38 77.0
R_0_31_37_2 Node0_31_37 Node0_32_37 77.0
R_0_31_37_3 Node0_31_37 Node1_31_37 12.320000000000002
C_0_31_37 Node0_31_37 GND 3.609375e-06
I_0_31_38 GND Node0_31_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_38_1 Node0_31_38 Node0_31_39 77.0
R_0_31_38_2 Node0_31_38 Node0_32_38 77.0
R_0_31_38_3 Node0_31_38 Node1_31_38 12.320000000000002
C_0_31_38 Node0_31_38 GND 3.609375e-06
I_0_31_39 GND Node0_31_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_31_39_2 Node0_31_39 Node0_32_39 77.0
R_0_31_39_3 Node0_31_39 Node1_31_39 12.320000000000002
C_0_31_39 Node0_31_39 GND 3.609375e-06
I_0_32_0 GND Node0_32_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_0_1 Node0_32_0 Node0_32_1 77.0
R_0_32_0_2 Node0_32_0 Node0_33_0 77.0
R_0_32_0_3 Node0_32_0 Node1_32_0 12.320000000000002
C_0_32_0 Node0_32_0 GND 3.609375e-06
I_0_32_1 GND Node0_32_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_1_1 Node0_32_1 Node0_32_2 77.0
R_0_32_1_2 Node0_32_1 Node0_33_1 77.0
R_0_32_1_3 Node0_32_1 Node1_32_1 12.320000000000002
C_0_32_1 Node0_32_1 GND 3.609375e-06
I_0_32_2 GND Node0_32_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_2_1 Node0_32_2 Node0_32_3 77.0
R_0_32_2_2 Node0_32_2 Node0_33_2 77.0
R_0_32_2_3 Node0_32_2 Node1_32_2 12.320000000000002
C_0_32_2 Node0_32_2 GND 3.609375e-06
I_0_32_3 GND Node0_32_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_3_1 Node0_32_3 Node0_32_4 77.0
R_0_32_3_2 Node0_32_3 Node0_33_3 77.0
R_0_32_3_3 Node0_32_3 Node1_32_3 12.320000000000002
C_0_32_3 Node0_32_3 GND 3.609375e-06
I_0_32_4 GND Node0_32_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_4_1 Node0_32_4 Node0_32_5 77.0
R_0_32_4_2 Node0_32_4 Node0_33_4 77.0
R_0_32_4_3 Node0_32_4 Node1_32_4 12.320000000000002
C_0_32_4 Node0_32_4 GND 3.609375e-06
I_0_32_5 GND Node0_32_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_5_1 Node0_32_5 Node0_32_6 77.0
R_0_32_5_2 Node0_32_5 Node0_33_5 77.0
R_0_32_5_3 Node0_32_5 Node1_32_5 12.320000000000002
C_0_32_5 Node0_32_5 GND 3.609375e-06
I_0_32_6 GND Node0_32_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_6_1 Node0_32_6 Node0_32_7 77.0
R_0_32_6_2 Node0_32_6 Node0_33_6 77.0
R_0_32_6_3 Node0_32_6 Node1_32_6 12.320000000000002
C_0_32_6 Node0_32_6 GND 3.609375e-06
I_0_32_7 GND Node0_32_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_7_1 Node0_32_7 Node0_32_8 77.0
R_0_32_7_2 Node0_32_7 Node0_33_7 77.0
R_0_32_7_3 Node0_32_7 Node1_32_7 12.320000000000002
C_0_32_7 Node0_32_7 GND 3.609375e-06
I_0_32_8 GND Node0_32_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_8_1 Node0_32_8 Node0_32_9 77.0
R_0_32_8_2 Node0_32_8 Node0_33_8 77.0
R_0_32_8_3 Node0_32_8 Node1_32_8 12.320000000000002
C_0_32_8 Node0_32_8 GND 3.609375e-06
I_0_32_9 GND Node0_32_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_9_1 Node0_32_9 Node0_32_10 77.0
R_0_32_9_2 Node0_32_9 Node0_33_9 77.0
R_0_32_9_3 Node0_32_9 Node1_32_9 12.320000000000002
C_0_32_9 Node0_32_9 GND 3.609375e-06
I_0_32_10 GND Node0_32_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_10_1 Node0_32_10 Node0_32_11 77.0
R_0_32_10_2 Node0_32_10 Node0_33_10 77.0
R_0_32_10_3 Node0_32_10 Node1_32_10 12.320000000000002
C_0_32_10 Node0_32_10 GND 3.609375e-06
I_0_32_11 GND Node0_32_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_11_1 Node0_32_11 Node0_32_12 77.0
R_0_32_11_2 Node0_32_11 Node0_33_11 77.0
R_0_32_11_3 Node0_32_11 Node1_32_11 12.320000000000002
C_0_32_11 Node0_32_11 GND 3.609375e-06
I_0_32_12 GND Node0_32_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_12_1 Node0_32_12 Node0_32_13 77.0
R_0_32_12_2 Node0_32_12 Node0_33_12 77.0
R_0_32_12_3 Node0_32_12 Node1_32_12 12.320000000000002
C_0_32_12 Node0_32_12 GND 3.609375e-06
I_0_32_13 GND Node0_32_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_13_1 Node0_32_13 Node0_32_14 77.0
R_0_32_13_2 Node0_32_13 Node0_33_13 77.0
R_0_32_13_3 Node0_32_13 Node1_32_13 12.320000000000002
C_0_32_13 Node0_32_13 GND 3.609375e-06
I_0_32_14 GND Node0_32_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_14_1 Node0_32_14 Node0_32_15 77.0
R_0_32_14_2 Node0_32_14 Node0_33_14 77.0
R_0_32_14_3 Node0_32_14 Node1_32_14 12.320000000000002
C_0_32_14 Node0_32_14 GND 3.609375e-06
I_0_32_15 GND Node0_32_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_15_1 Node0_32_15 Node0_32_16 77.0
R_0_32_15_2 Node0_32_15 Node0_33_15 77.0
R_0_32_15_3 Node0_32_15 Node1_32_15 12.320000000000002
C_0_32_15 Node0_32_15 GND 3.609375e-06
I_0_32_16 GND Node0_32_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_16_1 Node0_32_16 Node0_32_17 77.0
R_0_32_16_2 Node0_32_16 Node0_33_16 77.0
R_0_32_16_3 Node0_32_16 Node1_32_16 12.320000000000002
C_0_32_16 Node0_32_16 GND 3.609375e-06
I_0_32_17 GND Node0_32_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_17_1 Node0_32_17 Node0_32_18 77.0
R_0_32_17_2 Node0_32_17 Node0_33_17 77.0
R_0_32_17_3 Node0_32_17 Node1_32_17 12.320000000000002
C_0_32_17 Node0_32_17 GND 3.609375e-06
I_0_32_18 GND Node0_32_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_18_1 Node0_32_18 Node0_32_19 77.0
R_0_32_18_2 Node0_32_18 Node0_33_18 77.0
R_0_32_18_3 Node0_32_18 Node1_32_18 12.320000000000002
C_0_32_18 Node0_32_18 GND 3.609375e-06
I_0_32_19 GND Node0_32_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_19_1 Node0_32_19 Node0_32_20 77.0
R_0_32_19_2 Node0_32_19 Node0_33_19 77.0
R_0_32_19_3 Node0_32_19 Node1_32_19 12.320000000000002
C_0_32_19 Node0_32_19 GND 3.609375e-06
I_0_32_20 GND Node0_32_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_20_1 Node0_32_20 Node0_32_21 77.0
R_0_32_20_2 Node0_32_20 Node0_33_20 77.0
R_0_32_20_3 Node0_32_20 Node1_32_20 12.320000000000002
C_0_32_20 Node0_32_20 GND 3.609375e-06
I_0_32_21 GND Node0_32_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_21_1 Node0_32_21 Node0_32_22 77.0
R_0_32_21_2 Node0_32_21 Node0_33_21 77.0
R_0_32_21_3 Node0_32_21 Node1_32_21 12.320000000000002
C_0_32_21 Node0_32_21 GND 3.609375e-06
I_0_32_22 GND Node0_32_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_22_1 Node0_32_22 Node0_32_23 77.0
R_0_32_22_2 Node0_32_22 Node0_33_22 77.0
R_0_32_22_3 Node0_32_22 Node1_32_22 12.320000000000002
C_0_32_22 Node0_32_22 GND 3.609375e-06
I_0_32_23 GND Node0_32_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_23_1 Node0_32_23 Node0_32_24 77.0
R_0_32_23_2 Node0_32_23 Node0_33_23 77.0
R_0_32_23_3 Node0_32_23 Node1_32_23 12.320000000000002
C_0_32_23 Node0_32_23 GND 3.609375e-06
I_0_32_24 GND Node0_32_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_24_1 Node0_32_24 Node0_32_25 77.0
R_0_32_24_2 Node0_32_24 Node0_33_24 77.0
R_0_32_24_3 Node0_32_24 Node1_32_24 12.320000000000002
C_0_32_24 Node0_32_24 GND 3.609375e-06
I_0_32_25 GND Node0_32_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_25_1 Node0_32_25 Node0_32_26 77.0
R_0_32_25_2 Node0_32_25 Node0_33_25 77.0
R_0_32_25_3 Node0_32_25 Node1_32_25 12.320000000000002
C_0_32_25 Node0_32_25 GND 3.609375e-06
I_0_32_26 GND Node0_32_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_26_1 Node0_32_26 Node0_32_27 77.0
R_0_32_26_2 Node0_32_26 Node0_33_26 77.0
R_0_32_26_3 Node0_32_26 Node1_32_26 12.320000000000002
C_0_32_26 Node0_32_26 GND 3.609375e-06
I_0_32_27 GND Node0_32_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_27_1 Node0_32_27 Node0_32_28 77.0
R_0_32_27_2 Node0_32_27 Node0_33_27 77.0
R_0_32_27_3 Node0_32_27 Node1_32_27 12.320000000000002
C_0_32_27 Node0_32_27 GND 3.609375e-06
I_0_32_28 GND Node0_32_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_28_1 Node0_32_28 Node0_32_29 77.0
R_0_32_28_2 Node0_32_28 Node0_33_28 77.0
R_0_32_28_3 Node0_32_28 Node1_32_28 12.320000000000002
C_0_32_28 Node0_32_28 GND 3.609375e-06
I_0_32_29 GND Node0_32_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_29_1 Node0_32_29 Node0_32_30 77.0
R_0_32_29_2 Node0_32_29 Node0_33_29 77.0
R_0_32_29_3 Node0_32_29 Node1_32_29 12.320000000000002
C_0_32_29 Node0_32_29 GND 3.609375e-06
I_0_32_30 GND Node0_32_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_30_1 Node0_32_30 Node0_32_31 77.0
R_0_32_30_2 Node0_32_30 Node0_33_30 77.0
R_0_32_30_3 Node0_32_30 Node1_32_30 12.320000000000002
C_0_32_30 Node0_32_30 GND 3.609375e-06
I_0_32_31 GND Node0_32_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_31_1 Node0_32_31 Node0_32_32 77.0
R_0_32_31_2 Node0_32_31 Node0_33_31 77.0
R_0_32_31_3 Node0_32_31 Node1_32_31 12.320000000000002
C_0_32_31 Node0_32_31 GND 3.609375e-06
I_0_32_32 GND Node0_32_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_32_1 Node0_32_32 Node0_32_33 77.0
R_0_32_32_2 Node0_32_32 Node0_33_32 77.0
R_0_32_32_3 Node0_32_32 Node1_32_32 12.320000000000002
C_0_32_32 Node0_32_32 GND 3.609375e-06
I_0_32_33 GND Node0_32_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_33_1 Node0_32_33 Node0_32_34 77.0
R_0_32_33_2 Node0_32_33 Node0_33_33 77.0
R_0_32_33_3 Node0_32_33 Node1_32_33 12.320000000000002
C_0_32_33 Node0_32_33 GND 3.609375e-06
I_0_32_34 GND Node0_32_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_34_1 Node0_32_34 Node0_32_35 77.0
R_0_32_34_2 Node0_32_34 Node0_33_34 77.0
R_0_32_34_3 Node0_32_34 Node1_32_34 12.320000000000002
C_0_32_34 Node0_32_34 GND 3.609375e-06
I_0_32_35 GND Node0_32_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_35_1 Node0_32_35 Node0_32_36 77.0
R_0_32_35_2 Node0_32_35 Node0_33_35 77.0
R_0_32_35_3 Node0_32_35 Node1_32_35 12.320000000000002
C_0_32_35 Node0_32_35 GND 3.609375e-06
I_0_32_36 GND Node0_32_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_36_1 Node0_32_36 Node0_32_37 77.0
R_0_32_36_2 Node0_32_36 Node0_33_36 77.0
R_0_32_36_3 Node0_32_36 Node1_32_36 12.320000000000002
C_0_32_36 Node0_32_36 GND 3.609375e-06
I_0_32_37 GND Node0_32_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_37_1 Node0_32_37 Node0_32_38 77.0
R_0_32_37_2 Node0_32_37 Node0_33_37 77.0
R_0_32_37_3 Node0_32_37 Node1_32_37 12.320000000000002
C_0_32_37 Node0_32_37 GND 3.609375e-06
I_0_32_38 GND Node0_32_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_38_1 Node0_32_38 Node0_32_39 77.0
R_0_32_38_2 Node0_32_38 Node0_33_38 77.0
R_0_32_38_3 Node0_32_38 Node1_32_38 12.320000000000002
C_0_32_38 Node0_32_38 GND 3.609375e-06
I_0_32_39 GND Node0_32_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_32_39_2 Node0_32_39 Node0_33_39 77.0
R_0_32_39_3 Node0_32_39 Node1_32_39 12.320000000000002
C_0_32_39 Node0_32_39 GND 3.609375e-06
I_0_33_0 GND Node0_33_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_0_1 Node0_33_0 Node0_33_1 77.0
R_0_33_0_2 Node0_33_0 Node0_34_0 77.0
R_0_33_0_3 Node0_33_0 Node1_33_0 12.320000000000002
C_0_33_0 Node0_33_0 GND 3.609375e-06
I_0_33_1 GND Node0_33_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_1_1 Node0_33_1 Node0_33_2 77.0
R_0_33_1_2 Node0_33_1 Node0_34_1 77.0
R_0_33_1_3 Node0_33_1 Node1_33_1 12.320000000000002
C_0_33_1 Node0_33_1 GND 3.609375e-06
I_0_33_2 GND Node0_33_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_2_1 Node0_33_2 Node0_33_3 77.0
R_0_33_2_2 Node0_33_2 Node0_34_2 77.0
R_0_33_2_3 Node0_33_2 Node1_33_2 12.320000000000002
C_0_33_2 Node0_33_2 GND 3.609375e-06
I_0_33_3 GND Node0_33_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_3_1 Node0_33_3 Node0_33_4 77.0
R_0_33_3_2 Node0_33_3 Node0_34_3 77.0
R_0_33_3_3 Node0_33_3 Node1_33_3 12.320000000000002
C_0_33_3 Node0_33_3 GND 3.609375e-06
I_0_33_4 GND Node0_33_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_4_1 Node0_33_4 Node0_33_5 77.0
R_0_33_4_2 Node0_33_4 Node0_34_4 77.0
R_0_33_4_3 Node0_33_4 Node1_33_4 12.320000000000002
C_0_33_4 Node0_33_4 GND 3.609375e-06
I_0_33_5 GND Node0_33_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_5_1 Node0_33_5 Node0_33_6 77.0
R_0_33_5_2 Node0_33_5 Node0_34_5 77.0
R_0_33_5_3 Node0_33_5 Node1_33_5 12.320000000000002
C_0_33_5 Node0_33_5 GND 3.609375e-06
I_0_33_6 GND Node0_33_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_6_1 Node0_33_6 Node0_33_7 77.0
R_0_33_6_2 Node0_33_6 Node0_34_6 77.0
R_0_33_6_3 Node0_33_6 Node1_33_6 12.320000000000002
C_0_33_6 Node0_33_6 GND 3.609375e-06
I_0_33_7 GND Node0_33_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_7_1 Node0_33_7 Node0_33_8 77.0
R_0_33_7_2 Node0_33_7 Node0_34_7 77.0
R_0_33_7_3 Node0_33_7 Node1_33_7 12.320000000000002
C_0_33_7 Node0_33_7 GND 3.609375e-06
I_0_33_8 GND Node0_33_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_8_1 Node0_33_8 Node0_33_9 77.0
R_0_33_8_2 Node0_33_8 Node0_34_8 77.0
R_0_33_8_3 Node0_33_8 Node1_33_8 12.320000000000002
C_0_33_8 Node0_33_8 GND 3.609375e-06
I_0_33_9 GND Node0_33_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_9_1 Node0_33_9 Node0_33_10 77.0
R_0_33_9_2 Node0_33_9 Node0_34_9 77.0
R_0_33_9_3 Node0_33_9 Node1_33_9 12.320000000000002
C_0_33_9 Node0_33_9 GND 3.609375e-06
I_0_33_10 GND Node0_33_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_10_1 Node0_33_10 Node0_33_11 77.0
R_0_33_10_2 Node0_33_10 Node0_34_10 77.0
R_0_33_10_3 Node0_33_10 Node1_33_10 12.320000000000002
C_0_33_10 Node0_33_10 GND 3.609375e-06
I_0_33_11 GND Node0_33_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_11_1 Node0_33_11 Node0_33_12 77.0
R_0_33_11_2 Node0_33_11 Node0_34_11 77.0
R_0_33_11_3 Node0_33_11 Node1_33_11 12.320000000000002
C_0_33_11 Node0_33_11 GND 3.609375e-06
I_0_33_12 GND Node0_33_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_12_1 Node0_33_12 Node0_33_13 77.0
R_0_33_12_2 Node0_33_12 Node0_34_12 77.0
R_0_33_12_3 Node0_33_12 Node1_33_12 12.320000000000002
C_0_33_12 Node0_33_12 GND 3.609375e-06
I_0_33_13 GND Node0_33_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_13_1 Node0_33_13 Node0_33_14 77.0
R_0_33_13_2 Node0_33_13 Node0_34_13 77.0
R_0_33_13_3 Node0_33_13 Node1_33_13 12.320000000000002
C_0_33_13 Node0_33_13 GND 3.609375e-06
I_0_33_14 GND Node0_33_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_14_1 Node0_33_14 Node0_33_15 77.0
R_0_33_14_2 Node0_33_14 Node0_34_14 77.0
R_0_33_14_3 Node0_33_14 Node1_33_14 12.320000000000002
C_0_33_14 Node0_33_14 GND 3.609375e-06
I_0_33_15 GND Node0_33_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_15_1 Node0_33_15 Node0_33_16 77.0
R_0_33_15_2 Node0_33_15 Node0_34_15 77.0
R_0_33_15_3 Node0_33_15 Node1_33_15 12.320000000000002
C_0_33_15 Node0_33_15 GND 3.609375e-06
I_0_33_16 GND Node0_33_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_16_1 Node0_33_16 Node0_33_17 77.0
R_0_33_16_2 Node0_33_16 Node0_34_16 77.0
R_0_33_16_3 Node0_33_16 Node1_33_16 12.320000000000002
C_0_33_16 Node0_33_16 GND 3.609375e-06
I_0_33_17 GND Node0_33_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_17_1 Node0_33_17 Node0_33_18 77.0
R_0_33_17_2 Node0_33_17 Node0_34_17 77.0
R_0_33_17_3 Node0_33_17 Node1_33_17 12.320000000000002
C_0_33_17 Node0_33_17 GND 3.609375e-06
I_0_33_18 GND Node0_33_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_18_1 Node0_33_18 Node0_33_19 77.0
R_0_33_18_2 Node0_33_18 Node0_34_18 77.0
R_0_33_18_3 Node0_33_18 Node1_33_18 12.320000000000002
C_0_33_18 Node0_33_18 GND 3.609375e-06
I_0_33_19 GND Node0_33_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_19_1 Node0_33_19 Node0_33_20 77.0
R_0_33_19_2 Node0_33_19 Node0_34_19 77.0
R_0_33_19_3 Node0_33_19 Node1_33_19 12.320000000000002
C_0_33_19 Node0_33_19 GND 3.609375e-06
I_0_33_20 GND Node0_33_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_20_1 Node0_33_20 Node0_33_21 77.0
R_0_33_20_2 Node0_33_20 Node0_34_20 77.0
R_0_33_20_3 Node0_33_20 Node1_33_20 12.320000000000002
C_0_33_20 Node0_33_20 GND 3.609375e-06
I_0_33_21 GND Node0_33_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_21_1 Node0_33_21 Node0_33_22 77.0
R_0_33_21_2 Node0_33_21 Node0_34_21 77.0
R_0_33_21_3 Node0_33_21 Node1_33_21 12.320000000000002
C_0_33_21 Node0_33_21 GND 3.609375e-06
I_0_33_22 GND Node0_33_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_22_1 Node0_33_22 Node0_33_23 77.0
R_0_33_22_2 Node0_33_22 Node0_34_22 77.0
R_0_33_22_3 Node0_33_22 Node1_33_22 12.320000000000002
C_0_33_22 Node0_33_22 GND 3.609375e-06
I_0_33_23 GND Node0_33_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_23_1 Node0_33_23 Node0_33_24 77.0
R_0_33_23_2 Node0_33_23 Node0_34_23 77.0
R_0_33_23_3 Node0_33_23 Node1_33_23 12.320000000000002
C_0_33_23 Node0_33_23 GND 3.609375e-06
I_0_33_24 GND Node0_33_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_24_1 Node0_33_24 Node0_33_25 77.0
R_0_33_24_2 Node0_33_24 Node0_34_24 77.0
R_0_33_24_3 Node0_33_24 Node1_33_24 12.320000000000002
C_0_33_24 Node0_33_24 GND 3.609375e-06
I_0_33_25 GND Node0_33_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_25_1 Node0_33_25 Node0_33_26 77.0
R_0_33_25_2 Node0_33_25 Node0_34_25 77.0
R_0_33_25_3 Node0_33_25 Node1_33_25 12.320000000000002
C_0_33_25 Node0_33_25 GND 3.609375e-06
I_0_33_26 GND Node0_33_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_26_1 Node0_33_26 Node0_33_27 77.0
R_0_33_26_2 Node0_33_26 Node0_34_26 77.0
R_0_33_26_3 Node0_33_26 Node1_33_26 12.320000000000002
C_0_33_26 Node0_33_26 GND 3.609375e-06
I_0_33_27 GND Node0_33_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_27_1 Node0_33_27 Node0_33_28 77.0
R_0_33_27_2 Node0_33_27 Node0_34_27 77.0
R_0_33_27_3 Node0_33_27 Node1_33_27 12.320000000000002
C_0_33_27 Node0_33_27 GND 3.609375e-06
I_0_33_28 GND Node0_33_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_28_1 Node0_33_28 Node0_33_29 77.0
R_0_33_28_2 Node0_33_28 Node0_34_28 77.0
R_0_33_28_3 Node0_33_28 Node1_33_28 12.320000000000002
C_0_33_28 Node0_33_28 GND 3.609375e-06
I_0_33_29 GND Node0_33_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_29_1 Node0_33_29 Node0_33_30 77.0
R_0_33_29_2 Node0_33_29 Node0_34_29 77.0
R_0_33_29_3 Node0_33_29 Node1_33_29 12.320000000000002
C_0_33_29 Node0_33_29 GND 3.609375e-06
I_0_33_30 GND Node0_33_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_30_1 Node0_33_30 Node0_33_31 77.0
R_0_33_30_2 Node0_33_30 Node0_34_30 77.0
R_0_33_30_3 Node0_33_30 Node1_33_30 12.320000000000002
C_0_33_30 Node0_33_30 GND 3.609375e-06
I_0_33_31 GND Node0_33_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_31_1 Node0_33_31 Node0_33_32 77.0
R_0_33_31_2 Node0_33_31 Node0_34_31 77.0
R_0_33_31_3 Node0_33_31 Node1_33_31 12.320000000000002
C_0_33_31 Node0_33_31 GND 3.609375e-06
I_0_33_32 GND Node0_33_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_32_1 Node0_33_32 Node0_33_33 77.0
R_0_33_32_2 Node0_33_32 Node0_34_32 77.0
R_0_33_32_3 Node0_33_32 Node1_33_32 12.320000000000002
C_0_33_32 Node0_33_32 GND 3.609375e-06
I_0_33_33 GND Node0_33_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_33_1 Node0_33_33 Node0_33_34 77.0
R_0_33_33_2 Node0_33_33 Node0_34_33 77.0
R_0_33_33_3 Node0_33_33 Node1_33_33 12.320000000000002
C_0_33_33 Node0_33_33 GND 3.609375e-06
I_0_33_34 GND Node0_33_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_34_1 Node0_33_34 Node0_33_35 77.0
R_0_33_34_2 Node0_33_34 Node0_34_34 77.0
R_0_33_34_3 Node0_33_34 Node1_33_34 12.320000000000002
C_0_33_34 Node0_33_34 GND 3.609375e-06
I_0_33_35 GND Node0_33_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_35_1 Node0_33_35 Node0_33_36 77.0
R_0_33_35_2 Node0_33_35 Node0_34_35 77.0
R_0_33_35_3 Node0_33_35 Node1_33_35 12.320000000000002
C_0_33_35 Node0_33_35 GND 3.609375e-06
I_0_33_36 GND Node0_33_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_36_1 Node0_33_36 Node0_33_37 77.0
R_0_33_36_2 Node0_33_36 Node0_34_36 77.0
R_0_33_36_3 Node0_33_36 Node1_33_36 12.320000000000002
C_0_33_36 Node0_33_36 GND 3.609375e-06
I_0_33_37 GND Node0_33_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_37_1 Node0_33_37 Node0_33_38 77.0
R_0_33_37_2 Node0_33_37 Node0_34_37 77.0
R_0_33_37_3 Node0_33_37 Node1_33_37 12.320000000000002
C_0_33_37 Node0_33_37 GND 3.609375e-06
I_0_33_38 GND Node0_33_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_38_1 Node0_33_38 Node0_33_39 77.0
R_0_33_38_2 Node0_33_38 Node0_34_38 77.0
R_0_33_38_3 Node0_33_38 Node1_33_38 12.320000000000002
C_0_33_38 Node0_33_38 GND 3.609375e-06
I_0_33_39 GND Node0_33_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_33_39_2 Node0_33_39 Node0_34_39 77.0
R_0_33_39_3 Node0_33_39 Node1_33_39 12.320000000000002
C_0_33_39 Node0_33_39 GND 3.609375e-06
I_0_34_0 GND Node0_34_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_0_1 Node0_34_0 Node0_34_1 77.0
R_0_34_0_2 Node0_34_0 Node0_35_0 77.0
R_0_34_0_3 Node0_34_0 Node1_34_0 12.320000000000002
C_0_34_0 Node0_34_0 GND 3.609375e-06
I_0_34_1 GND Node0_34_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_1_1 Node0_34_1 Node0_34_2 77.0
R_0_34_1_2 Node0_34_1 Node0_35_1 77.0
R_0_34_1_3 Node0_34_1 Node1_34_1 12.320000000000002
C_0_34_1 Node0_34_1 GND 3.609375e-06
I_0_34_2 GND Node0_34_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_2_1 Node0_34_2 Node0_34_3 77.0
R_0_34_2_2 Node0_34_2 Node0_35_2 77.0
R_0_34_2_3 Node0_34_2 Node1_34_2 12.320000000000002
C_0_34_2 Node0_34_2 GND 3.609375e-06
I_0_34_3 GND Node0_34_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_3_1 Node0_34_3 Node0_34_4 77.0
R_0_34_3_2 Node0_34_3 Node0_35_3 77.0
R_0_34_3_3 Node0_34_3 Node1_34_3 12.320000000000002
C_0_34_3 Node0_34_3 GND 3.609375e-06
I_0_34_4 GND Node0_34_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_4_1 Node0_34_4 Node0_34_5 77.0
R_0_34_4_2 Node0_34_4 Node0_35_4 77.0
R_0_34_4_3 Node0_34_4 Node1_34_4 12.320000000000002
C_0_34_4 Node0_34_4 GND 3.609375e-06
I_0_34_5 GND Node0_34_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_5_1 Node0_34_5 Node0_34_6 77.0
R_0_34_5_2 Node0_34_5 Node0_35_5 77.0
R_0_34_5_3 Node0_34_5 Node1_34_5 12.320000000000002
C_0_34_5 Node0_34_5 GND 3.609375e-06
I_0_34_6 GND Node0_34_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_6_1 Node0_34_6 Node0_34_7 77.0
R_0_34_6_2 Node0_34_6 Node0_35_6 77.0
R_0_34_6_3 Node0_34_6 Node1_34_6 12.320000000000002
C_0_34_6 Node0_34_6 GND 3.609375e-06
I_0_34_7 GND Node0_34_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_7_1 Node0_34_7 Node0_34_8 77.0
R_0_34_7_2 Node0_34_7 Node0_35_7 77.0
R_0_34_7_3 Node0_34_7 Node1_34_7 12.320000000000002
C_0_34_7 Node0_34_7 GND 3.609375e-06
I_0_34_8 GND Node0_34_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_8_1 Node0_34_8 Node0_34_9 77.0
R_0_34_8_2 Node0_34_8 Node0_35_8 77.0
R_0_34_8_3 Node0_34_8 Node1_34_8 12.320000000000002
C_0_34_8 Node0_34_8 GND 3.609375e-06
I_0_34_9 GND Node0_34_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_9_1 Node0_34_9 Node0_34_10 77.0
R_0_34_9_2 Node0_34_9 Node0_35_9 77.0
R_0_34_9_3 Node0_34_9 Node1_34_9 12.320000000000002
C_0_34_9 Node0_34_9 GND 3.609375e-06
I_0_34_10 GND Node0_34_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_10_1 Node0_34_10 Node0_34_11 77.0
R_0_34_10_2 Node0_34_10 Node0_35_10 77.0
R_0_34_10_3 Node0_34_10 Node1_34_10 12.320000000000002
C_0_34_10 Node0_34_10 GND 3.609375e-06
I_0_34_11 GND Node0_34_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_11_1 Node0_34_11 Node0_34_12 77.0
R_0_34_11_2 Node0_34_11 Node0_35_11 77.0
R_0_34_11_3 Node0_34_11 Node1_34_11 12.320000000000002
C_0_34_11 Node0_34_11 GND 3.609375e-06
I_0_34_12 GND Node0_34_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_12_1 Node0_34_12 Node0_34_13 77.0
R_0_34_12_2 Node0_34_12 Node0_35_12 77.0
R_0_34_12_3 Node0_34_12 Node1_34_12 12.320000000000002
C_0_34_12 Node0_34_12 GND 3.609375e-06
I_0_34_13 GND Node0_34_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_13_1 Node0_34_13 Node0_34_14 77.0
R_0_34_13_2 Node0_34_13 Node0_35_13 77.0
R_0_34_13_3 Node0_34_13 Node1_34_13 12.320000000000002
C_0_34_13 Node0_34_13 GND 3.609375e-06
I_0_34_14 GND Node0_34_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_14_1 Node0_34_14 Node0_34_15 77.0
R_0_34_14_2 Node0_34_14 Node0_35_14 77.0
R_0_34_14_3 Node0_34_14 Node1_34_14 12.320000000000002
C_0_34_14 Node0_34_14 GND 3.609375e-06
I_0_34_15 GND Node0_34_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_15_1 Node0_34_15 Node0_34_16 77.0
R_0_34_15_2 Node0_34_15 Node0_35_15 77.0
R_0_34_15_3 Node0_34_15 Node1_34_15 12.320000000000002
C_0_34_15 Node0_34_15 GND 3.609375e-06
I_0_34_16 GND Node0_34_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_16_1 Node0_34_16 Node0_34_17 77.0
R_0_34_16_2 Node0_34_16 Node0_35_16 77.0
R_0_34_16_3 Node0_34_16 Node1_34_16 12.320000000000002
C_0_34_16 Node0_34_16 GND 3.609375e-06
I_0_34_17 GND Node0_34_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_17_1 Node0_34_17 Node0_34_18 77.0
R_0_34_17_2 Node0_34_17 Node0_35_17 77.0
R_0_34_17_3 Node0_34_17 Node1_34_17 12.320000000000002
C_0_34_17 Node0_34_17 GND 3.609375e-06
I_0_34_18 GND Node0_34_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_18_1 Node0_34_18 Node0_34_19 77.0
R_0_34_18_2 Node0_34_18 Node0_35_18 77.0
R_0_34_18_3 Node0_34_18 Node1_34_18 12.320000000000002
C_0_34_18 Node0_34_18 GND 3.609375e-06
I_0_34_19 GND Node0_34_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_19_1 Node0_34_19 Node0_34_20 77.0
R_0_34_19_2 Node0_34_19 Node0_35_19 77.0
R_0_34_19_3 Node0_34_19 Node1_34_19 12.320000000000002
C_0_34_19 Node0_34_19 GND 3.609375e-06
I_0_34_20 GND Node0_34_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_20_1 Node0_34_20 Node0_34_21 77.0
R_0_34_20_2 Node0_34_20 Node0_35_20 77.0
R_0_34_20_3 Node0_34_20 Node1_34_20 12.320000000000002
C_0_34_20 Node0_34_20 GND 3.609375e-06
I_0_34_21 GND Node0_34_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_21_1 Node0_34_21 Node0_34_22 77.0
R_0_34_21_2 Node0_34_21 Node0_35_21 77.0
R_0_34_21_3 Node0_34_21 Node1_34_21 12.320000000000002
C_0_34_21 Node0_34_21 GND 3.609375e-06
I_0_34_22 GND Node0_34_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_22_1 Node0_34_22 Node0_34_23 77.0
R_0_34_22_2 Node0_34_22 Node0_35_22 77.0
R_0_34_22_3 Node0_34_22 Node1_34_22 12.320000000000002
C_0_34_22 Node0_34_22 GND 3.609375e-06
I_0_34_23 GND Node0_34_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_23_1 Node0_34_23 Node0_34_24 77.0
R_0_34_23_2 Node0_34_23 Node0_35_23 77.0
R_0_34_23_3 Node0_34_23 Node1_34_23 12.320000000000002
C_0_34_23 Node0_34_23 GND 3.609375e-06
I_0_34_24 GND Node0_34_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_24_1 Node0_34_24 Node0_34_25 77.0
R_0_34_24_2 Node0_34_24 Node0_35_24 77.0
R_0_34_24_3 Node0_34_24 Node1_34_24 12.320000000000002
C_0_34_24 Node0_34_24 GND 3.609375e-06
I_0_34_25 GND Node0_34_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_25_1 Node0_34_25 Node0_34_26 77.0
R_0_34_25_2 Node0_34_25 Node0_35_25 77.0
R_0_34_25_3 Node0_34_25 Node1_34_25 12.320000000000002
C_0_34_25 Node0_34_25 GND 3.609375e-06
I_0_34_26 GND Node0_34_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_26_1 Node0_34_26 Node0_34_27 77.0
R_0_34_26_2 Node0_34_26 Node0_35_26 77.0
R_0_34_26_3 Node0_34_26 Node1_34_26 12.320000000000002
C_0_34_26 Node0_34_26 GND 3.609375e-06
I_0_34_27 GND Node0_34_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_27_1 Node0_34_27 Node0_34_28 77.0
R_0_34_27_2 Node0_34_27 Node0_35_27 77.0
R_0_34_27_3 Node0_34_27 Node1_34_27 12.320000000000002
C_0_34_27 Node0_34_27 GND 3.609375e-06
I_0_34_28 GND Node0_34_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_28_1 Node0_34_28 Node0_34_29 77.0
R_0_34_28_2 Node0_34_28 Node0_35_28 77.0
R_0_34_28_3 Node0_34_28 Node1_34_28 12.320000000000002
C_0_34_28 Node0_34_28 GND 3.609375e-06
I_0_34_29 GND Node0_34_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_29_1 Node0_34_29 Node0_34_30 77.0
R_0_34_29_2 Node0_34_29 Node0_35_29 77.0
R_0_34_29_3 Node0_34_29 Node1_34_29 12.320000000000002
C_0_34_29 Node0_34_29 GND 3.609375e-06
I_0_34_30 GND Node0_34_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_30_1 Node0_34_30 Node0_34_31 77.0
R_0_34_30_2 Node0_34_30 Node0_35_30 77.0
R_0_34_30_3 Node0_34_30 Node1_34_30 12.320000000000002
C_0_34_30 Node0_34_30 GND 3.609375e-06
I_0_34_31 GND Node0_34_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_31_1 Node0_34_31 Node0_34_32 77.0
R_0_34_31_2 Node0_34_31 Node0_35_31 77.0
R_0_34_31_3 Node0_34_31 Node1_34_31 12.320000000000002
C_0_34_31 Node0_34_31 GND 3.609375e-06
I_0_34_32 GND Node0_34_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_32_1 Node0_34_32 Node0_34_33 77.0
R_0_34_32_2 Node0_34_32 Node0_35_32 77.0
R_0_34_32_3 Node0_34_32 Node1_34_32 12.320000000000002
C_0_34_32 Node0_34_32 GND 3.609375e-06
I_0_34_33 GND Node0_34_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_33_1 Node0_34_33 Node0_34_34 77.0
R_0_34_33_2 Node0_34_33 Node0_35_33 77.0
R_0_34_33_3 Node0_34_33 Node1_34_33 12.320000000000002
C_0_34_33 Node0_34_33 GND 3.609375e-06
I_0_34_34 GND Node0_34_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_34_1 Node0_34_34 Node0_34_35 77.0
R_0_34_34_2 Node0_34_34 Node0_35_34 77.0
R_0_34_34_3 Node0_34_34 Node1_34_34 12.320000000000002
C_0_34_34 Node0_34_34 GND 3.609375e-06
I_0_34_35 GND Node0_34_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_35_1 Node0_34_35 Node0_34_36 77.0
R_0_34_35_2 Node0_34_35 Node0_35_35 77.0
R_0_34_35_3 Node0_34_35 Node1_34_35 12.320000000000002
C_0_34_35 Node0_34_35 GND 3.609375e-06
I_0_34_36 GND Node0_34_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_36_1 Node0_34_36 Node0_34_37 77.0
R_0_34_36_2 Node0_34_36 Node0_35_36 77.0
R_0_34_36_3 Node0_34_36 Node1_34_36 12.320000000000002
C_0_34_36 Node0_34_36 GND 3.609375e-06
I_0_34_37 GND Node0_34_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_37_1 Node0_34_37 Node0_34_38 77.0
R_0_34_37_2 Node0_34_37 Node0_35_37 77.0
R_0_34_37_3 Node0_34_37 Node1_34_37 12.320000000000002
C_0_34_37 Node0_34_37 GND 3.609375e-06
I_0_34_38 GND Node0_34_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_38_1 Node0_34_38 Node0_34_39 77.0
R_0_34_38_2 Node0_34_38 Node0_35_38 77.0
R_0_34_38_3 Node0_34_38 Node1_34_38 12.320000000000002
C_0_34_38 Node0_34_38 GND 3.609375e-06
I_0_34_39 GND Node0_34_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_34_39_2 Node0_34_39 Node0_35_39 77.0
R_0_34_39_3 Node0_34_39 Node1_34_39 12.320000000000002
C_0_34_39 Node0_34_39 GND 3.609375e-06
I_0_35_0 GND Node0_35_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_0_1 Node0_35_0 Node0_35_1 77.0
R_0_35_0_2 Node0_35_0 Node0_36_0 77.0
R_0_35_0_3 Node0_35_0 Node1_35_0 12.320000000000002
C_0_35_0 Node0_35_0 GND 3.609375e-06
I_0_35_1 GND Node0_35_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_1_1 Node0_35_1 Node0_35_2 77.0
R_0_35_1_2 Node0_35_1 Node0_36_1 77.0
R_0_35_1_3 Node0_35_1 Node1_35_1 12.320000000000002
C_0_35_1 Node0_35_1 GND 3.609375e-06
I_0_35_2 GND Node0_35_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_2_1 Node0_35_2 Node0_35_3 77.0
R_0_35_2_2 Node0_35_2 Node0_36_2 77.0
R_0_35_2_3 Node0_35_2 Node1_35_2 12.320000000000002
C_0_35_2 Node0_35_2 GND 3.609375e-06
I_0_35_3 GND Node0_35_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_3_1 Node0_35_3 Node0_35_4 77.0
R_0_35_3_2 Node0_35_3 Node0_36_3 77.0
R_0_35_3_3 Node0_35_3 Node1_35_3 12.320000000000002
C_0_35_3 Node0_35_3 GND 3.609375e-06
I_0_35_4 GND Node0_35_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_4_1 Node0_35_4 Node0_35_5 77.0
R_0_35_4_2 Node0_35_4 Node0_36_4 77.0
R_0_35_4_3 Node0_35_4 Node1_35_4 12.320000000000002
C_0_35_4 Node0_35_4 GND 3.609375e-06
I_0_35_5 GND Node0_35_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_5_1 Node0_35_5 Node0_35_6 77.0
R_0_35_5_2 Node0_35_5 Node0_36_5 77.0
R_0_35_5_3 Node0_35_5 Node1_35_5 12.320000000000002
C_0_35_5 Node0_35_5 GND 3.609375e-06
I_0_35_6 GND Node0_35_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_6_1 Node0_35_6 Node0_35_7 77.0
R_0_35_6_2 Node0_35_6 Node0_36_6 77.0
R_0_35_6_3 Node0_35_6 Node1_35_6 12.320000000000002
C_0_35_6 Node0_35_6 GND 3.609375e-06
I_0_35_7 GND Node0_35_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_7_1 Node0_35_7 Node0_35_8 77.0
R_0_35_7_2 Node0_35_7 Node0_36_7 77.0
R_0_35_7_3 Node0_35_7 Node1_35_7 12.320000000000002
C_0_35_7 Node0_35_7 GND 3.609375e-06
I_0_35_8 GND Node0_35_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_8_1 Node0_35_8 Node0_35_9 77.0
R_0_35_8_2 Node0_35_8 Node0_36_8 77.0
R_0_35_8_3 Node0_35_8 Node1_35_8 12.320000000000002
C_0_35_8 Node0_35_8 GND 3.609375e-06
I_0_35_9 GND Node0_35_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_9_1 Node0_35_9 Node0_35_10 77.0
R_0_35_9_2 Node0_35_9 Node0_36_9 77.0
R_0_35_9_3 Node0_35_9 Node1_35_9 12.320000000000002
C_0_35_9 Node0_35_9 GND 3.609375e-06
I_0_35_10 GND Node0_35_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_10_1 Node0_35_10 Node0_35_11 77.0
R_0_35_10_2 Node0_35_10 Node0_36_10 77.0
R_0_35_10_3 Node0_35_10 Node1_35_10 12.320000000000002
C_0_35_10 Node0_35_10 GND 3.609375e-06
I_0_35_11 GND Node0_35_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_11_1 Node0_35_11 Node0_35_12 77.0
R_0_35_11_2 Node0_35_11 Node0_36_11 77.0
R_0_35_11_3 Node0_35_11 Node1_35_11 12.320000000000002
C_0_35_11 Node0_35_11 GND 3.609375e-06
I_0_35_12 GND Node0_35_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_12_1 Node0_35_12 Node0_35_13 77.0
R_0_35_12_2 Node0_35_12 Node0_36_12 77.0
R_0_35_12_3 Node0_35_12 Node1_35_12 12.320000000000002
C_0_35_12 Node0_35_12 GND 3.609375e-06
I_0_35_13 GND Node0_35_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_13_1 Node0_35_13 Node0_35_14 77.0
R_0_35_13_2 Node0_35_13 Node0_36_13 77.0
R_0_35_13_3 Node0_35_13 Node1_35_13 12.320000000000002
C_0_35_13 Node0_35_13 GND 3.609375e-06
I_0_35_14 GND Node0_35_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_14_1 Node0_35_14 Node0_35_15 77.0
R_0_35_14_2 Node0_35_14 Node0_36_14 77.0
R_0_35_14_3 Node0_35_14 Node1_35_14 12.320000000000002
C_0_35_14 Node0_35_14 GND 3.609375e-06
I_0_35_15 GND Node0_35_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_15_1 Node0_35_15 Node0_35_16 77.0
R_0_35_15_2 Node0_35_15 Node0_36_15 77.0
R_0_35_15_3 Node0_35_15 Node1_35_15 12.320000000000002
C_0_35_15 Node0_35_15 GND 3.609375e-06
I_0_35_16 GND Node0_35_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_16_1 Node0_35_16 Node0_35_17 77.0
R_0_35_16_2 Node0_35_16 Node0_36_16 77.0
R_0_35_16_3 Node0_35_16 Node1_35_16 12.320000000000002
C_0_35_16 Node0_35_16 GND 3.609375e-06
I_0_35_17 GND Node0_35_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_17_1 Node0_35_17 Node0_35_18 77.0
R_0_35_17_2 Node0_35_17 Node0_36_17 77.0
R_0_35_17_3 Node0_35_17 Node1_35_17 12.320000000000002
C_0_35_17 Node0_35_17 GND 3.609375e-06
I_0_35_18 GND Node0_35_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_18_1 Node0_35_18 Node0_35_19 77.0
R_0_35_18_2 Node0_35_18 Node0_36_18 77.0
R_0_35_18_3 Node0_35_18 Node1_35_18 12.320000000000002
C_0_35_18 Node0_35_18 GND 3.609375e-06
I_0_35_19 GND Node0_35_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_19_1 Node0_35_19 Node0_35_20 77.0
R_0_35_19_2 Node0_35_19 Node0_36_19 77.0
R_0_35_19_3 Node0_35_19 Node1_35_19 12.320000000000002
C_0_35_19 Node0_35_19 GND 3.609375e-06
I_0_35_20 GND Node0_35_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_20_1 Node0_35_20 Node0_35_21 77.0
R_0_35_20_2 Node0_35_20 Node0_36_20 77.0
R_0_35_20_3 Node0_35_20 Node1_35_20 12.320000000000002
C_0_35_20 Node0_35_20 GND 3.609375e-06
I_0_35_21 GND Node0_35_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_21_1 Node0_35_21 Node0_35_22 77.0
R_0_35_21_2 Node0_35_21 Node0_36_21 77.0
R_0_35_21_3 Node0_35_21 Node1_35_21 12.320000000000002
C_0_35_21 Node0_35_21 GND 3.609375e-06
I_0_35_22 GND Node0_35_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_22_1 Node0_35_22 Node0_35_23 77.0
R_0_35_22_2 Node0_35_22 Node0_36_22 77.0
R_0_35_22_3 Node0_35_22 Node1_35_22 12.320000000000002
C_0_35_22 Node0_35_22 GND 3.609375e-06
I_0_35_23 GND Node0_35_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_23_1 Node0_35_23 Node0_35_24 77.0
R_0_35_23_2 Node0_35_23 Node0_36_23 77.0
R_0_35_23_3 Node0_35_23 Node1_35_23 12.320000000000002
C_0_35_23 Node0_35_23 GND 3.609375e-06
I_0_35_24 GND Node0_35_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_24_1 Node0_35_24 Node0_35_25 77.0
R_0_35_24_2 Node0_35_24 Node0_36_24 77.0
R_0_35_24_3 Node0_35_24 Node1_35_24 12.320000000000002
C_0_35_24 Node0_35_24 GND 3.609375e-06
I_0_35_25 GND Node0_35_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_25_1 Node0_35_25 Node0_35_26 77.0
R_0_35_25_2 Node0_35_25 Node0_36_25 77.0
R_0_35_25_3 Node0_35_25 Node1_35_25 12.320000000000002
C_0_35_25 Node0_35_25 GND 3.609375e-06
I_0_35_26 GND Node0_35_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_26_1 Node0_35_26 Node0_35_27 77.0
R_0_35_26_2 Node0_35_26 Node0_36_26 77.0
R_0_35_26_3 Node0_35_26 Node1_35_26 12.320000000000002
C_0_35_26 Node0_35_26 GND 3.609375e-06
I_0_35_27 GND Node0_35_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_27_1 Node0_35_27 Node0_35_28 77.0
R_0_35_27_2 Node0_35_27 Node0_36_27 77.0
R_0_35_27_3 Node0_35_27 Node1_35_27 12.320000000000002
C_0_35_27 Node0_35_27 GND 3.609375e-06
I_0_35_28 GND Node0_35_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_28_1 Node0_35_28 Node0_35_29 77.0
R_0_35_28_2 Node0_35_28 Node0_36_28 77.0
R_0_35_28_3 Node0_35_28 Node1_35_28 12.320000000000002
C_0_35_28 Node0_35_28 GND 3.609375e-06
I_0_35_29 GND Node0_35_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_29_1 Node0_35_29 Node0_35_30 77.0
R_0_35_29_2 Node0_35_29 Node0_36_29 77.0
R_0_35_29_3 Node0_35_29 Node1_35_29 12.320000000000002
C_0_35_29 Node0_35_29 GND 3.609375e-06
I_0_35_30 GND Node0_35_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_30_1 Node0_35_30 Node0_35_31 77.0
R_0_35_30_2 Node0_35_30 Node0_36_30 77.0
R_0_35_30_3 Node0_35_30 Node1_35_30 12.320000000000002
C_0_35_30 Node0_35_30 GND 3.609375e-06
I_0_35_31 GND Node0_35_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_31_1 Node0_35_31 Node0_35_32 77.0
R_0_35_31_2 Node0_35_31 Node0_36_31 77.0
R_0_35_31_3 Node0_35_31 Node1_35_31 12.320000000000002
C_0_35_31 Node0_35_31 GND 3.609375e-06
I_0_35_32 GND Node0_35_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_32_1 Node0_35_32 Node0_35_33 77.0
R_0_35_32_2 Node0_35_32 Node0_36_32 77.0
R_0_35_32_3 Node0_35_32 Node1_35_32 12.320000000000002
C_0_35_32 Node0_35_32 GND 3.609375e-06
I_0_35_33 GND Node0_35_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_33_1 Node0_35_33 Node0_35_34 77.0
R_0_35_33_2 Node0_35_33 Node0_36_33 77.0
R_0_35_33_3 Node0_35_33 Node1_35_33 12.320000000000002
C_0_35_33 Node0_35_33 GND 3.609375e-06
I_0_35_34 GND Node0_35_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_34_1 Node0_35_34 Node0_35_35 77.0
R_0_35_34_2 Node0_35_34 Node0_36_34 77.0
R_0_35_34_3 Node0_35_34 Node1_35_34 12.320000000000002
C_0_35_34 Node0_35_34 GND 3.609375e-06
I_0_35_35 GND Node0_35_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_35_1 Node0_35_35 Node0_35_36 77.0
R_0_35_35_2 Node0_35_35 Node0_36_35 77.0
R_0_35_35_3 Node0_35_35 Node1_35_35 12.320000000000002
C_0_35_35 Node0_35_35 GND 3.609375e-06
I_0_35_36 GND Node0_35_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_36_1 Node0_35_36 Node0_35_37 77.0
R_0_35_36_2 Node0_35_36 Node0_36_36 77.0
R_0_35_36_3 Node0_35_36 Node1_35_36 12.320000000000002
C_0_35_36 Node0_35_36 GND 3.609375e-06
I_0_35_37 GND Node0_35_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_37_1 Node0_35_37 Node0_35_38 77.0
R_0_35_37_2 Node0_35_37 Node0_36_37 77.0
R_0_35_37_3 Node0_35_37 Node1_35_37 12.320000000000002
C_0_35_37 Node0_35_37 GND 3.609375e-06
I_0_35_38 GND Node0_35_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_38_1 Node0_35_38 Node0_35_39 77.0
R_0_35_38_2 Node0_35_38 Node0_36_38 77.0
R_0_35_38_3 Node0_35_38 Node1_35_38 12.320000000000002
C_0_35_38 Node0_35_38 GND 3.609375e-06
I_0_35_39 GND Node0_35_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_35_39_2 Node0_35_39 Node0_36_39 77.0
R_0_35_39_3 Node0_35_39 Node1_35_39 12.320000000000002
C_0_35_39 Node0_35_39 GND 3.609375e-06
I_0_36_0 GND Node0_36_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_0_1 Node0_36_0 Node0_36_1 77.0
R_0_36_0_2 Node0_36_0 Node0_37_0 77.0
R_0_36_0_3 Node0_36_0 Node1_36_0 12.320000000000002
C_0_36_0 Node0_36_0 GND 3.609375e-06
I_0_36_1 GND Node0_36_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_1_1 Node0_36_1 Node0_36_2 77.0
R_0_36_1_2 Node0_36_1 Node0_37_1 77.0
R_0_36_1_3 Node0_36_1 Node1_36_1 12.320000000000002
C_0_36_1 Node0_36_1 GND 3.609375e-06
I_0_36_2 GND Node0_36_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_2_1 Node0_36_2 Node0_36_3 77.0
R_0_36_2_2 Node0_36_2 Node0_37_2 77.0
R_0_36_2_3 Node0_36_2 Node1_36_2 12.320000000000002
C_0_36_2 Node0_36_2 GND 3.609375e-06
I_0_36_3 GND Node0_36_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_3_1 Node0_36_3 Node0_36_4 77.0
R_0_36_3_2 Node0_36_3 Node0_37_3 77.0
R_0_36_3_3 Node0_36_3 Node1_36_3 12.320000000000002
C_0_36_3 Node0_36_3 GND 3.609375e-06
I_0_36_4 GND Node0_36_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_4_1 Node0_36_4 Node0_36_5 77.0
R_0_36_4_2 Node0_36_4 Node0_37_4 77.0
R_0_36_4_3 Node0_36_4 Node1_36_4 12.320000000000002
C_0_36_4 Node0_36_4 GND 3.609375e-06
I_0_36_5 GND Node0_36_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_5_1 Node0_36_5 Node0_36_6 77.0
R_0_36_5_2 Node0_36_5 Node0_37_5 77.0
R_0_36_5_3 Node0_36_5 Node1_36_5 12.320000000000002
C_0_36_5 Node0_36_5 GND 3.609375e-06
I_0_36_6 GND Node0_36_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_6_1 Node0_36_6 Node0_36_7 77.0
R_0_36_6_2 Node0_36_6 Node0_37_6 77.0
R_0_36_6_3 Node0_36_6 Node1_36_6 12.320000000000002
C_0_36_6 Node0_36_6 GND 3.609375e-06
I_0_36_7 GND Node0_36_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_7_1 Node0_36_7 Node0_36_8 77.0
R_0_36_7_2 Node0_36_7 Node0_37_7 77.0
R_0_36_7_3 Node0_36_7 Node1_36_7 12.320000000000002
C_0_36_7 Node0_36_7 GND 3.609375e-06
I_0_36_8 GND Node0_36_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_8_1 Node0_36_8 Node0_36_9 77.0
R_0_36_8_2 Node0_36_8 Node0_37_8 77.0
R_0_36_8_3 Node0_36_8 Node1_36_8 12.320000000000002
C_0_36_8 Node0_36_8 GND 3.609375e-06
I_0_36_9 GND Node0_36_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_9_1 Node0_36_9 Node0_36_10 77.0
R_0_36_9_2 Node0_36_9 Node0_37_9 77.0
R_0_36_9_3 Node0_36_9 Node1_36_9 12.320000000000002
C_0_36_9 Node0_36_9 GND 3.609375e-06
I_0_36_10 GND Node0_36_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_10_1 Node0_36_10 Node0_36_11 77.0
R_0_36_10_2 Node0_36_10 Node0_37_10 77.0
R_0_36_10_3 Node0_36_10 Node1_36_10 12.320000000000002
C_0_36_10 Node0_36_10 GND 3.609375e-06
I_0_36_11 GND Node0_36_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_11_1 Node0_36_11 Node0_36_12 77.0
R_0_36_11_2 Node0_36_11 Node0_37_11 77.0
R_0_36_11_3 Node0_36_11 Node1_36_11 12.320000000000002
C_0_36_11 Node0_36_11 GND 3.609375e-06
I_0_36_12 GND Node0_36_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_12_1 Node0_36_12 Node0_36_13 77.0
R_0_36_12_2 Node0_36_12 Node0_37_12 77.0
R_0_36_12_3 Node0_36_12 Node1_36_12 12.320000000000002
C_0_36_12 Node0_36_12 GND 3.609375e-06
I_0_36_13 GND Node0_36_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_13_1 Node0_36_13 Node0_36_14 77.0
R_0_36_13_2 Node0_36_13 Node0_37_13 77.0
R_0_36_13_3 Node0_36_13 Node1_36_13 12.320000000000002
C_0_36_13 Node0_36_13 GND 3.609375e-06
I_0_36_14 GND Node0_36_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_14_1 Node0_36_14 Node0_36_15 77.0
R_0_36_14_2 Node0_36_14 Node0_37_14 77.0
R_0_36_14_3 Node0_36_14 Node1_36_14 12.320000000000002
C_0_36_14 Node0_36_14 GND 3.609375e-06
I_0_36_15 GND Node0_36_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_15_1 Node0_36_15 Node0_36_16 77.0
R_0_36_15_2 Node0_36_15 Node0_37_15 77.0
R_0_36_15_3 Node0_36_15 Node1_36_15 12.320000000000002
C_0_36_15 Node0_36_15 GND 3.609375e-06
I_0_36_16 GND Node0_36_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_16_1 Node0_36_16 Node0_36_17 77.0
R_0_36_16_2 Node0_36_16 Node0_37_16 77.0
R_0_36_16_3 Node0_36_16 Node1_36_16 12.320000000000002
C_0_36_16 Node0_36_16 GND 3.609375e-06
I_0_36_17 GND Node0_36_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_17_1 Node0_36_17 Node0_36_18 77.0
R_0_36_17_2 Node0_36_17 Node0_37_17 77.0
R_0_36_17_3 Node0_36_17 Node1_36_17 12.320000000000002
C_0_36_17 Node0_36_17 GND 3.609375e-06
I_0_36_18 GND Node0_36_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_18_1 Node0_36_18 Node0_36_19 77.0
R_0_36_18_2 Node0_36_18 Node0_37_18 77.0
R_0_36_18_3 Node0_36_18 Node1_36_18 12.320000000000002
C_0_36_18 Node0_36_18 GND 3.609375e-06
I_0_36_19 GND Node0_36_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_19_1 Node0_36_19 Node0_36_20 77.0
R_0_36_19_2 Node0_36_19 Node0_37_19 77.0
R_0_36_19_3 Node0_36_19 Node1_36_19 12.320000000000002
C_0_36_19 Node0_36_19 GND 3.609375e-06
I_0_36_20 GND Node0_36_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_20_1 Node0_36_20 Node0_36_21 77.0
R_0_36_20_2 Node0_36_20 Node0_37_20 77.0
R_0_36_20_3 Node0_36_20 Node1_36_20 12.320000000000002
C_0_36_20 Node0_36_20 GND 3.609375e-06
I_0_36_21 GND Node0_36_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_21_1 Node0_36_21 Node0_36_22 77.0
R_0_36_21_2 Node0_36_21 Node0_37_21 77.0
R_0_36_21_3 Node0_36_21 Node1_36_21 12.320000000000002
C_0_36_21 Node0_36_21 GND 3.609375e-06
I_0_36_22 GND Node0_36_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_22_1 Node0_36_22 Node0_36_23 77.0
R_0_36_22_2 Node0_36_22 Node0_37_22 77.0
R_0_36_22_3 Node0_36_22 Node1_36_22 12.320000000000002
C_0_36_22 Node0_36_22 GND 3.609375e-06
I_0_36_23 GND Node0_36_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_23_1 Node0_36_23 Node0_36_24 77.0
R_0_36_23_2 Node0_36_23 Node0_37_23 77.0
R_0_36_23_3 Node0_36_23 Node1_36_23 12.320000000000002
C_0_36_23 Node0_36_23 GND 3.609375e-06
I_0_36_24 GND Node0_36_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_24_1 Node0_36_24 Node0_36_25 77.0
R_0_36_24_2 Node0_36_24 Node0_37_24 77.0
R_0_36_24_3 Node0_36_24 Node1_36_24 12.320000000000002
C_0_36_24 Node0_36_24 GND 3.609375e-06
I_0_36_25 GND Node0_36_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_25_1 Node0_36_25 Node0_36_26 77.0
R_0_36_25_2 Node0_36_25 Node0_37_25 77.0
R_0_36_25_3 Node0_36_25 Node1_36_25 12.320000000000002
C_0_36_25 Node0_36_25 GND 3.609375e-06
I_0_36_26 GND Node0_36_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_26_1 Node0_36_26 Node0_36_27 77.0
R_0_36_26_2 Node0_36_26 Node0_37_26 77.0
R_0_36_26_3 Node0_36_26 Node1_36_26 12.320000000000002
C_0_36_26 Node0_36_26 GND 3.609375e-06
I_0_36_27 GND Node0_36_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_27_1 Node0_36_27 Node0_36_28 77.0
R_0_36_27_2 Node0_36_27 Node0_37_27 77.0
R_0_36_27_3 Node0_36_27 Node1_36_27 12.320000000000002
C_0_36_27 Node0_36_27 GND 3.609375e-06
I_0_36_28 GND Node0_36_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_28_1 Node0_36_28 Node0_36_29 77.0
R_0_36_28_2 Node0_36_28 Node0_37_28 77.0
R_0_36_28_3 Node0_36_28 Node1_36_28 12.320000000000002
C_0_36_28 Node0_36_28 GND 3.609375e-06
I_0_36_29 GND Node0_36_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_29_1 Node0_36_29 Node0_36_30 77.0
R_0_36_29_2 Node0_36_29 Node0_37_29 77.0
R_0_36_29_3 Node0_36_29 Node1_36_29 12.320000000000002
C_0_36_29 Node0_36_29 GND 3.609375e-06
I_0_36_30 GND Node0_36_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_30_1 Node0_36_30 Node0_36_31 77.0
R_0_36_30_2 Node0_36_30 Node0_37_30 77.0
R_0_36_30_3 Node0_36_30 Node1_36_30 12.320000000000002
C_0_36_30 Node0_36_30 GND 3.609375e-06
I_0_36_31 GND Node0_36_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_31_1 Node0_36_31 Node0_36_32 77.0
R_0_36_31_2 Node0_36_31 Node0_37_31 77.0
R_0_36_31_3 Node0_36_31 Node1_36_31 12.320000000000002
C_0_36_31 Node0_36_31 GND 3.609375e-06
I_0_36_32 GND Node0_36_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_32_1 Node0_36_32 Node0_36_33 77.0
R_0_36_32_2 Node0_36_32 Node0_37_32 77.0
R_0_36_32_3 Node0_36_32 Node1_36_32 12.320000000000002
C_0_36_32 Node0_36_32 GND 3.609375e-06
I_0_36_33 GND Node0_36_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_33_1 Node0_36_33 Node0_36_34 77.0
R_0_36_33_2 Node0_36_33 Node0_37_33 77.0
R_0_36_33_3 Node0_36_33 Node1_36_33 12.320000000000002
C_0_36_33 Node0_36_33 GND 3.609375e-06
I_0_36_34 GND Node0_36_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_34_1 Node0_36_34 Node0_36_35 77.0
R_0_36_34_2 Node0_36_34 Node0_37_34 77.0
R_0_36_34_3 Node0_36_34 Node1_36_34 12.320000000000002
C_0_36_34 Node0_36_34 GND 3.609375e-06
I_0_36_35 GND Node0_36_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_35_1 Node0_36_35 Node0_36_36 77.0
R_0_36_35_2 Node0_36_35 Node0_37_35 77.0
R_0_36_35_3 Node0_36_35 Node1_36_35 12.320000000000002
C_0_36_35 Node0_36_35 GND 3.609375e-06
I_0_36_36 GND Node0_36_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_36_1 Node0_36_36 Node0_36_37 77.0
R_0_36_36_2 Node0_36_36 Node0_37_36 77.0
R_0_36_36_3 Node0_36_36 Node1_36_36 12.320000000000002
C_0_36_36 Node0_36_36 GND 3.609375e-06
I_0_36_37 GND Node0_36_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_37_1 Node0_36_37 Node0_36_38 77.0
R_0_36_37_2 Node0_36_37 Node0_37_37 77.0
R_0_36_37_3 Node0_36_37 Node1_36_37 12.320000000000002
C_0_36_37 Node0_36_37 GND 3.609375e-06
I_0_36_38 GND Node0_36_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_38_1 Node0_36_38 Node0_36_39 77.0
R_0_36_38_2 Node0_36_38 Node0_37_38 77.0
R_0_36_38_3 Node0_36_38 Node1_36_38 12.320000000000002
C_0_36_38 Node0_36_38 GND 3.609375e-06
I_0_36_39 GND Node0_36_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_36_39_2 Node0_36_39 Node0_37_39 77.0
R_0_36_39_3 Node0_36_39 Node1_36_39 12.320000000000002
C_0_36_39 Node0_36_39 GND 3.609375e-06
I_0_37_0 GND Node0_37_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_0_1 Node0_37_0 Node0_37_1 77.0
R_0_37_0_2 Node0_37_0 Node0_38_0 77.0
R_0_37_0_3 Node0_37_0 Node1_37_0 12.320000000000002
C_0_37_0 Node0_37_0 GND 3.609375e-06
I_0_37_1 GND Node0_37_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_1_1 Node0_37_1 Node0_37_2 77.0
R_0_37_1_2 Node0_37_1 Node0_38_1 77.0
R_0_37_1_3 Node0_37_1 Node1_37_1 12.320000000000002
C_0_37_1 Node0_37_1 GND 3.609375e-06
I_0_37_2 GND Node0_37_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_2_1 Node0_37_2 Node0_37_3 77.0
R_0_37_2_2 Node0_37_2 Node0_38_2 77.0
R_0_37_2_3 Node0_37_2 Node1_37_2 12.320000000000002
C_0_37_2 Node0_37_2 GND 3.609375e-06
I_0_37_3 GND Node0_37_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_3_1 Node0_37_3 Node0_37_4 77.0
R_0_37_3_2 Node0_37_3 Node0_38_3 77.0
R_0_37_3_3 Node0_37_3 Node1_37_3 12.320000000000002
C_0_37_3 Node0_37_3 GND 3.609375e-06
I_0_37_4 GND Node0_37_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_4_1 Node0_37_4 Node0_37_5 77.0
R_0_37_4_2 Node0_37_4 Node0_38_4 77.0
R_0_37_4_3 Node0_37_4 Node1_37_4 12.320000000000002
C_0_37_4 Node0_37_4 GND 3.609375e-06
I_0_37_5 GND Node0_37_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_5_1 Node0_37_5 Node0_37_6 77.0
R_0_37_5_2 Node0_37_5 Node0_38_5 77.0
R_0_37_5_3 Node0_37_5 Node1_37_5 12.320000000000002
C_0_37_5 Node0_37_5 GND 3.609375e-06
I_0_37_6 GND Node0_37_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_6_1 Node0_37_6 Node0_37_7 77.0
R_0_37_6_2 Node0_37_6 Node0_38_6 77.0
R_0_37_6_3 Node0_37_6 Node1_37_6 12.320000000000002
C_0_37_6 Node0_37_6 GND 3.609375e-06
I_0_37_7 GND Node0_37_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_7_1 Node0_37_7 Node0_37_8 77.0
R_0_37_7_2 Node0_37_7 Node0_38_7 77.0
R_0_37_7_3 Node0_37_7 Node1_37_7 12.320000000000002
C_0_37_7 Node0_37_7 GND 3.609375e-06
I_0_37_8 GND Node0_37_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_8_1 Node0_37_8 Node0_37_9 77.0
R_0_37_8_2 Node0_37_8 Node0_38_8 77.0
R_0_37_8_3 Node0_37_8 Node1_37_8 12.320000000000002
C_0_37_8 Node0_37_8 GND 3.609375e-06
I_0_37_9 GND Node0_37_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_9_1 Node0_37_9 Node0_37_10 77.0
R_0_37_9_2 Node0_37_9 Node0_38_9 77.0
R_0_37_9_3 Node0_37_9 Node1_37_9 12.320000000000002
C_0_37_9 Node0_37_9 GND 3.609375e-06
I_0_37_10 GND Node0_37_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_10_1 Node0_37_10 Node0_37_11 77.0
R_0_37_10_2 Node0_37_10 Node0_38_10 77.0
R_0_37_10_3 Node0_37_10 Node1_37_10 12.320000000000002
C_0_37_10 Node0_37_10 GND 3.609375e-06
I_0_37_11 GND Node0_37_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_11_1 Node0_37_11 Node0_37_12 77.0
R_0_37_11_2 Node0_37_11 Node0_38_11 77.0
R_0_37_11_3 Node0_37_11 Node1_37_11 12.320000000000002
C_0_37_11 Node0_37_11 GND 3.609375e-06
I_0_37_12 GND Node0_37_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_12_1 Node0_37_12 Node0_37_13 77.0
R_0_37_12_2 Node0_37_12 Node0_38_12 77.0
R_0_37_12_3 Node0_37_12 Node1_37_12 12.320000000000002
C_0_37_12 Node0_37_12 GND 3.609375e-06
I_0_37_13 GND Node0_37_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_13_1 Node0_37_13 Node0_37_14 77.0
R_0_37_13_2 Node0_37_13 Node0_38_13 77.0
R_0_37_13_3 Node0_37_13 Node1_37_13 12.320000000000002
C_0_37_13 Node0_37_13 GND 3.609375e-06
I_0_37_14 GND Node0_37_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_14_1 Node0_37_14 Node0_37_15 77.0
R_0_37_14_2 Node0_37_14 Node0_38_14 77.0
R_0_37_14_3 Node0_37_14 Node1_37_14 12.320000000000002
C_0_37_14 Node0_37_14 GND 3.609375e-06
I_0_37_15 GND Node0_37_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_15_1 Node0_37_15 Node0_37_16 77.0
R_0_37_15_2 Node0_37_15 Node0_38_15 77.0
R_0_37_15_3 Node0_37_15 Node1_37_15 12.320000000000002
C_0_37_15 Node0_37_15 GND 3.609375e-06
I_0_37_16 GND Node0_37_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_16_1 Node0_37_16 Node0_37_17 77.0
R_0_37_16_2 Node0_37_16 Node0_38_16 77.0
R_0_37_16_3 Node0_37_16 Node1_37_16 12.320000000000002
C_0_37_16 Node0_37_16 GND 3.609375e-06
I_0_37_17 GND Node0_37_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_17_1 Node0_37_17 Node0_37_18 77.0
R_0_37_17_2 Node0_37_17 Node0_38_17 77.0
R_0_37_17_3 Node0_37_17 Node1_37_17 12.320000000000002
C_0_37_17 Node0_37_17 GND 3.609375e-06
I_0_37_18 GND Node0_37_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_18_1 Node0_37_18 Node0_37_19 77.0
R_0_37_18_2 Node0_37_18 Node0_38_18 77.0
R_0_37_18_3 Node0_37_18 Node1_37_18 12.320000000000002
C_0_37_18 Node0_37_18 GND 3.609375e-06
I_0_37_19 GND Node0_37_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_19_1 Node0_37_19 Node0_37_20 77.0
R_0_37_19_2 Node0_37_19 Node0_38_19 77.0
R_0_37_19_3 Node0_37_19 Node1_37_19 12.320000000000002
C_0_37_19 Node0_37_19 GND 3.609375e-06
I_0_37_20 GND Node0_37_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_20_1 Node0_37_20 Node0_37_21 77.0
R_0_37_20_2 Node0_37_20 Node0_38_20 77.0
R_0_37_20_3 Node0_37_20 Node1_37_20 12.320000000000002
C_0_37_20 Node0_37_20 GND 3.609375e-06
I_0_37_21 GND Node0_37_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_21_1 Node0_37_21 Node0_37_22 77.0
R_0_37_21_2 Node0_37_21 Node0_38_21 77.0
R_0_37_21_3 Node0_37_21 Node1_37_21 12.320000000000002
C_0_37_21 Node0_37_21 GND 3.609375e-06
I_0_37_22 GND Node0_37_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_22_1 Node0_37_22 Node0_37_23 77.0
R_0_37_22_2 Node0_37_22 Node0_38_22 77.0
R_0_37_22_3 Node0_37_22 Node1_37_22 12.320000000000002
C_0_37_22 Node0_37_22 GND 3.609375e-06
I_0_37_23 GND Node0_37_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_23_1 Node0_37_23 Node0_37_24 77.0
R_0_37_23_2 Node0_37_23 Node0_38_23 77.0
R_0_37_23_3 Node0_37_23 Node1_37_23 12.320000000000002
C_0_37_23 Node0_37_23 GND 3.609375e-06
I_0_37_24 GND Node0_37_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_24_1 Node0_37_24 Node0_37_25 77.0
R_0_37_24_2 Node0_37_24 Node0_38_24 77.0
R_0_37_24_3 Node0_37_24 Node1_37_24 12.320000000000002
C_0_37_24 Node0_37_24 GND 3.609375e-06
I_0_37_25 GND Node0_37_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_25_1 Node0_37_25 Node0_37_26 77.0
R_0_37_25_2 Node0_37_25 Node0_38_25 77.0
R_0_37_25_3 Node0_37_25 Node1_37_25 12.320000000000002
C_0_37_25 Node0_37_25 GND 3.609375e-06
I_0_37_26 GND Node0_37_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_26_1 Node0_37_26 Node0_37_27 77.0
R_0_37_26_2 Node0_37_26 Node0_38_26 77.0
R_0_37_26_3 Node0_37_26 Node1_37_26 12.320000000000002
C_0_37_26 Node0_37_26 GND 3.609375e-06
I_0_37_27 GND Node0_37_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_27_1 Node0_37_27 Node0_37_28 77.0
R_0_37_27_2 Node0_37_27 Node0_38_27 77.0
R_0_37_27_3 Node0_37_27 Node1_37_27 12.320000000000002
C_0_37_27 Node0_37_27 GND 3.609375e-06
I_0_37_28 GND Node0_37_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_28_1 Node0_37_28 Node0_37_29 77.0
R_0_37_28_2 Node0_37_28 Node0_38_28 77.0
R_0_37_28_3 Node0_37_28 Node1_37_28 12.320000000000002
C_0_37_28 Node0_37_28 GND 3.609375e-06
I_0_37_29 GND Node0_37_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_29_1 Node0_37_29 Node0_37_30 77.0
R_0_37_29_2 Node0_37_29 Node0_38_29 77.0
R_0_37_29_3 Node0_37_29 Node1_37_29 12.320000000000002
C_0_37_29 Node0_37_29 GND 3.609375e-06
I_0_37_30 GND Node0_37_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_30_1 Node0_37_30 Node0_37_31 77.0
R_0_37_30_2 Node0_37_30 Node0_38_30 77.0
R_0_37_30_3 Node0_37_30 Node1_37_30 12.320000000000002
C_0_37_30 Node0_37_30 GND 3.609375e-06
I_0_37_31 GND Node0_37_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_31_1 Node0_37_31 Node0_37_32 77.0
R_0_37_31_2 Node0_37_31 Node0_38_31 77.0
R_0_37_31_3 Node0_37_31 Node1_37_31 12.320000000000002
C_0_37_31 Node0_37_31 GND 3.609375e-06
I_0_37_32 GND Node0_37_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_32_1 Node0_37_32 Node0_37_33 77.0
R_0_37_32_2 Node0_37_32 Node0_38_32 77.0
R_0_37_32_3 Node0_37_32 Node1_37_32 12.320000000000002
C_0_37_32 Node0_37_32 GND 3.609375e-06
I_0_37_33 GND Node0_37_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_33_1 Node0_37_33 Node0_37_34 77.0
R_0_37_33_2 Node0_37_33 Node0_38_33 77.0
R_0_37_33_3 Node0_37_33 Node1_37_33 12.320000000000002
C_0_37_33 Node0_37_33 GND 3.609375e-06
I_0_37_34 GND Node0_37_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_34_1 Node0_37_34 Node0_37_35 77.0
R_0_37_34_2 Node0_37_34 Node0_38_34 77.0
R_0_37_34_3 Node0_37_34 Node1_37_34 12.320000000000002
C_0_37_34 Node0_37_34 GND 3.609375e-06
I_0_37_35 GND Node0_37_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_35_1 Node0_37_35 Node0_37_36 77.0
R_0_37_35_2 Node0_37_35 Node0_38_35 77.0
R_0_37_35_3 Node0_37_35 Node1_37_35 12.320000000000002
C_0_37_35 Node0_37_35 GND 3.609375e-06
I_0_37_36 GND Node0_37_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_36_1 Node0_37_36 Node0_37_37 77.0
R_0_37_36_2 Node0_37_36 Node0_38_36 77.0
R_0_37_36_3 Node0_37_36 Node1_37_36 12.320000000000002
C_0_37_36 Node0_37_36 GND 3.609375e-06
I_0_37_37 GND Node0_37_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_37_1 Node0_37_37 Node0_37_38 77.0
R_0_37_37_2 Node0_37_37 Node0_38_37 77.0
R_0_37_37_3 Node0_37_37 Node1_37_37 12.320000000000002
C_0_37_37 Node0_37_37 GND 3.609375e-06
I_0_37_38 GND Node0_37_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_38_1 Node0_37_38 Node0_37_39 77.0
R_0_37_38_2 Node0_37_38 Node0_38_38 77.0
R_0_37_38_3 Node0_37_38 Node1_37_38 12.320000000000002
C_0_37_38 Node0_37_38 GND 3.609375e-06
I_0_37_39 GND Node0_37_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_37_39_2 Node0_37_39 Node0_38_39 77.0
R_0_37_39_3 Node0_37_39 Node1_37_39 12.320000000000002
C_0_37_39 Node0_37_39 GND 3.609375e-06
I_0_38_0 GND Node0_38_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_0_1 Node0_38_0 Node0_38_1 77.0
R_0_38_0_2 Node0_38_0 Node0_39_0 77.0
R_0_38_0_3 Node0_38_0 Node1_38_0 12.320000000000002
C_0_38_0 Node0_38_0 GND 3.609375e-06
I_0_38_1 GND Node0_38_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_1_1 Node0_38_1 Node0_38_2 77.0
R_0_38_1_2 Node0_38_1 Node0_39_1 77.0
R_0_38_1_3 Node0_38_1 Node1_38_1 12.320000000000002
C_0_38_1 Node0_38_1 GND 3.609375e-06
I_0_38_2 GND Node0_38_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_2_1 Node0_38_2 Node0_38_3 77.0
R_0_38_2_2 Node0_38_2 Node0_39_2 77.0
R_0_38_2_3 Node0_38_2 Node1_38_2 12.320000000000002
C_0_38_2 Node0_38_2 GND 3.609375e-06
I_0_38_3 GND Node0_38_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_3_1 Node0_38_3 Node0_38_4 77.0
R_0_38_3_2 Node0_38_3 Node0_39_3 77.0
R_0_38_3_3 Node0_38_3 Node1_38_3 12.320000000000002
C_0_38_3 Node0_38_3 GND 3.609375e-06
I_0_38_4 GND Node0_38_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_4_1 Node0_38_4 Node0_38_5 77.0
R_0_38_4_2 Node0_38_4 Node0_39_4 77.0
R_0_38_4_3 Node0_38_4 Node1_38_4 12.320000000000002
C_0_38_4 Node0_38_4 GND 3.609375e-06
I_0_38_5 GND Node0_38_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_5_1 Node0_38_5 Node0_38_6 77.0
R_0_38_5_2 Node0_38_5 Node0_39_5 77.0
R_0_38_5_3 Node0_38_5 Node1_38_5 12.320000000000002
C_0_38_5 Node0_38_5 GND 3.609375e-06
I_0_38_6 GND Node0_38_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_6_1 Node0_38_6 Node0_38_7 77.0
R_0_38_6_2 Node0_38_6 Node0_39_6 77.0
R_0_38_6_3 Node0_38_6 Node1_38_6 12.320000000000002
C_0_38_6 Node0_38_6 GND 3.609375e-06
I_0_38_7 GND Node0_38_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_7_1 Node0_38_7 Node0_38_8 77.0
R_0_38_7_2 Node0_38_7 Node0_39_7 77.0
R_0_38_7_3 Node0_38_7 Node1_38_7 12.320000000000002
C_0_38_7 Node0_38_7 GND 3.609375e-06
I_0_38_8 GND Node0_38_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_8_1 Node0_38_8 Node0_38_9 77.0
R_0_38_8_2 Node0_38_8 Node0_39_8 77.0
R_0_38_8_3 Node0_38_8 Node1_38_8 12.320000000000002
C_0_38_8 Node0_38_8 GND 3.609375e-06
I_0_38_9 GND Node0_38_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_9_1 Node0_38_9 Node0_38_10 77.0
R_0_38_9_2 Node0_38_9 Node0_39_9 77.0
R_0_38_9_3 Node0_38_9 Node1_38_9 12.320000000000002
C_0_38_9 Node0_38_9 GND 3.609375e-06
I_0_38_10 GND Node0_38_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_10_1 Node0_38_10 Node0_38_11 77.0
R_0_38_10_2 Node0_38_10 Node0_39_10 77.0
R_0_38_10_3 Node0_38_10 Node1_38_10 12.320000000000002
C_0_38_10 Node0_38_10 GND 3.609375e-06
I_0_38_11 GND Node0_38_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_11_1 Node0_38_11 Node0_38_12 77.0
R_0_38_11_2 Node0_38_11 Node0_39_11 77.0
R_0_38_11_3 Node0_38_11 Node1_38_11 12.320000000000002
C_0_38_11 Node0_38_11 GND 3.609375e-06
I_0_38_12 GND Node0_38_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_12_1 Node0_38_12 Node0_38_13 77.0
R_0_38_12_2 Node0_38_12 Node0_39_12 77.0
R_0_38_12_3 Node0_38_12 Node1_38_12 12.320000000000002
C_0_38_12 Node0_38_12 GND 3.609375e-06
I_0_38_13 GND Node0_38_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_13_1 Node0_38_13 Node0_38_14 77.0
R_0_38_13_2 Node0_38_13 Node0_39_13 77.0
R_0_38_13_3 Node0_38_13 Node1_38_13 12.320000000000002
C_0_38_13 Node0_38_13 GND 3.609375e-06
I_0_38_14 GND Node0_38_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_14_1 Node0_38_14 Node0_38_15 77.0
R_0_38_14_2 Node0_38_14 Node0_39_14 77.0
R_0_38_14_3 Node0_38_14 Node1_38_14 12.320000000000002
C_0_38_14 Node0_38_14 GND 3.609375e-06
I_0_38_15 GND Node0_38_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_15_1 Node0_38_15 Node0_38_16 77.0
R_0_38_15_2 Node0_38_15 Node0_39_15 77.0
R_0_38_15_3 Node0_38_15 Node1_38_15 12.320000000000002
C_0_38_15 Node0_38_15 GND 3.609375e-06
I_0_38_16 GND Node0_38_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_16_1 Node0_38_16 Node0_38_17 77.0
R_0_38_16_2 Node0_38_16 Node0_39_16 77.0
R_0_38_16_3 Node0_38_16 Node1_38_16 12.320000000000002
C_0_38_16 Node0_38_16 GND 3.609375e-06
I_0_38_17 GND Node0_38_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_17_1 Node0_38_17 Node0_38_18 77.0
R_0_38_17_2 Node0_38_17 Node0_39_17 77.0
R_0_38_17_3 Node0_38_17 Node1_38_17 12.320000000000002
C_0_38_17 Node0_38_17 GND 3.609375e-06
I_0_38_18 GND Node0_38_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_18_1 Node0_38_18 Node0_38_19 77.0
R_0_38_18_2 Node0_38_18 Node0_39_18 77.0
R_0_38_18_3 Node0_38_18 Node1_38_18 12.320000000000002
C_0_38_18 Node0_38_18 GND 3.609375e-06
I_0_38_19 GND Node0_38_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_19_1 Node0_38_19 Node0_38_20 77.0
R_0_38_19_2 Node0_38_19 Node0_39_19 77.0
R_0_38_19_3 Node0_38_19 Node1_38_19 12.320000000000002
C_0_38_19 Node0_38_19 GND 3.609375e-06
I_0_38_20 GND Node0_38_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_20_1 Node0_38_20 Node0_38_21 77.0
R_0_38_20_2 Node0_38_20 Node0_39_20 77.0
R_0_38_20_3 Node0_38_20 Node1_38_20 12.320000000000002
C_0_38_20 Node0_38_20 GND 3.609375e-06
I_0_38_21 GND Node0_38_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_21_1 Node0_38_21 Node0_38_22 77.0
R_0_38_21_2 Node0_38_21 Node0_39_21 77.0
R_0_38_21_3 Node0_38_21 Node1_38_21 12.320000000000002
C_0_38_21 Node0_38_21 GND 3.609375e-06
I_0_38_22 GND Node0_38_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_22_1 Node0_38_22 Node0_38_23 77.0
R_0_38_22_2 Node0_38_22 Node0_39_22 77.0
R_0_38_22_3 Node0_38_22 Node1_38_22 12.320000000000002
C_0_38_22 Node0_38_22 GND 3.609375e-06
I_0_38_23 GND Node0_38_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_23_1 Node0_38_23 Node0_38_24 77.0
R_0_38_23_2 Node0_38_23 Node0_39_23 77.0
R_0_38_23_3 Node0_38_23 Node1_38_23 12.320000000000002
C_0_38_23 Node0_38_23 GND 3.609375e-06
I_0_38_24 GND Node0_38_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_24_1 Node0_38_24 Node0_38_25 77.0
R_0_38_24_2 Node0_38_24 Node0_39_24 77.0
R_0_38_24_3 Node0_38_24 Node1_38_24 12.320000000000002
C_0_38_24 Node0_38_24 GND 3.609375e-06
I_0_38_25 GND Node0_38_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_25_1 Node0_38_25 Node0_38_26 77.0
R_0_38_25_2 Node0_38_25 Node0_39_25 77.0
R_0_38_25_3 Node0_38_25 Node1_38_25 12.320000000000002
C_0_38_25 Node0_38_25 GND 3.609375e-06
I_0_38_26 GND Node0_38_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_26_1 Node0_38_26 Node0_38_27 77.0
R_0_38_26_2 Node0_38_26 Node0_39_26 77.0
R_0_38_26_3 Node0_38_26 Node1_38_26 12.320000000000002
C_0_38_26 Node0_38_26 GND 3.609375e-06
I_0_38_27 GND Node0_38_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_27_1 Node0_38_27 Node0_38_28 77.0
R_0_38_27_2 Node0_38_27 Node0_39_27 77.0
R_0_38_27_3 Node0_38_27 Node1_38_27 12.320000000000002
C_0_38_27 Node0_38_27 GND 3.609375e-06
I_0_38_28 GND Node0_38_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_28_1 Node0_38_28 Node0_38_29 77.0
R_0_38_28_2 Node0_38_28 Node0_39_28 77.0
R_0_38_28_3 Node0_38_28 Node1_38_28 12.320000000000002
C_0_38_28 Node0_38_28 GND 3.609375e-06
I_0_38_29 GND Node0_38_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_29_1 Node0_38_29 Node0_38_30 77.0
R_0_38_29_2 Node0_38_29 Node0_39_29 77.0
R_0_38_29_3 Node0_38_29 Node1_38_29 12.320000000000002
C_0_38_29 Node0_38_29 GND 3.609375e-06
I_0_38_30 GND Node0_38_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_30_1 Node0_38_30 Node0_38_31 77.0
R_0_38_30_2 Node0_38_30 Node0_39_30 77.0
R_0_38_30_3 Node0_38_30 Node1_38_30 12.320000000000002
C_0_38_30 Node0_38_30 GND 3.609375e-06
I_0_38_31 GND Node0_38_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_31_1 Node0_38_31 Node0_38_32 77.0
R_0_38_31_2 Node0_38_31 Node0_39_31 77.0
R_0_38_31_3 Node0_38_31 Node1_38_31 12.320000000000002
C_0_38_31 Node0_38_31 GND 3.609375e-06
I_0_38_32 GND Node0_38_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_32_1 Node0_38_32 Node0_38_33 77.0
R_0_38_32_2 Node0_38_32 Node0_39_32 77.0
R_0_38_32_3 Node0_38_32 Node1_38_32 12.320000000000002
C_0_38_32 Node0_38_32 GND 3.609375e-06
I_0_38_33 GND Node0_38_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_33_1 Node0_38_33 Node0_38_34 77.0
R_0_38_33_2 Node0_38_33 Node0_39_33 77.0
R_0_38_33_3 Node0_38_33 Node1_38_33 12.320000000000002
C_0_38_33 Node0_38_33 GND 3.609375e-06
I_0_38_34 GND Node0_38_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_34_1 Node0_38_34 Node0_38_35 77.0
R_0_38_34_2 Node0_38_34 Node0_39_34 77.0
R_0_38_34_3 Node0_38_34 Node1_38_34 12.320000000000002
C_0_38_34 Node0_38_34 GND 3.609375e-06
I_0_38_35 GND Node0_38_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_35_1 Node0_38_35 Node0_38_36 77.0
R_0_38_35_2 Node0_38_35 Node0_39_35 77.0
R_0_38_35_3 Node0_38_35 Node1_38_35 12.320000000000002
C_0_38_35 Node0_38_35 GND 3.609375e-06
I_0_38_36 GND Node0_38_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_36_1 Node0_38_36 Node0_38_37 77.0
R_0_38_36_2 Node0_38_36 Node0_39_36 77.0
R_0_38_36_3 Node0_38_36 Node1_38_36 12.320000000000002
C_0_38_36 Node0_38_36 GND 3.609375e-06
I_0_38_37 GND Node0_38_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_37_1 Node0_38_37 Node0_38_38 77.0
R_0_38_37_2 Node0_38_37 Node0_39_37 77.0
R_0_38_37_3 Node0_38_37 Node1_38_37 12.320000000000002
C_0_38_37 Node0_38_37 GND 3.609375e-06
I_0_38_38 GND Node0_38_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_38_1 Node0_38_38 Node0_38_39 77.0
R_0_38_38_2 Node0_38_38 Node0_39_38 77.0
R_0_38_38_3 Node0_38_38 Node1_38_38 12.320000000000002
C_0_38_38 Node0_38_38 GND 3.609375e-06
I_0_38_39 GND Node0_38_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_38_39_2 Node0_38_39 Node0_39_39 77.0
R_0_38_39_3 Node0_38_39 Node1_38_39 12.320000000000002
C_0_38_39 Node0_38_39 GND 3.609375e-06
I_0_39_0 GND Node0_39_0 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_0_1 Node0_39_0 Node0_39_1 77.0
R_0_39_0_3 Node0_39_0 Node1_39_0 12.320000000000002
C_0_39_0 Node0_39_0 GND 3.609375e-06
I_0_39_1 GND Node0_39_1 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_1_1 Node0_39_1 Node0_39_2 77.0
R_0_39_1_3 Node0_39_1 Node1_39_1 12.320000000000002
C_0_39_1 Node0_39_1 GND 3.609375e-06
I_0_39_2 GND Node0_39_2 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_2_1 Node0_39_2 Node0_39_3 77.0
R_0_39_2_3 Node0_39_2 Node1_39_2 12.320000000000002
C_0_39_2 Node0_39_2 GND 3.609375e-06
I_0_39_3 GND Node0_39_3 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_3_1 Node0_39_3 Node0_39_4 77.0
R_0_39_3_3 Node0_39_3 Node1_39_3 12.320000000000002
C_0_39_3 Node0_39_3 GND 3.609375e-06
I_0_39_4 GND Node0_39_4 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_4_1 Node0_39_4 Node0_39_5 77.0
R_0_39_4_3 Node0_39_4 Node1_39_4 12.320000000000002
C_0_39_4 Node0_39_4 GND 3.609375e-06
I_0_39_5 GND Node0_39_5 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_5_1 Node0_39_5 Node0_39_6 77.0
R_0_39_5_3 Node0_39_5 Node1_39_5 12.320000000000002
C_0_39_5 Node0_39_5 GND 3.609375e-06
I_0_39_6 GND Node0_39_6 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_6_1 Node0_39_6 Node0_39_7 77.0
R_0_39_6_3 Node0_39_6 Node1_39_6 12.320000000000002
C_0_39_6 Node0_39_6 GND 3.609375e-06
I_0_39_7 GND Node0_39_7 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_7_1 Node0_39_7 Node0_39_8 77.0
R_0_39_7_3 Node0_39_7 Node1_39_7 12.320000000000002
C_0_39_7 Node0_39_7 GND 3.609375e-06
I_0_39_8 GND Node0_39_8 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_8_1 Node0_39_8 Node0_39_9 77.0
R_0_39_8_3 Node0_39_8 Node1_39_8 12.320000000000002
C_0_39_8 Node0_39_8 GND 3.609375e-06
I_0_39_9 GND Node0_39_9 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_9_1 Node0_39_9 Node0_39_10 77.0
R_0_39_9_3 Node0_39_9 Node1_39_9 12.320000000000002
C_0_39_9 Node0_39_9 GND 3.609375e-06
I_0_39_10 GND Node0_39_10 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_10_1 Node0_39_10 Node0_39_11 77.0
R_0_39_10_3 Node0_39_10 Node1_39_10 12.320000000000002
C_0_39_10 Node0_39_10 GND 3.609375e-06
I_0_39_11 GND Node0_39_11 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_11_1 Node0_39_11 Node0_39_12 77.0
R_0_39_11_3 Node0_39_11 Node1_39_11 12.320000000000002
C_0_39_11 Node0_39_11 GND 3.609375e-06
I_0_39_12 GND Node0_39_12 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_12_1 Node0_39_12 Node0_39_13 77.0
R_0_39_12_3 Node0_39_12 Node1_39_12 12.320000000000002
C_0_39_12 Node0_39_12 GND 3.609375e-06
I_0_39_13 GND Node0_39_13 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_13_1 Node0_39_13 Node0_39_14 77.0
R_0_39_13_3 Node0_39_13 Node1_39_13 12.320000000000002
C_0_39_13 Node0_39_13 GND 3.609375e-06
I_0_39_14 GND Node0_39_14 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_14_1 Node0_39_14 Node0_39_15 77.0
R_0_39_14_3 Node0_39_14 Node1_39_14 12.320000000000002
C_0_39_14 Node0_39_14 GND 3.609375e-06
I_0_39_15 GND Node0_39_15 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_15_1 Node0_39_15 Node0_39_16 77.0
R_0_39_15_3 Node0_39_15 Node1_39_15 12.320000000000002
C_0_39_15 Node0_39_15 GND 3.609375e-06
I_0_39_16 GND Node0_39_16 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_16_1 Node0_39_16 Node0_39_17 77.0
R_0_39_16_3 Node0_39_16 Node1_39_16 12.320000000000002
C_0_39_16 Node0_39_16 GND 3.609375e-06
I_0_39_17 GND Node0_39_17 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_17_1 Node0_39_17 Node0_39_18 77.0
R_0_39_17_3 Node0_39_17 Node1_39_17 12.320000000000002
C_0_39_17 Node0_39_17 GND 3.609375e-06
I_0_39_18 GND Node0_39_18 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_18_1 Node0_39_18 Node0_39_19 77.0
R_0_39_18_3 Node0_39_18 Node1_39_18 12.320000000000002
C_0_39_18 Node0_39_18 GND 3.609375e-06
I_0_39_19 GND Node0_39_19 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_19_1 Node0_39_19 Node0_39_20 77.0
R_0_39_19_3 Node0_39_19 Node1_39_19 12.320000000000002
C_0_39_19 Node0_39_19 GND 3.609375e-06
I_0_39_20 GND Node0_39_20 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_20_1 Node0_39_20 Node0_39_21 77.0
R_0_39_20_3 Node0_39_20 Node1_39_20 12.320000000000002
C_0_39_20 Node0_39_20 GND 3.609375e-06
I_0_39_21 GND Node0_39_21 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_21_1 Node0_39_21 Node0_39_22 77.0
R_0_39_21_3 Node0_39_21 Node1_39_21 12.320000000000002
C_0_39_21 Node0_39_21 GND 3.609375e-06
I_0_39_22 GND Node0_39_22 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_22_1 Node0_39_22 Node0_39_23 77.0
R_0_39_22_3 Node0_39_22 Node1_39_22 12.320000000000002
C_0_39_22 Node0_39_22 GND 3.609375e-06
I_0_39_23 GND Node0_39_23 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_23_1 Node0_39_23 Node0_39_24 77.0
R_0_39_23_3 Node0_39_23 Node1_39_23 12.320000000000002
C_0_39_23 Node0_39_23 GND 3.609375e-06
I_0_39_24 GND Node0_39_24 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_24_1 Node0_39_24 Node0_39_25 77.0
R_0_39_24_3 Node0_39_24 Node1_39_24 12.320000000000002
C_0_39_24 Node0_39_24 GND 3.609375e-06
I_0_39_25 GND Node0_39_25 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_25_1 Node0_39_25 Node0_39_26 77.0
R_0_39_25_3 Node0_39_25 Node1_39_25 12.320000000000002
C_0_39_25 Node0_39_25 GND 3.609375e-06
I_0_39_26 GND Node0_39_26 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_26_1 Node0_39_26 Node0_39_27 77.0
R_0_39_26_3 Node0_39_26 Node1_39_26 12.320000000000002
C_0_39_26 Node0_39_26 GND 3.609375e-06
I_0_39_27 GND Node0_39_27 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_27_1 Node0_39_27 Node0_39_28 77.0
R_0_39_27_3 Node0_39_27 Node1_39_27 12.320000000000002
C_0_39_27 Node0_39_27 GND 3.609375e-06
I_0_39_28 GND Node0_39_28 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_28_1 Node0_39_28 Node0_39_29 77.0
R_0_39_28_3 Node0_39_28 Node1_39_28 12.320000000000002
C_0_39_28 Node0_39_28 GND 3.609375e-06
I_0_39_29 GND Node0_39_29 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_29_1 Node0_39_29 Node0_39_30 77.0
R_0_39_29_3 Node0_39_29 Node1_39_29 12.320000000000002
C_0_39_29 Node0_39_29 GND 3.609375e-06
I_0_39_30 GND Node0_39_30 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_30_1 Node0_39_30 Node0_39_31 77.0
R_0_39_30_3 Node0_39_30 Node1_39_30 12.320000000000002
C_0_39_30 Node0_39_30 GND 3.609375e-06
I_0_39_31 GND Node0_39_31 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_31_1 Node0_39_31 Node0_39_32 77.0
R_0_39_31_3 Node0_39_31 Node1_39_31 12.320000000000002
C_0_39_31 Node0_39_31 GND 3.609375e-06
I_0_39_32 GND Node0_39_32 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_32_1 Node0_39_32 Node0_39_33 77.0
R_0_39_32_3 Node0_39_32 Node1_39_32 12.320000000000002
C_0_39_32 Node0_39_32 GND 3.609375e-06
I_0_39_33 GND Node0_39_33 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_33_1 Node0_39_33 Node0_39_34 77.0
R_0_39_33_3 Node0_39_33 Node1_39_33 12.320000000000002
C_0_39_33 Node0_39_33 GND 3.609375e-06
I_0_39_34 GND Node0_39_34 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_34_1 Node0_39_34 Node0_39_35 77.0
R_0_39_34_3 Node0_39_34 Node1_39_34 12.320000000000002
C_0_39_34 Node0_39_34 GND 3.609375e-06
I_0_39_35 GND Node0_39_35 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_35_1 Node0_39_35 Node0_39_36 77.0
R_0_39_35_3 Node0_39_35 Node1_39_35 12.320000000000002
C_0_39_35 Node0_39_35 GND 3.609375e-06
I_0_39_36 GND Node0_39_36 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_36_1 Node0_39_36 Node0_39_37 77.0
R_0_39_36_3 Node0_39_36 Node1_39_36 12.320000000000002
C_0_39_36 Node0_39_36 GND 3.609375e-06
I_0_39_37 GND Node0_39_37 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_37_1 Node0_39_37 Node0_39_38 77.0
R_0_39_37_3 Node0_39_37 Node1_39_37 12.320000000000002
C_0_39_37 Node0_39_37 GND 3.609375e-06
I_0_39_38 GND Node0_39_38 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_38_1 Node0_39_38 Node0_39_39 77.0
R_0_39_38_3 Node0_39_38 Node1_39_38 12.320000000000002
C_0_39_38 Node0_39_38 GND 3.609375e-06
I_0_39_39 GND Node0_39_39 PULSE(0 0.03125A 0s 0s 0s 33.3ms 33.3ms)
R_0_39_39_3 Node0_39_39 Node1_39_39 12.320000000000002
C_0_39_39 Node0_39_39 GND 3.609375e-06
R_1_0_0_1 Node1_0_0 Node1_0_1 250.00000000000003
R_1_0_0_2 Node1_0_0 Node1_1_0 250.00000000000003
R_1_0_0_3 Node1_0_0 GND 16.0
C_1_0_0 Node1_0_0 GND 3.6093750000000004e-07
R_1_0_1_1 Node1_0_1 Node1_0_2 250.00000000000003
R_1_0_1_2 Node1_0_1 Node1_1_1 250.00000000000003
R_1_0_1_3 Node1_0_1 GND 16.0
C_1_0_1 Node1_0_1 GND 3.6093750000000004e-07
R_1_0_2_1 Node1_0_2 Node1_0_3 250.00000000000003
R_1_0_2_2 Node1_0_2 Node1_1_2 250.00000000000003
R_1_0_2_3 Node1_0_2 GND 16.0
C_1_0_2 Node1_0_2 GND 3.6093750000000004e-07
R_1_0_3_1 Node1_0_3 Node1_0_4 250.00000000000003
R_1_0_3_2 Node1_0_3 Node1_1_3 250.00000000000003
R_1_0_3_3 Node1_0_3 GND 16.0
C_1_0_3 Node1_0_3 GND 3.6093750000000004e-07
R_1_0_4_1 Node1_0_4 Node1_0_5 250.00000000000003
R_1_0_4_2 Node1_0_4 Node1_1_4 250.00000000000003
R_1_0_4_3 Node1_0_4 GND 16.0
C_1_0_4 Node1_0_4 GND 3.6093750000000004e-07
R_1_0_5_1 Node1_0_5 Node1_0_6 250.00000000000003
R_1_0_5_2 Node1_0_5 Node1_1_5 250.00000000000003
R_1_0_5_3 Node1_0_5 GND 16.0
C_1_0_5 Node1_0_5 GND 3.6093750000000004e-07
R_1_0_6_1 Node1_0_6 Node1_0_7 250.00000000000003
R_1_0_6_2 Node1_0_6 Node1_1_6 250.00000000000003
R_1_0_6_3 Node1_0_6 GND 16.0
C_1_0_6 Node1_0_6 GND 3.6093750000000004e-07
R_1_0_7_1 Node1_0_7 Node1_0_8 250.00000000000003
R_1_0_7_2 Node1_0_7 Node1_1_7 250.00000000000003
R_1_0_7_3 Node1_0_7 GND 16.0
C_1_0_7 Node1_0_7 GND 3.6093750000000004e-07
R_1_0_8_1 Node1_0_8 Node1_0_9 250.00000000000003
R_1_0_8_2 Node1_0_8 Node1_1_8 250.00000000000003
R_1_0_8_3 Node1_0_8 GND 16.0
C_1_0_8 Node1_0_8 GND 3.6093750000000004e-07
R_1_0_9_1 Node1_0_9 Node1_0_10 250.00000000000003
R_1_0_9_2 Node1_0_9 Node1_1_9 250.00000000000003
R_1_0_9_3 Node1_0_9 GND 16.0
C_1_0_9 Node1_0_9 GND 3.6093750000000004e-07
R_1_0_10_1 Node1_0_10 Node1_0_11 250.00000000000003
R_1_0_10_2 Node1_0_10 Node1_1_10 250.00000000000003
R_1_0_10_3 Node1_0_10 GND 16.0
C_1_0_10 Node1_0_10 GND 3.6093750000000004e-07
R_1_0_11_1 Node1_0_11 Node1_0_12 250.00000000000003
R_1_0_11_2 Node1_0_11 Node1_1_11 250.00000000000003
R_1_0_11_3 Node1_0_11 GND 16.0
C_1_0_11 Node1_0_11 GND 3.6093750000000004e-07
R_1_0_12_1 Node1_0_12 Node1_0_13 250.00000000000003
R_1_0_12_2 Node1_0_12 Node1_1_12 250.00000000000003
R_1_0_12_3 Node1_0_12 GND 16.0
C_1_0_12 Node1_0_12 GND 3.6093750000000004e-07
R_1_0_13_1 Node1_0_13 Node1_0_14 250.00000000000003
R_1_0_13_2 Node1_0_13 Node1_1_13 250.00000000000003
R_1_0_13_3 Node1_0_13 GND 16.0
C_1_0_13 Node1_0_13 GND 3.6093750000000004e-07
R_1_0_14_1 Node1_0_14 Node1_0_15 250.00000000000003
R_1_0_14_2 Node1_0_14 Node1_1_14 250.00000000000003
R_1_0_14_3 Node1_0_14 GND 16.0
C_1_0_14 Node1_0_14 GND 3.6093750000000004e-07
R_1_0_15_1 Node1_0_15 Node1_0_16 250.00000000000003
R_1_0_15_2 Node1_0_15 Node1_1_15 250.00000000000003
R_1_0_15_3 Node1_0_15 GND 16.0
C_1_0_15 Node1_0_15 GND 3.6093750000000004e-07
R_1_0_16_1 Node1_0_16 Node1_0_17 250.00000000000003
R_1_0_16_2 Node1_0_16 Node1_1_16 250.00000000000003
R_1_0_16_3 Node1_0_16 GND 16.0
C_1_0_16 Node1_0_16 GND 3.6093750000000004e-07
R_1_0_17_1 Node1_0_17 Node1_0_18 250.00000000000003
R_1_0_17_2 Node1_0_17 Node1_1_17 250.00000000000003
R_1_0_17_3 Node1_0_17 GND 16.0
C_1_0_17 Node1_0_17 GND 3.6093750000000004e-07
R_1_0_18_1 Node1_0_18 Node1_0_19 250.00000000000003
R_1_0_18_2 Node1_0_18 Node1_1_18 250.00000000000003
R_1_0_18_3 Node1_0_18 GND 16.0
C_1_0_18 Node1_0_18 GND 3.6093750000000004e-07
R_1_0_19_1 Node1_0_19 Node1_0_20 250.00000000000003
R_1_0_19_2 Node1_0_19 Node1_1_19 250.00000000000003
R_1_0_19_3 Node1_0_19 GND 16.0
C_1_0_19 Node1_0_19 GND 3.6093750000000004e-07
R_1_0_20_1 Node1_0_20 Node1_0_21 250.00000000000003
R_1_0_20_2 Node1_0_20 Node1_1_20 250.00000000000003
R_1_0_20_3 Node1_0_20 GND 16.0
C_1_0_20 Node1_0_20 GND 3.6093750000000004e-07
R_1_0_21_1 Node1_0_21 Node1_0_22 250.00000000000003
R_1_0_21_2 Node1_0_21 Node1_1_21 250.00000000000003
R_1_0_21_3 Node1_0_21 GND 16.0
C_1_0_21 Node1_0_21 GND 3.6093750000000004e-07
R_1_0_22_1 Node1_0_22 Node1_0_23 250.00000000000003
R_1_0_22_2 Node1_0_22 Node1_1_22 250.00000000000003
R_1_0_22_3 Node1_0_22 GND 16.0
C_1_0_22 Node1_0_22 GND 3.6093750000000004e-07
R_1_0_23_1 Node1_0_23 Node1_0_24 250.00000000000003
R_1_0_23_2 Node1_0_23 Node1_1_23 250.00000000000003
R_1_0_23_3 Node1_0_23 GND 16.0
C_1_0_23 Node1_0_23 GND 3.6093750000000004e-07
R_1_0_24_1 Node1_0_24 Node1_0_25 250.00000000000003
R_1_0_24_2 Node1_0_24 Node1_1_24 250.00000000000003
R_1_0_24_3 Node1_0_24 GND 16.0
C_1_0_24 Node1_0_24 GND 3.6093750000000004e-07
R_1_0_25_1 Node1_0_25 Node1_0_26 250.00000000000003
R_1_0_25_2 Node1_0_25 Node1_1_25 250.00000000000003
R_1_0_25_3 Node1_0_25 GND 16.0
C_1_0_25 Node1_0_25 GND 3.6093750000000004e-07
R_1_0_26_1 Node1_0_26 Node1_0_27 250.00000000000003
R_1_0_26_2 Node1_0_26 Node1_1_26 250.00000000000003
R_1_0_26_3 Node1_0_26 GND 16.0
C_1_0_26 Node1_0_26 GND 3.6093750000000004e-07
R_1_0_27_1 Node1_0_27 Node1_0_28 250.00000000000003
R_1_0_27_2 Node1_0_27 Node1_1_27 250.00000000000003
R_1_0_27_3 Node1_0_27 GND 16.0
C_1_0_27 Node1_0_27 GND 3.6093750000000004e-07
R_1_0_28_1 Node1_0_28 Node1_0_29 250.00000000000003
R_1_0_28_2 Node1_0_28 Node1_1_28 250.00000000000003
R_1_0_28_3 Node1_0_28 GND 16.0
C_1_0_28 Node1_0_28 GND 3.6093750000000004e-07
R_1_0_29_1 Node1_0_29 Node1_0_30 250.00000000000003
R_1_0_29_2 Node1_0_29 Node1_1_29 250.00000000000003
R_1_0_29_3 Node1_0_29 GND 16.0
C_1_0_29 Node1_0_29 GND 3.6093750000000004e-07
R_1_0_30_1 Node1_0_30 Node1_0_31 250.00000000000003
R_1_0_30_2 Node1_0_30 Node1_1_30 250.00000000000003
R_1_0_30_3 Node1_0_30 GND 16.0
C_1_0_30 Node1_0_30 GND 3.6093750000000004e-07
R_1_0_31_1 Node1_0_31 Node1_0_32 250.00000000000003
R_1_0_31_2 Node1_0_31 Node1_1_31 250.00000000000003
R_1_0_31_3 Node1_0_31 GND 16.0
C_1_0_31 Node1_0_31 GND 3.6093750000000004e-07
R_1_0_32_1 Node1_0_32 Node1_0_33 250.00000000000003
R_1_0_32_2 Node1_0_32 Node1_1_32 250.00000000000003
R_1_0_32_3 Node1_0_32 GND 16.0
C_1_0_32 Node1_0_32 GND 3.6093750000000004e-07
R_1_0_33_1 Node1_0_33 Node1_0_34 250.00000000000003
R_1_0_33_2 Node1_0_33 Node1_1_33 250.00000000000003
R_1_0_33_3 Node1_0_33 GND 16.0
C_1_0_33 Node1_0_33 GND 3.6093750000000004e-07
R_1_0_34_1 Node1_0_34 Node1_0_35 250.00000000000003
R_1_0_34_2 Node1_0_34 Node1_1_34 250.00000000000003
R_1_0_34_3 Node1_0_34 GND 16.0
C_1_0_34 Node1_0_34 GND 3.6093750000000004e-07
R_1_0_35_1 Node1_0_35 Node1_0_36 250.00000000000003
R_1_0_35_2 Node1_0_35 Node1_1_35 250.00000000000003
R_1_0_35_3 Node1_0_35 GND 16.0
C_1_0_35 Node1_0_35 GND 3.6093750000000004e-07
R_1_0_36_1 Node1_0_36 Node1_0_37 250.00000000000003
R_1_0_36_2 Node1_0_36 Node1_1_36 250.00000000000003
R_1_0_36_3 Node1_0_36 GND 16.0
C_1_0_36 Node1_0_36 GND 3.6093750000000004e-07
R_1_0_37_1 Node1_0_37 Node1_0_38 250.00000000000003
R_1_0_37_2 Node1_0_37 Node1_1_37 250.00000000000003
R_1_0_37_3 Node1_0_37 GND 16.0
C_1_0_37 Node1_0_37 GND 3.6093750000000004e-07
R_1_0_38_1 Node1_0_38 Node1_0_39 250.00000000000003
R_1_0_38_2 Node1_0_38 Node1_1_38 250.00000000000003
R_1_0_38_3 Node1_0_38 GND 16.0
C_1_0_38 Node1_0_38 GND 3.6093750000000004e-07
R_1_0_39_2 Node1_0_39 Node1_1_39 250.00000000000003
R_1_0_39_3 Node1_0_39 GND 16.0
C_1_0_39 Node1_0_39 GND 3.6093750000000004e-07
R_1_1_0_1 Node1_1_0 Node1_1_1 250.00000000000003
R_1_1_0_2 Node1_1_0 Node1_2_0 250.00000000000003
R_1_1_0_3 Node1_1_0 GND 16.0
C_1_1_0 Node1_1_0 GND 3.6093750000000004e-07
R_1_1_1_1 Node1_1_1 Node1_1_2 250.00000000000003
R_1_1_1_2 Node1_1_1 Node1_2_1 250.00000000000003
R_1_1_1_3 Node1_1_1 GND 16.0
C_1_1_1 Node1_1_1 GND 3.6093750000000004e-07
R_1_1_2_1 Node1_1_2 Node1_1_3 250.00000000000003
R_1_1_2_2 Node1_1_2 Node1_2_2 250.00000000000003
R_1_1_2_3 Node1_1_2 GND 16.0
C_1_1_2 Node1_1_2 GND 3.6093750000000004e-07
R_1_1_3_1 Node1_1_3 Node1_1_4 250.00000000000003
R_1_1_3_2 Node1_1_3 Node1_2_3 250.00000000000003
R_1_1_3_3 Node1_1_3 GND 16.0
C_1_1_3 Node1_1_3 GND 3.6093750000000004e-07
R_1_1_4_1 Node1_1_4 Node1_1_5 250.00000000000003
R_1_1_4_2 Node1_1_4 Node1_2_4 250.00000000000003
R_1_1_4_3 Node1_1_4 GND 16.0
C_1_1_4 Node1_1_4 GND 3.6093750000000004e-07
R_1_1_5_1 Node1_1_5 Node1_1_6 250.00000000000003
R_1_1_5_2 Node1_1_5 Node1_2_5 250.00000000000003
R_1_1_5_3 Node1_1_5 GND 16.0
C_1_1_5 Node1_1_5 GND 3.6093750000000004e-07
R_1_1_6_1 Node1_1_6 Node1_1_7 250.00000000000003
R_1_1_6_2 Node1_1_6 Node1_2_6 250.00000000000003
R_1_1_6_3 Node1_1_6 GND 16.0
C_1_1_6 Node1_1_6 GND 3.6093750000000004e-07
R_1_1_7_1 Node1_1_7 Node1_1_8 250.00000000000003
R_1_1_7_2 Node1_1_7 Node1_2_7 250.00000000000003
R_1_1_7_3 Node1_1_7 GND 16.0
C_1_1_7 Node1_1_7 GND 3.6093750000000004e-07
R_1_1_8_1 Node1_1_8 Node1_1_9 250.00000000000003
R_1_1_8_2 Node1_1_8 Node1_2_8 250.00000000000003
R_1_1_8_3 Node1_1_8 GND 16.0
C_1_1_8 Node1_1_8 GND 3.6093750000000004e-07
R_1_1_9_1 Node1_1_9 Node1_1_10 250.00000000000003
R_1_1_9_2 Node1_1_9 Node1_2_9 250.00000000000003
R_1_1_9_3 Node1_1_9 GND 16.0
C_1_1_9 Node1_1_9 GND 3.6093750000000004e-07
R_1_1_10_1 Node1_1_10 Node1_1_11 250.00000000000003
R_1_1_10_2 Node1_1_10 Node1_2_10 250.00000000000003
R_1_1_10_3 Node1_1_10 GND 16.0
C_1_1_10 Node1_1_10 GND 3.6093750000000004e-07
R_1_1_11_1 Node1_1_11 Node1_1_12 250.00000000000003
R_1_1_11_2 Node1_1_11 Node1_2_11 250.00000000000003
R_1_1_11_3 Node1_1_11 GND 16.0
C_1_1_11 Node1_1_11 GND 3.6093750000000004e-07
R_1_1_12_1 Node1_1_12 Node1_1_13 250.00000000000003
R_1_1_12_2 Node1_1_12 Node1_2_12 250.00000000000003
R_1_1_12_3 Node1_1_12 GND 16.0
C_1_1_12 Node1_1_12 GND 3.6093750000000004e-07
R_1_1_13_1 Node1_1_13 Node1_1_14 250.00000000000003
R_1_1_13_2 Node1_1_13 Node1_2_13 250.00000000000003
R_1_1_13_3 Node1_1_13 GND 16.0
C_1_1_13 Node1_1_13 GND 3.6093750000000004e-07
R_1_1_14_1 Node1_1_14 Node1_1_15 250.00000000000003
R_1_1_14_2 Node1_1_14 Node1_2_14 250.00000000000003
R_1_1_14_3 Node1_1_14 GND 16.0
C_1_1_14 Node1_1_14 GND 3.6093750000000004e-07
R_1_1_15_1 Node1_1_15 Node1_1_16 250.00000000000003
R_1_1_15_2 Node1_1_15 Node1_2_15 250.00000000000003
R_1_1_15_3 Node1_1_15 GND 16.0
C_1_1_15 Node1_1_15 GND 3.6093750000000004e-07
R_1_1_16_1 Node1_1_16 Node1_1_17 250.00000000000003
R_1_1_16_2 Node1_1_16 Node1_2_16 250.00000000000003
R_1_1_16_3 Node1_1_16 GND 16.0
C_1_1_16 Node1_1_16 GND 3.6093750000000004e-07
R_1_1_17_1 Node1_1_17 Node1_1_18 250.00000000000003
R_1_1_17_2 Node1_1_17 Node1_2_17 250.00000000000003
R_1_1_17_3 Node1_1_17 GND 16.0
C_1_1_17 Node1_1_17 GND 3.6093750000000004e-07
R_1_1_18_1 Node1_1_18 Node1_1_19 250.00000000000003
R_1_1_18_2 Node1_1_18 Node1_2_18 250.00000000000003
R_1_1_18_3 Node1_1_18 GND 16.0
C_1_1_18 Node1_1_18 GND 3.6093750000000004e-07
R_1_1_19_1 Node1_1_19 Node1_1_20 250.00000000000003
R_1_1_19_2 Node1_1_19 Node1_2_19 250.00000000000003
R_1_1_19_3 Node1_1_19 GND 16.0
C_1_1_19 Node1_1_19 GND 3.6093750000000004e-07
R_1_1_20_1 Node1_1_20 Node1_1_21 250.00000000000003
R_1_1_20_2 Node1_1_20 Node1_2_20 250.00000000000003
R_1_1_20_3 Node1_1_20 GND 16.0
C_1_1_20 Node1_1_20 GND 3.6093750000000004e-07
R_1_1_21_1 Node1_1_21 Node1_1_22 250.00000000000003
R_1_1_21_2 Node1_1_21 Node1_2_21 250.00000000000003
R_1_1_21_3 Node1_1_21 GND 16.0
C_1_1_21 Node1_1_21 GND 3.6093750000000004e-07
R_1_1_22_1 Node1_1_22 Node1_1_23 250.00000000000003
R_1_1_22_2 Node1_1_22 Node1_2_22 250.00000000000003
R_1_1_22_3 Node1_1_22 GND 16.0
C_1_1_22 Node1_1_22 GND 3.6093750000000004e-07
R_1_1_23_1 Node1_1_23 Node1_1_24 250.00000000000003
R_1_1_23_2 Node1_1_23 Node1_2_23 250.00000000000003
R_1_1_23_3 Node1_1_23 GND 16.0
C_1_1_23 Node1_1_23 GND 3.6093750000000004e-07
R_1_1_24_1 Node1_1_24 Node1_1_25 250.00000000000003
R_1_1_24_2 Node1_1_24 Node1_2_24 250.00000000000003
R_1_1_24_3 Node1_1_24 GND 16.0
C_1_1_24 Node1_1_24 GND 3.6093750000000004e-07
R_1_1_25_1 Node1_1_25 Node1_1_26 250.00000000000003
R_1_1_25_2 Node1_1_25 Node1_2_25 250.00000000000003
R_1_1_25_3 Node1_1_25 GND 16.0
C_1_1_25 Node1_1_25 GND 3.6093750000000004e-07
R_1_1_26_1 Node1_1_26 Node1_1_27 250.00000000000003
R_1_1_26_2 Node1_1_26 Node1_2_26 250.00000000000003
R_1_1_26_3 Node1_1_26 GND 16.0
C_1_1_26 Node1_1_26 GND 3.6093750000000004e-07
R_1_1_27_1 Node1_1_27 Node1_1_28 250.00000000000003
R_1_1_27_2 Node1_1_27 Node1_2_27 250.00000000000003
R_1_1_27_3 Node1_1_27 GND 16.0
C_1_1_27 Node1_1_27 GND 3.6093750000000004e-07
R_1_1_28_1 Node1_1_28 Node1_1_29 250.00000000000003
R_1_1_28_2 Node1_1_28 Node1_2_28 250.00000000000003
R_1_1_28_3 Node1_1_28 GND 16.0
C_1_1_28 Node1_1_28 GND 3.6093750000000004e-07
R_1_1_29_1 Node1_1_29 Node1_1_30 250.00000000000003
R_1_1_29_2 Node1_1_29 Node1_2_29 250.00000000000003
R_1_1_29_3 Node1_1_29 GND 16.0
C_1_1_29 Node1_1_29 GND 3.6093750000000004e-07
R_1_1_30_1 Node1_1_30 Node1_1_31 250.00000000000003
R_1_1_30_2 Node1_1_30 Node1_2_30 250.00000000000003
R_1_1_30_3 Node1_1_30 GND 16.0
C_1_1_30 Node1_1_30 GND 3.6093750000000004e-07
R_1_1_31_1 Node1_1_31 Node1_1_32 250.00000000000003
R_1_1_31_2 Node1_1_31 Node1_2_31 250.00000000000003
R_1_1_31_3 Node1_1_31 GND 16.0
C_1_1_31 Node1_1_31 GND 3.6093750000000004e-07
R_1_1_32_1 Node1_1_32 Node1_1_33 250.00000000000003
R_1_1_32_2 Node1_1_32 Node1_2_32 250.00000000000003
R_1_1_32_3 Node1_1_32 GND 16.0
C_1_1_32 Node1_1_32 GND 3.6093750000000004e-07
R_1_1_33_1 Node1_1_33 Node1_1_34 250.00000000000003
R_1_1_33_2 Node1_1_33 Node1_2_33 250.00000000000003
R_1_1_33_3 Node1_1_33 GND 16.0
C_1_1_33 Node1_1_33 GND 3.6093750000000004e-07
R_1_1_34_1 Node1_1_34 Node1_1_35 250.00000000000003
R_1_1_34_2 Node1_1_34 Node1_2_34 250.00000000000003
R_1_1_34_3 Node1_1_34 GND 16.0
C_1_1_34 Node1_1_34 GND 3.6093750000000004e-07
R_1_1_35_1 Node1_1_35 Node1_1_36 250.00000000000003
R_1_1_35_2 Node1_1_35 Node1_2_35 250.00000000000003
R_1_1_35_3 Node1_1_35 GND 16.0
C_1_1_35 Node1_1_35 GND 3.6093750000000004e-07
R_1_1_36_1 Node1_1_36 Node1_1_37 250.00000000000003
R_1_1_36_2 Node1_1_36 Node1_2_36 250.00000000000003
R_1_1_36_3 Node1_1_36 GND 16.0
C_1_1_36 Node1_1_36 GND 3.6093750000000004e-07
R_1_1_37_1 Node1_1_37 Node1_1_38 250.00000000000003
R_1_1_37_2 Node1_1_37 Node1_2_37 250.00000000000003
R_1_1_37_3 Node1_1_37 GND 16.0
C_1_1_37 Node1_1_37 GND 3.6093750000000004e-07
R_1_1_38_1 Node1_1_38 Node1_1_39 250.00000000000003
R_1_1_38_2 Node1_1_38 Node1_2_38 250.00000000000003
R_1_1_38_3 Node1_1_38 GND 16.0
C_1_1_38 Node1_1_38 GND 3.6093750000000004e-07
R_1_1_39_2 Node1_1_39 Node1_2_39 250.00000000000003
R_1_1_39_3 Node1_1_39 GND 16.0
C_1_1_39 Node1_1_39 GND 3.6093750000000004e-07
R_1_2_0_1 Node1_2_0 Node1_2_1 250.00000000000003
R_1_2_0_2 Node1_2_0 Node1_3_0 250.00000000000003
R_1_2_0_3 Node1_2_0 GND 16.0
C_1_2_0 Node1_2_0 GND 3.6093750000000004e-07
R_1_2_1_1 Node1_2_1 Node1_2_2 250.00000000000003
R_1_2_1_2 Node1_2_1 Node1_3_1 250.00000000000003
R_1_2_1_3 Node1_2_1 GND 16.0
C_1_2_1 Node1_2_1 GND 3.6093750000000004e-07
R_1_2_2_1 Node1_2_2 Node1_2_3 250.00000000000003
R_1_2_2_2 Node1_2_2 Node1_3_2 250.00000000000003
R_1_2_2_3 Node1_2_2 GND 16.0
C_1_2_2 Node1_2_2 GND 3.6093750000000004e-07
R_1_2_3_1 Node1_2_3 Node1_2_4 250.00000000000003
R_1_2_3_2 Node1_2_3 Node1_3_3 250.00000000000003
R_1_2_3_3 Node1_2_3 GND 16.0
C_1_2_3 Node1_2_3 GND 3.6093750000000004e-07
R_1_2_4_1 Node1_2_4 Node1_2_5 250.00000000000003
R_1_2_4_2 Node1_2_4 Node1_3_4 250.00000000000003
R_1_2_4_3 Node1_2_4 GND 16.0
C_1_2_4 Node1_2_4 GND 3.6093750000000004e-07
R_1_2_5_1 Node1_2_5 Node1_2_6 250.00000000000003
R_1_2_5_2 Node1_2_5 Node1_3_5 250.00000000000003
R_1_2_5_3 Node1_2_5 GND 16.0
C_1_2_5 Node1_2_5 GND 3.6093750000000004e-07
R_1_2_6_1 Node1_2_6 Node1_2_7 250.00000000000003
R_1_2_6_2 Node1_2_6 Node1_3_6 250.00000000000003
R_1_2_6_3 Node1_2_6 GND 16.0
C_1_2_6 Node1_2_6 GND 3.6093750000000004e-07
R_1_2_7_1 Node1_2_7 Node1_2_8 250.00000000000003
R_1_2_7_2 Node1_2_7 Node1_3_7 250.00000000000003
R_1_2_7_3 Node1_2_7 GND 16.0
C_1_2_7 Node1_2_7 GND 3.6093750000000004e-07
R_1_2_8_1 Node1_2_8 Node1_2_9 250.00000000000003
R_1_2_8_2 Node1_2_8 Node1_3_8 250.00000000000003
R_1_2_8_3 Node1_2_8 GND 16.0
C_1_2_8 Node1_2_8 GND 3.6093750000000004e-07
R_1_2_9_1 Node1_2_9 Node1_2_10 250.00000000000003
R_1_2_9_2 Node1_2_9 Node1_3_9 250.00000000000003
R_1_2_9_3 Node1_2_9 GND 16.0
C_1_2_9 Node1_2_9 GND 3.6093750000000004e-07
R_1_2_10_1 Node1_2_10 Node1_2_11 250.00000000000003
R_1_2_10_2 Node1_2_10 Node1_3_10 250.00000000000003
R_1_2_10_3 Node1_2_10 GND 16.0
C_1_2_10 Node1_2_10 GND 3.6093750000000004e-07
R_1_2_11_1 Node1_2_11 Node1_2_12 250.00000000000003
R_1_2_11_2 Node1_2_11 Node1_3_11 250.00000000000003
R_1_2_11_3 Node1_2_11 GND 16.0
C_1_2_11 Node1_2_11 GND 3.6093750000000004e-07
R_1_2_12_1 Node1_2_12 Node1_2_13 250.00000000000003
R_1_2_12_2 Node1_2_12 Node1_3_12 250.00000000000003
R_1_2_12_3 Node1_2_12 GND 16.0
C_1_2_12 Node1_2_12 GND 3.6093750000000004e-07
R_1_2_13_1 Node1_2_13 Node1_2_14 250.00000000000003
R_1_2_13_2 Node1_2_13 Node1_3_13 250.00000000000003
R_1_2_13_3 Node1_2_13 GND 16.0
C_1_2_13 Node1_2_13 GND 3.6093750000000004e-07
R_1_2_14_1 Node1_2_14 Node1_2_15 250.00000000000003
R_1_2_14_2 Node1_2_14 Node1_3_14 250.00000000000003
R_1_2_14_3 Node1_2_14 GND 16.0
C_1_2_14 Node1_2_14 GND 3.6093750000000004e-07
R_1_2_15_1 Node1_2_15 Node1_2_16 250.00000000000003
R_1_2_15_2 Node1_2_15 Node1_3_15 250.00000000000003
R_1_2_15_3 Node1_2_15 GND 16.0
C_1_2_15 Node1_2_15 GND 3.6093750000000004e-07
R_1_2_16_1 Node1_2_16 Node1_2_17 250.00000000000003
R_1_2_16_2 Node1_2_16 Node1_3_16 250.00000000000003
R_1_2_16_3 Node1_2_16 GND 16.0
C_1_2_16 Node1_2_16 GND 3.6093750000000004e-07
R_1_2_17_1 Node1_2_17 Node1_2_18 250.00000000000003
R_1_2_17_2 Node1_2_17 Node1_3_17 250.00000000000003
R_1_2_17_3 Node1_2_17 GND 16.0
C_1_2_17 Node1_2_17 GND 3.6093750000000004e-07
R_1_2_18_1 Node1_2_18 Node1_2_19 250.00000000000003
R_1_2_18_2 Node1_2_18 Node1_3_18 250.00000000000003
R_1_2_18_3 Node1_2_18 GND 16.0
C_1_2_18 Node1_2_18 GND 3.6093750000000004e-07
R_1_2_19_1 Node1_2_19 Node1_2_20 250.00000000000003
R_1_2_19_2 Node1_2_19 Node1_3_19 250.00000000000003
R_1_2_19_3 Node1_2_19 GND 16.0
C_1_2_19 Node1_2_19 GND 3.6093750000000004e-07
R_1_2_20_1 Node1_2_20 Node1_2_21 250.00000000000003
R_1_2_20_2 Node1_2_20 Node1_3_20 250.00000000000003
R_1_2_20_3 Node1_2_20 GND 16.0
C_1_2_20 Node1_2_20 GND 3.6093750000000004e-07
R_1_2_21_1 Node1_2_21 Node1_2_22 250.00000000000003
R_1_2_21_2 Node1_2_21 Node1_3_21 250.00000000000003
R_1_2_21_3 Node1_2_21 GND 16.0
C_1_2_21 Node1_2_21 GND 3.6093750000000004e-07
R_1_2_22_1 Node1_2_22 Node1_2_23 250.00000000000003
R_1_2_22_2 Node1_2_22 Node1_3_22 250.00000000000003
R_1_2_22_3 Node1_2_22 GND 16.0
C_1_2_22 Node1_2_22 GND 3.6093750000000004e-07
R_1_2_23_1 Node1_2_23 Node1_2_24 250.00000000000003
R_1_2_23_2 Node1_2_23 Node1_3_23 250.00000000000003
R_1_2_23_3 Node1_2_23 GND 16.0
C_1_2_23 Node1_2_23 GND 3.6093750000000004e-07
R_1_2_24_1 Node1_2_24 Node1_2_25 250.00000000000003
R_1_2_24_2 Node1_2_24 Node1_3_24 250.00000000000003
R_1_2_24_3 Node1_2_24 GND 16.0
C_1_2_24 Node1_2_24 GND 3.6093750000000004e-07
R_1_2_25_1 Node1_2_25 Node1_2_26 250.00000000000003
R_1_2_25_2 Node1_2_25 Node1_3_25 250.00000000000003
R_1_2_25_3 Node1_2_25 GND 16.0
C_1_2_25 Node1_2_25 GND 3.6093750000000004e-07
R_1_2_26_1 Node1_2_26 Node1_2_27 250.00000000000003
R_1_2_26_2 Node1_2_26 Node1_3_26 250.00000000000003
R_1_2_26_3 Node1_2_26 GND 16.0
C_1_2_26 Node1_2_26 GND 3.6093750000000004e-07
R_1_2_27_1 Node1_2_27 Node1_2_28 250.00000000000003
R_1_2_27_2 Node1_2_27 Node1_3_27 250.00000000000003
R_1_2_27_3 Node1_2_27 GND 16.0
C_1_2_27 Node1_2_27 GND 3.6093750000000004e-07
R_1_2_28_1 Node1_2_28 Node1_2_29 250.00000000000003
R_1_2_28_2 Node1_2_28 Node1_3_28 250.00000000000003
R_1_2_28_3 Node1_2_28 GND 16.0
C_1_2_28 Node1_2_28 GND 3.6093750000000004e-07
R_1_2_29_1 Node1_2_29 Node1_2_30 250.00000000000003
R_1_2_29_2 Node1_2_29 Node1_3_29 250.00000000000003
R_1_2_29_3 Node1_2_29 GND 16.0
C_1_2_29 Node1_2_29 GND 3.6093750000000004e-07
R_1_2_30_1 Node1_2_30 Node1_2_31 250.00000000000003
R_1_2_30_2 Node1_2_30 Node1_3_30 250.00000000000003
R_1_2_30_3 Node1_2_30 GND 16.0
C_1_2_30 Node1_2_30 GND 3.6093750000000004e-07
R_1_2_31_1 Node1_2_31 Node1_2_32 250.00000000000003
R_1_2_31_2 Node1_2_31 Node1_3_31 250.00000000000003
R_1_2_31_3 Node1_2_31 GND 16.0
C_1_2_31 Node1_2_31 GND 3.6093750000000004e-07
R_1_2_32_1 Node1_2_32 Node1_2_33 250.00000000000003
R_1_2_32_2 Node1_2_32 Node1_3_32 250.00000000000003
R_1_2_32_3 Node1_2_32 GND 16.0
C_1_2_32 Node1_2_32 GND 3.6093750000000004e-07
R_1_2_33_1 Node1_2_33 Node1_2_34 250.00000000000003
R_1_2_33_2 Node1_2_33 Node1_3_33 250.00000000000003
R_1_2_33_3 Node1_2_33 GND 16.0
C_1_2_33 Node1_2_33 GND 3.6093750000000004e-07
R_1_2_34_1 Node1_2_34 Node1_2_35 250.00000000000003
R_1_2_34_2 Node1_2_34 Node1_3_34 250.00000000000003
R_1_2_34_3 Node1_2_34 GND 16.0
C_1_2_34 Node1_2_34 GND 3.6093750000000004e-07
R_1_2_35_1 Node1_2_35 Node1_2_36 250.00000000000003
R_1_2_35_2 Node1_2_35 Node1_3_35 250.00000000000003
R_1_2_35_3 Node1_2_35 GND 16.0
C_1_2_35 Node1_2_35 GND 3.6093750000000004e-07
R_1_2_36_1 Node1_2_36 Node1_2_37 250.00000000000003
R_1_2_36_2 Node1_2_36 Node1_3_36 250.00000000000003
R_1_2_36_3 Node1_2_36 GND 16.0
C_1_2_36 Node1_2_36 GND 3.6093750000000004e-07
R_1_2_37_1 Node1_2_37 Node1_2_38 250.00000000000003
R_1_2_37_2 Node1_2_37 Node1_3_37 250.00000000000003
R_1_2_37_3 Node1_2_37 GND 16.0
C_1_2_37 Node1_2_37 GND 3.6093750000000004e-07
R_1_2_38_1 Node1_2_38 Node1_2_39 250.00000000000003
R_1_2_38_2 Node1_2_38 Node1_3_38 250.00000000000003
R_1_2_38_3 Node1_2_38 GND 16.0
C_1_2_38 Node1_2_38 GND 3.6093750000000004e-07
R_1_2_39_2 Node1_2_39 Node1_3_39 250.00000000000003
R_1_2_39_3 Node1_2_39 GND 16.0
C_1_2_39 Node1_2_39 GND 3.6093750000000004e-07
R_1_3_0_1 Node1_3_0 Node1_3_1 250.00000000000003
R_1_3_0_2 Node1_3_0 Node1_4_0 250.00000000000003
R_1_3_0_3 Node1_3_0 GND 16.0
C_1_3_0 Node1_3_0 GND 3.6093750000000004e-07
R_1_3_1_1 Node1_3_1 Node1_3_2 250.00000000000003
R_1_3_1_2 Node1_3_1 Node1_4_1 250.00000000000003
R_1_3_1_3 Node1_3_1 GND 16.0
C_1_3_1 Node1_3_1 GND 3.6093750000000004e-07
R_1_3_2_1 Node1_3_2 Node1_3_3 250.00000000000003
R_1_3_2_2 Node1_3_2 Node1_4_2 250.00000000000003
R_1_3_2_3 Node1_3_2 GND 16.0
C_1_3_2 Node1_3_2 GND 3.6093750000000004e-07
R_1_3_3_1 Node1_3_3 Node1_3_4 250.00000000000003
R_1_3_3_2 Node1_3_3 Node1_4_3 250.00000000000003
R_1_3_3_3 Node1_3_3 GND 16.0
C_1_3_3 Node1_3_3 GND 3.6093750000000004e-07
R_1_3_4_1 Node1_3_4 Node1_3_5 250.00000000000003
R_1_3_4_2 Node1_3_4 Node1_4_4 250.00000000000003
R_1_3_4_3 Node1_3_4 GND 16.0
C_1_3_4 Node1_3_4 GND 3.6093750000000004e-07
R_1_3_5_1 Node1_3_5 Node1_3_6 250.00000000000003
R_1_3_5_2 Node1_3_5 Node1_4_5 250.00000000000003
R_1_3_5_3 Node1_3_5 GND 16.0
C_1_3_5 Node1_3_5 GND 3.6093750000000004e-07
R_1_3_6_1 Node1_3_6 Node1_3_7 250.00000000000003
R_1_3_6_2 Node1_3_6 Node1_4_6 250.00000000000003
R_1_3_6_3 Node1_3_6 GND 16.0
C_1_3_6 Node1_3_6 GND 3.6093750000000004e-07
R_1_3_7_1 Node1_3_7 Node1_3_8 250.00000000000003
R_1_3_7_2 Node1_3_7 Node1_4_7 250.00000000000003
R_1_3_7_3 Node1_3_7 GND 16.0
C_1_3_7 Node1_3_7 GND 3.6093750000000004e-07
R_1_3_8_1 Node1_3_8 Node1_3_9 250.00000000000003
R_1_3_8_2 Node1_3_8 Node1_4_8 250.00000000000003
R_1_3_8_3 Node1_3_8 GND 16.0
C_1_3_8 Node1_3_8 GND 3.6093750000000004e-07
R_1_3_9_1 Node1_3_9 Node1_3_10 250.00000000000003
R_1_3_9_2 Node1_3_9 Node1_4_9 250.00000000000003
R_1_3_9_3 Node1_3_9 GND 16.0
C_1_3_9 Node1_3_9 GND 3.6093750000000004e-07
R_1_3_10_1 Node1_3_10 Node1_3_11 250.00000000000003
R_1_3_10_2 Node1_3_10 Node1_4_10 250.00000000000003
R_1_3_10_3 Node1_3_10 GND 16.0
C_1_3_10 Node1_3_10 GND 3.6093750000000004e-07
R_1_3_11_1 Node1_3_11 Node1_3_12 250.00000000000003
R_1_3_11_2 Node1_3_11 Node1_4_11 250.00000000000003
R_1_3_11_3 Node1_3_11 GND 16.0
C_1_3_11 Node1_3_11 GND 3.6093750000000004e-07
R_1_3_12_1 Node1_3_12 Node1_3_13 250.00000000000003
R_1_3_12_2 Node1_3_12 Node1_4_12 250.00000000000003
R_1_3_12_3 Node1_3_12 GND 16.0
C_1_3_12 Node1_3_12 GND 3.6093750000000004e-07
R_1_3_13_1 Node1_3_13 Node1_3_14 250.00000000000003
R_1_3_13_2 Node1_3_13 Node1_4_13 250.00000000000003
R_1_3_13_3 Node1_3_13 GND 16.0
C_1_3_13 Node1_3_13 GND 3.6093750000000004e-07
R_1_3_14_1 Node1_3_14 Node1_3_15 250.00000000000003
R_1_3_14_2 Node1_3_14 Node1_4_14 250.00000000000003
R_1_3_14_3 Node1_3_14 GND 16.0
C_1_3_14 Node1_3_14 GND 3.6093750000000004e-07
R_1_3_15_1 Node1_3_15 Node1_3_16 250.00000000000003
R_1_3_15_2 Node1_3_15 Node1_4_15 250.00000000000003
R_1_3_15_3 Node1_3_15 GND 16.0
C_1_3_15 Node1_3_15 GND 3.6093750000000004e-07
R_1_3_16_1 Node1_3_16 Node1_3_17 250.00000000000003
R_1_3_16_2 Node1_3_16 Node1_4_16 250.00000000000003
R_1_3_16_3 Node1_3_16 GND 16.0
C_1_3_16 Node1_3_16 GND 3.6093750000000004e-07
R_1_3_17_1 Node1_3_17 Node1_3_18 250.00000000000003
R_1_3_17_2 Node1_3_17 Node1_4_17 250.00000000000003
R_1_3_17_3 Node1_3_17 GND 16.0
C_1_3_17 Node1_3_17 GND 3.6093750000000004e-07
R_1_3_18_1 Node1_3_18 Node1_3_19 250.00000000000003
R_1_3_18_2 Node1_3_18 Node1_4_18 250.00000000000003
R_1_3_18_3 Node1_3_18 GND 16.0
C_1_3_18 Node1_3_18 GND 3.6093750000000004e-07
R_1_3_19_1 Node1_3_19 Node1_3_20 250.00000000000003
R_1_3_19_2 Node1_3_19 Node1_4_19 250.00000000000003
R_1_3_19_3 Node1_3_19 GND 16.0
C_1_3_19 Node1_3_19 GND 3.6093750000000004e-07
R_1_3_20_1 Node1_3_20 Node1_3_21 250.00000000000003
R_1_3_20_2 Node1_3_20 Node1_4_20 250.00000000000003
R_1_3_20_3 Node1_3_20 GND 16.0
C_1_3_20 Node1_3_20 GND 3.6093750000000004e-07
R_1_3_21_1 Node1_3_21 Node1_3_22 250.00000000000003
R_1_3_21_2 Node1_3_21 Node1_4_21 250.00000000000003
R_1_3_21_3 Node1_3_21 GND 16.0
C_1_3_21 Node1_3_21 GND 3.6093750000000004e-07
R_1_3_22_1 Node1_3_22 Node1_3_23 250.00000000000003
R_1_3_22_2 Node1_3_22 Node1_4_22 250.00000000000003
R_1_3_22_3 Node1_3_22 GND 16.0
C_1_3_22 Node1_3_22 GND 3.6093750000000004e-07
R_1_3_23_1 Node1_3_23 Node1_3_24 250.00000000000003
R_1_3_23_2 Node1_3_23 Node1_4_23 250.00000000000003
R_1_3_23_3 Node1_3_23 GND 16.0
C_1_3_23 Node1_3_23 GND 3.6093750000000004e-07
R_1_3_24_1 Node1_3_24 Node1_3_25 250.00000000000003
R_1_3_24_2 Node1_3_24 Node1_4_24 250.00000000000003
R_1_3_24_3 Node1_3_24 GND 16.0
C_1_3_24 Node1_3_24 GND 3.6093750000000004e-07
R_1_3_25_1 Node1_3_25 Node1_3_26 250.00000000000003
R_1_3_25_2 Node1_3_25 Node1_4_25 250.00000000000003
R_1_3_25_3 Node1_3_25 GND 16.0
C_1_3_25 Node1_3_25 GND 3.6093750000000004e-07
R_1_3_26_1 Node1_3_26 Node1_3_27 250.00000000000003
R_1_3_26_2 Node1_3_26 Node1_4_26 250.00000000000003
R_1_3_26_3 Node1_3_26 GND 16.0
C_1_3_26 Node1_3_26 GND 3.6093750000000004e-07
R_1_3_27_1 Node1_3_27 Node1_3_28 250.00000000000003
R_1_3_27_2 Node1_3_27 Node1_4_27 250.00000000000003
R_1_3_27_3 Node1_3_27 GND 16.0
C_1_3_27 Node1_3_27 GND 3.6093750000000004e-07
R_1_3_28_1 Node1_3_28 Node1_3_29 250.00000000000003
R_1_3_28_2 Node1_3_28 Node1_4_28 250.00000000000003
R_1_3_28_3 Node1_3_28 GND 16.0
C_1_3_28 Node1_3_28 GND 3.6093750000000004e-07
R_1_3_29_1 Node1_3_29 Node1_3_30 250.00000000000003
R_1_3_29_2 Node1_3_29 Node1_4_29 250.00000000000003
R_1_3_29_3 Node1_3_29 GND 16.0
C_1_3_29 Node1_3_29 GND 3.6093750000000004e-07
R_1_3_30_1 Node1_3_30 Node1_3_31 250.00000000000003
R_1_3_30_2 Node1_3_30 Node1_4_30 250.00000000000003
R_1_3_30_3 Node1_3_30 GND 16.0
C_1_3_30 Node1_3_30 GND 3.6093750000000004e-07
R_1_3_31_1 Node1_3_31 Node1_3_32 250.00000000000003
R_1_3_31_2 Node1_3_31 Node1_4_31 250.00000000000003
R_1_3_31_3 Node1_3_31 GND 16.0
C_1_3_31 Node1_3_31 GND 3.6093750000000004e-07
R_1_3_32_1 Node1_3_32 Node1_3_33 250.00000000000003
R_1_3_32_2 Node1_3_32 Node1_4_32 250.00000000000003
R_1_3_32_3 Node1_3_32 GND 16.0
C_1_3_32 Node1_3_32 GND 3.6093750000000004e-07
R_1_3_33_1 Node1_3_33 Node1_3_34 250.00000000000003
R_1_3_33_2 Node1_3_33 Node1_4_33 250.00000000000003
R_1_3_33_3 Node1_3_33 GND 16.0
C_1_3_33 Node1_3_33 GND 3.6093750000000004e-07
R_1_3_34_1 Node1_3_34 Node1_3_35 250.00000000000003
R_1_3_34_2 Node1_3_34 Node1_4_34 250.00000000000003
R_1_3_34_3 Node1_3_34 GND 16.0
C_1_3_34 Node1_3_34 GND 3.6093750000000004e-07
R_1_3_35_1 Node1_3_35 Node1_3_36 250.00000000000003
R_1_3_35_2 Node1_3_35 Node1_4_35 250.00000000000003
R_1_3_35_3 Node1_3_35 GND 16.0
C_1_3_35 Node1_3_35 GND 3.6093750000000004e-07
R_1_3_36_1 Node1_3_36 Node1_3_37 250.00000000000003
R_1_3_36_2 Node1_3_36 Node1_4_36 250.00000000000003
R_1_3_36_3 Node1_3_36 GND 16.0
C_1_3_36 Node1_3_36 GND 3.6093750000000004e-07
R_1_3_37_1 Node1_3_37 Node1_3_38 250.00000000000003
R_1_3_37_2 Node1_3_37 Node1_4_37 250.00000000000003
R_1_3_37_3 Node1_3_37 GND 16.0
C_1_3_37 Node1_3_37 GND 3.6093750000000004e-07
R_1_3_38_1 Node1_3_38 Node1_3_39 250.00000000000003
R_1_3_38_2 Node1_3_38 Node1_4_38 250.00000000000003
R_1_3_38_3 Node1_3_38 GND 16.0
C_1_3_38 Node1_3_38 GND 3.6093750000000004e-07
R_1_3_39_2 Node1_3_39 Node1_4_39 250.00000000000003
R_1_3_39_3 Node1_3_39 GND 16.0
C_1_3_39 Node1_3_39 GND 3.6093750000000004e-07
R_1_4_0_1 Node1_4_0 Node1_4_1 250.00000000000003
R_1_4_0_2 Node1_4_0 Node1_5_0 250.00000000000003
R_1_4_0_3 Node1_4_0 GND 16.0
C_1_4_0 Node1_4_0 GND 3.6093750000000004e-07
R_1_4_1_1 Node1_4_1 Node1_4_2 250.00000000000003
R_1_4_1_2 Node1_4_1 Node1_5_1 250.00000000000003
R_1_4_1_3 Node1_4_1 GND 16.0
C_1_4_1 Node1_4_1 GND 3.6093750000000004e-07
R_1_4_2_1 Node1_4_2 Node1_4_3 250.00000000000003
R_1_4_2_2 Node1_4_2 Node1_5_2 250.00000000000003
R_1_4_2_3 Node1_4_2 GND 16.0
C_1_4_2 Node1_4_2 GND 3.6093750000000004e-07
R_1_4_3_1 Node1_4_3 Node1_4_4 250.00000000000003
R_1_4_3_2 Node1_4_3 Node1_5_3 250.00000000000003
R_1_4_3_3 Node1_4_3 GND 16.0
C_1_4_3 Node1_4_3 GND 3.6093750000000004e-07
R_1_4_4_1 Node1_4_4 Node1_4_5 250.00000000000003
R_1_4_4_2 Node1_4_4 Node1_5_4 250.00000000000003
R_1_4_4_3 Node1_4_4 GND 16.0
C_1_4_4 Node1_4_4 GND 3.6093750000000004e-07
R_1_4_5_1 Node1_4_5 Node1_4_6 250.00000000000003
R_1_4_5_2 Node1_4_5 Node1_5_5 250.00000000000003
R_1_4_5_3 Node1_4_5 GND 16.0
C_1_4_5 Node1_4_5 GND 3.6093750000000004e-07
R_1_4_6_1 Node1_4_6 Node1_4_7 250.00000000000003
R_1_4_6_2 Node1_4_6 Node1_5_6 250.00000000000003
R_1_4_6_3 Node1_4_6 GND 16.0
C_1_4_6 Node1_4_6 GND 3.6093750000000004e-07
R_1_4_7_1 Node1_4_7 Node1_4_8 250.00000000000003
R_1_4_7_2 Node1_4_7 Node1_5_7 250.00000000000003
R_1_4_7_3 Node1_4_7 GND 16.0
C_1_4_7 Node1_4_7 GND 3.6093750000000004e-07
R_1_4_8_1 Node1_4_8 Node1_4_9 250.00000000000003
R_1_4_8_2 Node1_4_8 Node1_5_8 250.00000000000003
R_1_4_8_3 Node1_4_8 GND 16.0
C_1_4_8 Node1_4_8 GND 3.6093750000000004e-07
R_1_4_9_1 Node1_4_9 Node1_4_10 250.00000000000003
R_1_4_9_2 Node1_4_9 Node1_5_9 250.00000000000003
R_1_4_9_3 Node1_4_9 GND 16.0
C_1_4_9 Node1_4_9 GND 3.6093750000000004e-07
R_1_4_10_1 Node1_4_10 Node1_4_11 250.00000000000003
R_1_4_10_2 Node1_4_10 Node1_5_10 250.00000000000003
R_1_4_10_3 Node1_4_10 GND 16.0
C_1_4_10 Node1_4_10 GND 3.6093750000000004e-07
R_1_4_11_1 Node1_4_11 Node1_4_12 250.00000000000003
R_1_4_11_2 Node1_4_11 Node1_5_11 250.00000000000003
R_1_4_11_3 Node1_4_11 GND 16.0
C_1_4_11 Node1_4_11 GND 3.6093750000000004e-07
R_1_4_12_1 Node1_4_12 Node1_4_13 250.00000000000003
R_1_4_12_2 Node1_4_12 Node1_5_12 250.00000000000003
R_1_4_12_3 Node1_4_12 GND 16.0
C_1_4_12 Node1_4_12 GND 3.6093750000000004e-07
R_1_4_13_1 Node1_4_13 Node1_4_14 250.00000000000003
R_1_4_13_2 Node1_4_13 Node1_5_13 250.00000000000003
R_1_4_13_3 Node1_4_13 GND 16.0
C_1_4_13 Node1_4_13 GND 3.6093750000000004e-07
R_1_4_14_1 Node1_4_14 Node1_4_15 250.00000000000003
R_1_4_14_2 Node1_4_14 Node1_5_14 250.00000000000003
R_1_4_14_3 Node1_4_14 GND 16.0
C_1_4_14 Node1_4_14 GND 3.6093750000000004e-07
R_1_4_15_1 Node1_4_15 Node1_4_16 250.00000000000003
R_1_4_15_2 Node1_4_15 Node1_5_15 250.00000000000003
R_1_4_15_3 Node1_4_15 GND 16.0
C_1_4_15 Node1_4_15 GND 3.6093750000000004e-07
R_1_4_16_1 Node1_4_16 Node1_4_17 250.00000000000003
R_1_4_16_2 Node1_4_16 Node1_5_16 250.00000000000003
R_1_4_16_3 Node1_4_16 GND 16.0
C_1_4_16 Node1_4_16 GND 3.6093750000000004e-07
R_1_4_17_1 Node1_4_17 Node1_4_18 250.00000000000003
R_1_4_17_2 Node1_4_17 Node1_5_17 250.00000000000003
R_1_4_17_3 Node1_4_17 GND 16.0
C_1_4_17 Node1_4_17 GND 3.6093750000000004e-07
R_1_4_18_1 Node1_4_18 Node1_4_19 250.00000000000003
R_1_4_18_2 Node1_4_18 Node1_5_18 250.00000000000003
R_1_4_18_3 Node1_4_18 GND 16.0
C_1_4_18 Node1_4_18 GND 3.6093750000000004e-07
R_1_4_19_1 Node1_4_19 Node1_4_20 250.00000000000003
R_1_4_19_2 Node1_4_19 Node1_5_19 250.00000000000003
R_1_4_19_3 Node1_4_19 GND 16.0
C_1_4_19 Node1_4_19 GND 3.6093750000000004e-07
R_1_4_20_1 Node1_4_20 Node1_4_21 250.00000000000003
R_1_4_20_2 Node1_4_20 Node1_5_20 250.00000000000003
R_1_4_20_3 Node1_4_20 GND 16.0
C_1_4_20 Node1_4_20 GND 3.6093750000000004e-07
R_1_4_21_1 Node1_4_21 Node1_4_22 250.00000000000003
R_1_4_21_2 Node1_4_21 Node1_5_21 250.00000000000003
R_1_4_21_3 Node1_4_21 GND 16.0
C_1_4_21 Node1_4_21 GND 3.6093750000000004e-07
R_1_4_22_1 Node1_4_22 Node1_4_23 250.00000000000003
R_1_4_22_2 Node1_4_22 Node1_5_22 250.00000000000003
R_1_4_22_3 Node1_4_22 GND 16.0
C_1_4_22 Node1_4_22 GND 3.6093750000000004e-07
R_1_4_23_1 Node1_4_23 Node1_4_24 250.00000000000003
R_1_4_23_2 Node1_4_23 Node1_5_23 250.00000000000003
R_1_4_23_3 Node1_4_23 GND 16.0
C_1_4_23 Node1_4_23 GND 3.6093750000000004e-07
R_1_4_24_1 Node1_4_24 Node1_4_25 250.00000000000003
R_1_4_24_2 Node1_4_24 Node1_5_24 250.00000000000003
R_1_4_24_3 Node1_4_24 GND 16.0
C_1_4_24 Node1_4_24 GND 3.6093750000000004e-07
R_1_4_25_1 Node1_4_25 Node1_4_26 250.00000000000003
R_1_4_25_2 Node1_4_25 Node1_5_25 250.00000000000003
R_1_4_25_3 Node1_4_25 GND 16.0
C_1_4_25 Node1_4_25 GND 3.6093750000000004e-07
R_1_4_26_1 Node1_4_26 Node1_4_27 250.00000000000003
R_1_4_26_2 Node1_4_26 Node1_5_26 250.00000000000003
R_1_4_26_3 Node1_4_26 GND 16.0
C_1_4_26 Node1_4_26 GND 3.6093750000000004e-07
R_1_4_27_1 Node1_4_27 Node1_4_28 250.00000000000003
R_1_4_27_2 Node1_4_27 Node1_5_27 250.00000000000003
R_1_4_27_3 Node1_4_27 GND 16.0
C_1_4_27 Node1_4_27 GND 3.6093750000000004e-07
R_1_4_28_1 Node1_4_28 Node1_4_29 250.00000000000003
R_1_4_28_2 Node1_4_28 Node1_5_28 250.00000000000003
R_1_4_28_3 Node1_4_28 GND 16.0
C_1_4_28 Node1_4_28 GND 3.6093750000000004e-07
R_1_4_29_1 Node1_4_29 Node1_4_30 250.00000000000003
R_1_4_29_2 Node1_4_29 Node1_5_29 250.00000000000003
R_1_4_29_3 Node1_4_29 GND 16.0
C_1_4_29 Node1_4_29 GND 3.6093750000000004e-07
R_1_4_30_1 Node1_4_30 Node1_4_31 250.00000000000003
R_1_4_30_2 Node1_4_30 Node1_5_30 250.00000000000003
R_1_4_30_3 Node1_4_30 GND 16.0
C_1_4_30 Node1_4_30 GND 3.6093750000000004e-07
R_1_4_31_1 Node1_4_31 Node1_4_32 250.00000000000003
R_1_4_31_2 Node1_4_31 Node1_5_31 250.00000000000003
R_1_4_31_3 Node1_4_31 GND 16.0
C_1_4_31 Node1_4_31 GND 3.6093750000000004e-07
R_1_4_32_1 Node1_4_32 Node1_4_33 250.00000000000003
R_1_4_32_2 Node1_4_32 Node1_5_32 250.00000000000003
R_1_4_32_3 Node1_4_32 GND 16.0
C_1_4_32 Node1_4_32 GND 3.6093750000000004e-07
R_1_4_33_1 Node1_4_33 Node1_4_34 250.00000000000003
R_1_4_33_2 Node1_4_33 Node1_5_33 250.00000000000003
R_1_4_33_3 Node1_4_33 GND 16.0
C_1_4_33 Node1_4_33 GND 3.6093750000000004e-07
R_1_4_34_1 Node1_4_34 Node1_4_35 250.00000000000003
R_1_4_34_2 Node1_4_34 Node1_5_34 250.00000000000003
R_1_4_34_3 Node1_4_34 GND 16.0
C_1_4_34 Node1_4_34 GND 3.6093750000000004e-07
R_1_4_35_1 Node1_4_35 Node1_4_36 250.00000000000003
R_1_4_35_2 Node1_4_35 Node1_5_35 250.00000000000003
R_1_4_35_3 Node1_4_35 GND 16.0
C_1_4_35 Node1_4_35 GND 3.6093750000000004e-07
R_1_4_36_1 Node1_4_36 Node1_4_37 250.00000000000003
R_1_4_36_2 Node1_4_36 Node1_5_36 250.00000000000003
R_1_4_36_3 Node1_4_36 GND 16.0
C_1_4_36 Node1_4_36 GND 3.6093750000000004e-07
R_1_4_37_1 Node1_4_37 Node1_4_38 250.00000000000003
R_1_4_37_2 Node1_4_37 Node1_5_37 250.00000000000003
R_1_4_37_3 Node1_4_37 GND 16.0
C_1_4_37 Node1_4_37 GND 3.6093750000000004e-07
R_1_4_38_1 Node1_4_38 Node1_4_39 250.00000000000003
R_1_4_38_2 Node1_4_38 Node1_5_38 250.00000000000003
R_1_4_38_3 Node1_4_38 GND 16.0
C_1_4_38 Node1_4_38 GND 3.6093750000000004e-07
R_1_4_39_2 Node1_4_39 Node1_5_39 250.00000000000003
R_1_4_39_3 Node1_4_39 GND 16.0
C_1_4_39 Node1_4_39 GND 3.6093750000000004e-07
R_1_5_0_1 Node1_5_0 Node1_5_1 250.00000000000003
R_1_5_0_2 Node1_5_0 Node1_6_0 250.00000000000003
R_1_5_0_3 Node1_5_0 GND 16.0
C_1_5_0 Node1_5_0 GND 3.6093750000000004e-07
R_1_5_1_1 Node1_5_1 Node1_5_2 250.00000000000003
R_1_5_1_2 Node1_5_1 Node1_6_1 250.00000000000003
R_1_5_1_3 Node1_5_1 GND 16.0
C_1_5_1 Node1_5_1 GND 3.6093750000000004e-07
R_1_5_2_1 Node1_5_2 Node1_5_3 250.00000000000003
R_1_5_2_2 Node1_5_2 Node1_6_2 250.00000000000003
R_1_5_2_3 Node1_5_2 GND 16.0
C_1_5_2 Node1_5_2 GND 3.6093750000000004e-07
R_1_5_3_1 Node1_5_3 Node1_5_4 250.00000000000003
R_1_5_3_2 Node1_5_3 Node1_6_3 250.00000000000003
R_1_5_3_3 Node1_5_3 GND 16.0
C_1_5_3 Node1_5_3 GND 3.6093750000000004e-07
R_1_5_4_1 Node1_5_4 Node1_5_5 250.00000000000003
R_1_5_4_2 Node1_5_4 Node1_6_4 250.00000000000003
R_1_5_4_3 Node1_5_4 GND 16.0
C_1_5_4 Node1_5_4 GND 3.6093750000000004e-07
R_1_5_5_1 Node1_5_5 Node1_5_6 250.00000000000003
R_1_5_5_2 Node1_5_5 Node1_6_5 250.00000000000003
R_1_5_5_3 Node1_5_5 GND 16.0
C_1_5_5 Node1_5_5 GND 3.6093750000000004e-07
R_1_5_6_1 Node1_5_6 Node1_5_7 250.00000000000003
R_1_5_6_2 Node1_5_6 Node1_6_6 250.00000000000003
R_1_5_6_3 Node1_5_6 GND 16.0
C_1_5_6 Node1_5_6 GND 3.6093750000000004e-07
R_1_5_7_1 Node1_5_7 Node1_5_8 250.00000000000003
R_1_5_7_2 Node1_5_7 Node1_6_7 250.00000000000003
R_1_5_7_3 Node1_5_7 GND 16.0
C_1_5_7 Node1_5_7 GND 3.6093750000000004e-07
R_1_5_8_1 Node1_5_8 Node1_5_9 250.00000000000003
R_1_5_8_2 Node1_5_8 Node1_6_8 250.00000000000003
R_1_5_8_3 Node1_5_8 GND 16.0
C_1_5_8 Node1_5_8 GND 3.6093750000000004e-07
R_1_5_9_1 Node1_5_9 Node1_5_10 250.00000000000003
R_1_5_9_2 Node1_5_9 Node1_6_9 250.00000000000003
R_1_5_9_3 Node1_5_9 GND 16.0
C_1_5_9 Node1_5_9 GND 3.6093750000000004e-07
R_1_5_10_1 Node1_5_10 Node1_5_11 250.00000000000003
R_1_5_10_2 Node1_5_10 Node1_6_10 250.00000000000003
R_1_5_10_3 Node1_5_10 GND 16.0
C_1_5_10 Node1_5_10 GND 3.6093750000000004e-07
R_1_5_11_1 Node1_5_11 Node1_5_12 250.00000000000003
R_1_5_11_2 Node1_5_11 Node1_6_11 250.00000000000003
R_1_5_11_3 Node1_5_11 GND 16.0
C_1_5_11 Node1_5_11 GND 3.6093750000000004e-07
R_1_5_12_1 Node1_5_12 Node1_5_13 250.00000000000003
R_1_5_12_2 Node1_5_12 Node1_6_12 250.00000000000003
R_1_5_12_3 Node1_5_12 GND 16.0
C_1_5_12 Node1_5_12 GND 3.6093750000000004e-07
R_1_5_13_1 Node1_5_13 Node1_5_14 250.00000000000003
R_1_5_13_2 Node1_5_13 Node1_6_13 250.00000000000003
R_1_5_13_3 Node1_5_13 GND 16.0
C_1_5_13 Node1_5_13 GND 3.6093750000000004e-07
R_1_5_14_1 Node1_5_14 Node1_5_15 250.00000000000003
R_1_5_14_2 Node1_5_14 Node1_6_14 250.00000000000003
R_1_5_14_3 Node1_5_14 GND 16.0
C_1_5_14 Node1_5_14 GND 3.6093750000000004e-07
R_1_5_15_1 Node1_5_15 Node1_5_16 250.00000000000003
R_1_5_15_2 Node1_5_15 Node1_6_15 250.00000000000003
R_1_5_15_3 Node1_5_15 GND 16.0
C_1_5_15 Node1_5_15 GND 3.6093750000000004e-07
R_1_5_16_1 Node1_5_16 Node1_5_17 250.00000000000003
R_1_5_16_2 Node1_5_16 Node1_6_16 250.00000000000003
R_1_5_16_3 Node1_5_16 GND 16.0
C_1_5_16 Node1_5_16 GND 3.6093750000000004e-07
R_1_5_17_1 Node1_5_17 Node1_5_18 250.00000000000003
R_1_5_17_2 Node1_5_17 Node1_6_17 250.00000000000003
R_1_5_17_3 Node1_5_17 GND 16.0
C_1_5_17 Node1_5_17 GND 3.6093750000000004e-07
R_1_5_18_1 Node1_5_18 Node1_5_19 250.00000000000003
R_1_5_18_2 Node1_5_18 Node1_6_18 250.00000000000003
R_1_5_18_3 Node1_5_18 GND 16.0
C_1_5_18 Node1_5_18 GND 3.6093750000000004e-07
R_1_5_19_1 Node1_5_19 Node1_5_20 250.00000000000003
R_1_5_19_2 Node1_5_19 Node1_6_19 250.00000000000003
R_1_5_19_3 Node1_5_19 GND 16.0
C_1_5_19 Node1_5_19 GND 3.6093750000000004e-07
R_1_5_20_1 Node1_5_20 Node1_5_21 250.00000000000003
R_1_5_20_2 Node1_5_20 Node1_6_20 250.00000000000003
R_1_5_20_3 Node1_5_20 GND 16.0
C_1_5_20 Node1_5_20 GND 3.6093750000000004e-07
R_1_5_21_1 Node1_5_21 Node1_5_22 250.00000000000003
R_1_5_21_2 Node1_5_21 Node1_6_21 250.00000000000003
R_1_5_21_3 Node1_5_21 GND 16.0
C_1_5_21 Node1_5_21 GND 3.6093750000000004e-07
R_1_5_22_1 Node1_5_22 Node1_5_23 250.00000000000003
R_1_5_22_2 Node1_5_22 Node1_6_22 250.00000000000003
R_1_5_22_3 Node1_5_22 GND 16.0
C_1_5_22 Node1_5_22 GND 3.6093750000000004e-07
R_1_5_23_1 Node1_5_23 Node1_5_24 250.00000000000003
R_1_5_23_2 Node1_5_23 Node1_6_23 250.00000000000003
R_1_5_23_3 Node1_5_23 GND 16.0
C_1_5_23 Node1_5_23 GND 3.6093750000000004e-07
R_1_5_24_1 Node1_5_24 Node1_5_25 250.00000000000003
R_1_5_24_2 Node1_5_24 Node1_6_24 250.00000000000003
R_1_5_24_3 Node1_5_24 GND 16.0
C_1_5_24 Node1_5_24 GND 3.6093750000000004e-07
R_1_5_25_1 Node1_5_25 Node1_5_26 250.00000000000003
R_1_5_25_2 Node1_5_25 Node1_6_25 250.00000000000003
R_1_5_25_3 Node1_5_25 GND 16.0
C_1_5_25 Node1_5_25 GND 3.6093750000000004e-07
R_1_5_26_1 Node1_5_26 Node1_5_27 250.00000000000003
R_1_5_26_2 Node1_5_26 Node1_6_26 250.00000000000003
R_1_5_26_3 Node1_5_26 GND 16.0
C_1_5_26 Node1_5_26 GND 3.6093750000000004e-07
R_1_5_27_1 Node1_5_27 Node1_5_28 250.00000000000003
R_1_5_27_2 Node1_5_27 Node1_6_27 250.00000000000003
R_1_5_27_3 Node1_5_27 GND 16.0
C_1_5_27 Node1_5_27 GND 3.6093750000000004e-07
R_1_5_28_1 Node1_5_28 Node1_5_29 250.00000000000003
R_1_5_28_2 Node1_5_28 Node1_6_28 250.00000000000003
R_1_5_28_3 Node1_5_28 GND 16.0
C_1_5_28 Node1_5_28 GND 3.6093750000000004e-07
R_1_5_29_1 Node1_5_29 Node1_5_30 250.00000000000003
R_1_5_29_2 Node1_5_29 Node1_6_29 250.00000000000003
R_1_5_29_3 Node1_5_29 GND 16.0
C_1_5_29 Node1_5_29 GND 3.6093750000000004e-07
R_1_5_30_1 Node1_5_30 Node1_5_31 250.00000000000003
R_1_5_30_2 Node1_5_30 Node1_6_30 250.00000000000003
R_1_5_30_3 Node1_5_30 GND 16.0
C_1_5_30 Node1_5_30 GND 3.6093750000000004e-07
R_1_5_31_1 Node1_5_31 Node1_5_32 250.00000000000003
R_1_5_31_2 Node1_5_31 Node1_6_31 250.00000000000003
R_1_5_31_3 Node1_5_31 GND 16.0
C_1_5_31 Node1_5_31 GND 3.6093750000000004e-07
R_1_5_32_1 Node1_5_32 Node1_5_33 250.00000000000003
R_1_5_32_2 Node1_5_32 Node1_6_32 250.00000000000003
R_1_5_32_3 Node1_5_32 GND 16.0
C_1_5_32 Node1_5_32 GND 3.6093750000000004e-07
R_1_5_33_1 Node1_5_33 Node1_5_34 250.00000000000003
R_1_5_33_2 Node1_5_33 Node1_6_33 250.00000000000003
R_1_5_33_3 Node1_5_33 GND 16.0
C_1_5_33 Node1_5_33 GND 3.6093750000000004e-07
R_1_5_34_1 Node1_5_34 Node1_5_35 250.00000000000003
R_1_5_34_2 Node1_5_34 Node1_6_34 250.00000000000003
R_1_5_34_3 Node1_5_34 GND 16.0
C_1_5_34 Node1_5_34 GND 3.6093750000000004e-07
R_1_5_35_1 Node1_5_35 Node1_5_36 250.00000000000003
R_1_5_35_2 Node1_5_35 Node1_6_35 250.00000000000003
R_1_5_35_3 Node1_5_35 GND 16.0
C_1_5_35 Node1_5_35 GND 3.6093750000000004e-07
R_1_5_36_1 Node1_5_36 Node1_5_37 250.00000000000003
R_1_5_36_2 Node1_5_36 Node1_6_36 250.00000000000003
R_1_5_36_3 Node1_5_36 GND 16.0
C_1_5_36 Node1_5_36 GND 3.6093750000000004e-07
R_1_5_37_1 Node1_5_37 Node1_5_38 250.00000000000003
R_1_5_37_2 Node1_5_37 Node1_6_37 250.00000000000003
R_1_5_37_3 Node1_5_37 GND 16.0
C_1_5_37 Node1_5_37 GND 3.6093750000000004e-07
R_1_5_38_1 Node1_5_38 Node1_5_39 250.00000000000003
R_1_5_38_2 Node1_5_38 Node1_6_38 250.00000000000003
R_1_5_38_3 Node1_5_38 GND 16.0
C_1_5_38 Node1_5_38 GND 3.6093750000000004e-07
R_1_5_39_2 Node1_5_39 Node1_6_39 250.00000000000003
R_1_5_39_3 Node1_5_39 GND 16.0
C_1_5_39 Node1_5_39 GND 3.6093750000000004e-07
R_1_6_0_1 Node1_6_0 Node1_6_1 250.00000000000003
R_1_6_0_2 Node1_6_0 Node1_7_0 250.00000000000003
R_1_6_0_3 Node1_6_0 GND 16.0
C_1_6_0 Node1_6_0 GND 3.6093750000000004e-07
R_1_6_1_1 Node1_6_1 Node1_6_2 250.00000000000003
R_1_6_1_2 Node1_6_1 Node1_7_1 250.00000000000003
R_1_6_1_3 Node1_6_1 GND 16.0
C_1_6_1 Node1_6_1 GND 3.6093750000000004e-07
R_1_6_2_1 Node1_6_2 Node1_6_3 250.00000000000003
R_1_6_2_2 Node1_6_2 Node1_7_2 250.00000000000003
R_1_6_2_3 Node1_6_2 GND 16.0
C_1_6_2 Node1_6_2 GND 3.6093750000000004e-07
R_1_6_3_1 Node1_6_3 Node1_6_4 250.00000000000003
R_1_6_3_2 Node1_6_3 Node1_7_3 250.00000000000003
R_1_6_3_3 Node1_6_3 GND 16.0
C_1_6_3 Node1_6_3 GND 3.6093750000000004e-07
R_1_6_4_1 Node1_6_4 Node1_6_5 250.00000000000003
R_1_6_4_2 Node1_6_4 Node1_7_4 250.00000000000003
R_1_6_4_3 Node1_6_4 GND 16.0
C_1_6_4 Node1_6_4 GND 3.6093750000000004e-07
R_1_6_5_1 Node1_6_5 Node1_6_6 250.00000000000003
R_1_6_5_2 Node1_6_5 Node1_7_5 250.00000000000003
R_1_6_5_3 Node1_6_5 GND 16.0
C_1_6_5 Node1_6_5 GND 3.6093750000000004e-07
R_1_6_6_1 Node1_6_6 Node1_6_7 250.00000000000003
R_1_6_6_2 Node1_6_6 Node1_7_6 250.00000000000003
R_1_6_6_3 Node1_6_6 GND 16.0
C_1_6_6 Node1_6_6 GND 3.6093750000000004e-07
R_1_6_7_1 Node1_6_7 Node1_6_8 250.00000000000003
R_1_6_7_2 Node1_6_7 Node1_7_7 250.00000000000003
R_1_6_7_3 Node1_6_7 GND 16.0
C_1_6_7 Node1_6_7 GND 3.6093750000000004e-07
R_1_6_8_1 Node1_6_8 Node1_6_9 250.00000000000003
R_1_6_8_2 Node1_6_8 Node1_7_8 250.00000000000003
R_1_6_8_3 Node1_6_8 GND 16.0
C_1_6_8 Node1_6_8 GND 3.6093750000000004e-07
R_1_6_9_1 Node1_6_9 Node1_6_10 250.00000000000003
R_1_6_9_2 Node1_6_9 Node1_7_9 250.00000000000003
R_1_6_9_3 Node1_6_9 GND 16.0
C_1_6_9 Node1_6_9 GND 3.6093750000000004e-07
R_1_6_10_1 Node1_6_10 Node1_6_11 250.00000000000003
R_1_6_10_2 Node1_6_10 Node1_7_10 250.00000000000003
R_1_6_10_3 Node1_6_10 GND 16.0
C_1_6_10 Node1_6_10 GND 3.6093750000000004e-07
R_1_6_11_1 Node1_6_11 Node1_6_12 250.00000000000003
R_1_6_11_2 Node1_6_11 Node1_7_11 250.00000000000003
R_1_6_11_3 Node1_6_11 GND 16.0
C_1_6_11 Node1_6_11 GND 3.6093750000000004e-07
R_1_6_12_1 Node1_6_12 Node1_6_13 250.00000000000003
R_1_6_12_2 Node1_6_12 Node1_7_12 250.00000000000003
R_1_6_12_3 Node1_6_12 GND 16.0
C_1_6_12 Node1_6_12 GND 3.6093750000000004e-07
R_1_6_13_1 Node1_6_13 Node1_6_14 250.00000000000003
R_1_6_13_2 Node1_6_13 Node1_7_13 250.00000000000003
R_1_6_13_3 Node1_6_13 GND 16.0
C_1_6_13 Node1_6_13 GND 3.6093750000000004e-07
R_1_6_14_1 Node1_6_14 Node1_6_15 250.00000000000003
R_1_6_14_2 Node1_6_14 Node1_7_14 250.00000000000003
R_1_6_14_3 Node1_6_14 GND 16.0
C_1_6_14 Node1_6_14 GND 3.6093750000000004e-07
R_1_6_15_1 Node1_6_15 Node1_6_16 250.00000000000003
R_1_6_15_2 Node1_6_15 Node1_7_15 250.00000000000003
R_1_6_15_3 Node1_6_15 GND 16.0
C_1_6_15 Node1_6_15 GND 3.6093750000000004e-07
R_1_6_16_1 Node1_6_16 Node1_6_17 250.00000000000003
R_1_6_16_2 Node1_6_16 Node1_7_16 250.00000000000003
R_1_6_16_3 Node1_6_16 GND 16.0
C_1_6_16 Node1_6_16 GND 3.6093750000000004e-07
R_1_6_17_1 Node1_6_17 Node1_6_18 250.00000000000003
R_1_6_17_2 Node1_6_17 Node1_7_17 250.00000000000003
R_1_6_17_3 Node1_6_17 GND 16.0
C_1_6_17 Node1_6_17 GND 3.6093750000000004e-07
R_1_6_18_1 Node1_6_18 Node1_6_19 250.00000000000003
R_1_6_18_2 Node1_6_18 Node1_7_18 250.00000000000003
R_1_6_18_3 Node1_6_18 GND 16.0
C_1_6_18 Node1_6_18 GND 3.6093750000000004e-07
R_1_6_19_1 Node1_6_19 Node1_6_20 250.00000000000003
R_1_6_19_2 Node1_6_19 Node1_7_19 250.00000000000003
R_1_6_19_3 Node1_6_19 GND 16.0
C_1_6_19 Node1_6_19 GND 3.6093750000000004e-07
R_1_6_20_1 Node1_6_20 Node1_6_21 250.00000000000003
R_1_6_20_2 Node1_6_20 Node1_7_20 250.00000000000003
R_1_6_20_3 Node1_6_20 GND 16.0
C_1_6_20 Node1_6_20 GND 3.6093750000000004e-07
R_1_6_21_1 Node1_6_21 Node1_6_22 250.00000000000003
R_1_6_21_2 Node1_6_21 Node1_7_21 250.00000000000003
R_1_6_21_3 Node1_6_21 GND 16.0
C_1_6_21 Node1_6_21 GND 3.6093750000000004e-07
R_1_6_22_1 Node1_6_22 Node1_6_23 250.00000000000003
R_1_6_22_2 Node1_6_22 Node1_7_22 250.00000000000003
R_1_6_22_3 Node1_6_22 GND 16.0
C_1_6_22 Node1_6_22 GND 3.6093750000000004e-07
R_1_6_23_1 Node1_6_23 Node1_6_24 250.00000000000003
R_1_6_23_2 Node1_6_23 Node1_7_23 250.00000000000003
R_1_6_23_3 Node1_6_23 GND 16.0
C_1_6_23 Node1_6_23 GND 3.6093750000000004e-07
R_1_6_24_1 Node1_6_24 Node1_6_25 250.00000000000003
R_1_6_24_2 Node1_6_24 Node1_7_24 250.00000000000003
R_1_6_24_3 Node1_6_24 GND 16.0
C_1_6_24 Node1_6_24 GND 3.6093750000000004e-07
R_1_6_25_1 Node1_6_25 Node1_6_26 250.00000000000003
R_1_6_25_2 Node1_6_25 Node1_7_25 250.00000000000003
R_1_6_25_3 Node1_6_25 GND 16.0
C_1_6_25 Node1_6_25 GND 3.6093750000000004e-07
R_1_6_26_1 Node1_6_26 Node1_6_27 250.00000000000003
R_1_6_26_2 Node1_6_26 Node1_7_26 250.00000000000003
R_1_6_26_3 Node1_6_26 GND 16.0
C_1_6_26 Node1_6_26 GND 3.6093750000000004e-07
R_1_6_27_1 Node1_6_27 Node1_6_28 250.00000000000003
R_1_6_27_2 Node1_6_27 Node1_7_27 250.00000000000003
R_1_6_27_3 Node1_6_27 GND 16.0
C_1_6_27 Node1_6_27 GND 3.6093750000000004e-07
R_1_6_28_1 Node1_6_28 Node1_6_29 250.00000000000003
R_1_6_28_2 Node1_6_28 Node1_7_28 250.00000000000003
R_1_6_28_3 Node1_6_28 GND 16.0
C_1_6_28 Node1_6_28 GND 3.6093750000000004e-07
R_1_6_29_1 Node1_6_29 Node1_6_30 250.00000000000003
R_1_6_29_2 Node1_6_29 Node1_7_29 250.00000000000003
R_1_6_29_3 Node1_6_29 GND 16.0
C_1_6_29 Node1_6_29 GND 3.6093750000000004e-07
R_1_6_30_1 Node1_6_30 Node1_6_31 250.00000000000003
R_1_6_30_2 Node1_6_30 Node1_7_30 250.00000000000003
R_1_6_30_3 Node1_6_30 GND 16.0
C_1_6_30 Node1_6_30 GND 3.6093750000000004e-07
R_1_6_31_1 Node1_6_31 Node1_6_32 250.00000000000003
R_1_6_31_2 Node1_6_31 Node1_7_31 250.00000000000003
R_1_6_31_3 Node1_6_31 GND 16.0
C_1_6_31 Node1_6_31 GND 3.6093750000000004e-07
R_1_6_32_1 Node1_6_32 Node1_6_33 250.00000000000003
R_1_6_32_2 Node1_6_32 Node1_7_32 250.00000000000003
R_1_6_32_3 Node1_6_32 GND 16.0
C_1_6_32 Node1_6_32 GND 3.6093750000000004e-07
R_1_6_33_1 Node1_6_33 Node1_6_34 250.00000000000003
R_1_6_33_2 Node1_6_33 Node1_7_33 250.00000000000003
R_1_6_33_3 Node1_6_33 GND 16.0
C_1_6_33 Node1_6_33 GND 3.6093750000000004e-07
R_1_6_34_1 Node1_6_34 Node1_6_35 250.00000000000003
R_1_6_34_2 Node1_6_34 Node1_7_34 250.00000000000003
R_1_6_34_3 Node1_6_34 GND 16.0
C_1_6_34 Node1_6_34 GND 3.6093750000000004e-07
R_1_6_35_1 Node1_6_35 Node1_6_36 250.00000000000003
R_1_6_35_2 Node1_6_35 Node1_7_35 250.00000000000003
R_1_6_35_3 Node1_6_35 GND 16.0
C_1_6_35 Node1_6_35 GND 3.6093750000000004e-07
R_1_6_36_1 Node1_6_36 Node1_6_37 250.00000000000003
R_1_6_36_2 Node1_6_36 Node1_7_36 250.00000000000003
R_1_6_36_3 Node1_6_36 GND 16.0
C_1_6_36 Node1_6_36 GND 3.6093750000000004e-07
R_1_6_37_1 Node1_6_37 Node1_6_38 250.00000000000003
R_1_6_37_2 Node1_6_37 Node1_7_37 250.00000000000003
R_1_6_37_3 Node1_6_37 GND 16.0
C_1_6_37 Node1_6_37 GND 3.6093750000000004e-07
R_1_6_38_1 Node1_6_38 Node1_6_39 250.00000000000003
R_1_6_38_2 Node1_6_38 Node1_7_38 250.00000000000003
R_1_6_38_3 Node1_6_38 GND 16.0
C_1_6_38 Node1_6_38 GND 3.6093750000000004e-07
R_1_6_39_2 Node1_6_39 Node1_7_39 250.00000000000003
R_1_6_39_3 Node1_6_39 GND 16.0
C_1_6_39 Node1_6_39 GND 3.6093750000000004e-07
R_1_7_0_1 Node1_7_0 Node1_7_1 250.00000000000003
R_1_7_0_2 Node1_7_0 Node1_8_0 250.00000000000003
R_1_7_0_3 Node1_7_0 GND 16.0
C_1_7_0 Node1_7_0 GND 3.6093750000000004e-07
R_1_7_1_1 Node1_7_1 Node1_7_2 250.00000000000003
R_1_7_1_2 Node1_7_1 Node1_8_1 250.00000000000003
R_1_7_1_3 Node1_7_1 GND 16.0
C_1_7_1 Node1_7_1 GND 3.6093750000000004e-07
R_1_7_2_1 Node1_7_2 Node1_7_3 250.00000000000003
R_1_7_2_2 Node1_7_2 Node1_8_2 250.00000000000003
R_1_7_2_3 Node1_7_2 GND 16.0
C_1_7_2 Node1_7_2 GND 3.6093750000000004e-07
R_1_7_3_1 Node1_7_3 Node1_7_4 250.00000000000003
R_1_7_3_2 Node1_7_3 Node1_8_3 250.00000000000003
R_1_7_3_3 Node1_7_3 GND 16.0
C_1_7_3 Node1_7_3 GND 3.6093750000000004e-07
R_1_7_4_1 Node1_7_4 Node1_7_5 250.00000000000003
R_1_7_4_2 Node1_7_4 Node1_8_4 250.00000000000003
R_1_7_4_3 Node1_7_4 GND 16.0
C_1_7_4 Node1_7_4 GND 3.6093750000000004e-07
R_1_7_5_1 Node1_7_5 Node1_7_6 250.00000000000003
R_1_7_5_2 Node1_7_5 Node1_8_5 250.00000000000003
R_1_7_5_3 Node1_7_5 GND 16.0
C_1_7_5 Node1_7_5 GND 3.6093750000000004e-07
R_1_7_6_1 Node1_7_6 Node1_7_7 250.00000000000003
R_1_7_6_2 Node1_7_6 Node1_8_6 250.00000000000003
R_1_7_6_3 Node1_7_6 GND 16.0
C_1_7_6 Node1_7_6 GND 3.6093750000000004e-07
R_1_7_7_1 Node1_7_7 Node1_7_8 250.00000000000003
R_1_7_7_2 Node1_7_7 Node1_8_7 250.00000000000003
R_1_7_7_3 Node1_7_7 GND 16.0
C_1_7_7 Node1_7_7 GND 3.6093750000000004e-07
R_1_7_8_1 Node1_7_8 Node1_7_9 250.00000000000003
R_1_7_8_2 Node1_7_8 Node1_8_8 250.00000000000003
R_1_7_8_3 Node1_7_8 GND 16.0
C_1_7_8 Node1_7_8 GND 3.6093750000000004e-07
R_1_7_9_1 Node1_7_9 Node1_7_10 250.00000000000003
R_1_7_9_2 Node1_7_9 Node1_8_9 250.00000000000003
R_1_7_9_3 Node1_7_9 GND 16.0
C_1_7_9 Node1_7_9 GND 3.6093750000000004e-07
R_1_7_10_1 Node1_7_10 Node1_7_11 250.00000000000003
R_1_7_10_2 Node1_7_10 Node1_8_10 250.00000000000003
R_1_7_10_3 Node1_7_10 GND 16.0
C_1_7_10 Node1_7_10 GND 3.6093750000000004e-07
R_1_7_11_1 Node1_7_11 Node1_7_12 250.00000000000003
R_1_7_11_2 Node1_7_11 Node1_8_11 250.00000000000003
R_1_7_11_3 Node1_7_11 GND 16.0
C_1_7_11 Node1_7_11 GND 3.6093750000000004e-07
R_1_7_12_1 Node1_7_12 Node1_7_13 250.00000000000003
R_1_7_12_2 Node1_7_12 Node1_8_12 250.00000000000003
R_1_7_12_3 Node1_7_12 GND 16.0
C_1_7_12 Node1_7_12 GND 3.6093750000000004e-07
R_1_7_13_1 Node1_7_13 Node1_7_14 250.00000000000003
R_1_7_13_2 Node1_7_13 Node1_8_13 250.00000000000003
R_1_7_13_3 Node1_7_13 GND 16.0
C_1_7_13 Node1_7_13 GND 3.6093750000000004e-07
R_1_7_14_1 Node1_7_14 Node1_7_15 250.00000000000003
R_1_7_14_2 Node1_7_14 Node1_8_14 250.00000000000003
R_1_7_14_3 Node1_7_14 GND 16.0
C_1_7_14 Node1_7_14 GND 3.6093750000000004e-07
R_1_7_15_1 Node1_7_15 Node1_7_16 250.00000000000003
R_1_7_15_2 Node1_7_15 Node1_8_15 250.00000000000003
R_1_7_15_3 Node1_7_15 GND 16.0
C_1_7_15 Node1_7_15 GND 3.6093750000000004e-07
R_1_7_16_1 Node1_7_16 Node1_7_17 250.00000000000003
R_1_7_16_2 Node1_7_16 Node1_8_16 250.00000000000003
R_1_7_16_3 Node1_7_16 GND 16.0
C_1_7_16 Node1_7_16 GND 3.6093750000000004e-07
R_1_7_17_1 Node1_7_17 Node1_7_18 250.00000000000003
R_1_7_17_2 Node1_7_17 Node1_8_17 250.00000000000003
R_1_7_17_3 Node1_7_17 GND 16.0
C_1_7_17 Node1_7_17 GND 3.6093750000000004e-07
R_1_7_18_1 Node1_7_18 Node1_7_19 250.00000000000003
R_1_7_18_2 Node1_7_18 Node1_8_18 250.00000000000003
R_1_7_18_3 Node1_7_18 GND 16.0
C_1_7_18 Node1_7_18 GND 3.6093750000000004e-07
R_1_7_19_1 Node1_7_19 Node1_7_20 250.00000000000003
R_1_7_19_2 Node1_7_19 Node1_8_19 250.00000000000003
R_1_7_19_3 Node1_7_19 GND 16.0
C_1_7_19 Node1_7_19 GND 3.6093750000000004e-07
R_1_7_20_1 Node1_7_20 Node1_7_21 250.00000000000003
R_1_7_20_2 Node1_7_20 Node1_8_20 250.00000000000003
R_1_7_20_3 Node1_7_20 GND 16.0
C_1_7_20 Node1_7_20 GND 3.6093750000000004e-07
R_1_7_21_1 Node1_7_21 Node1_7_22 250.00000000000003
R_1_7_21_2 Node1_7_21 Node1_8_21 250.00000000000003
R_1_7_21_3 Node1_7_21 GND 16.0
C_1_7_21 Node1_7_21 GND 3.6093750000000004e-07
R_1_7_22_1 Node1_7_22 Node1_7_23 250.00000000000003
R_1_7_22_2 Node1_7_22 Node1_8_22 250.00000000000003
R_1_7_22_3 Node1_7_22 GND 16.0
C_1_7_22 Node1_7_22 GND 3.6093750000000004e-07
R_1_7_23_1 Node1_7_23 Node1_7_24 250.00000000000003
R_1_7_23_2 Node1_7_23 Node1_8_23 250.00000000000003
R_1_7_23_3 Node1_7_23 GND 16.0
C_1_7_23 Node1_7_23 GND 3.6093750000000004e-07
R_1_7_24_1 Node1_7_24 Node1_7_25 250.00000000000003
R_1_7_24_2 Node1_7_24 Node1_8_24 250.00000000000003
R_1_7_24_3 Node1_7_24 GND 16.0
C_1_7_24 Node1_7_24 GND 3.6093750000000004e-07
R_1_7_25_1 Node1_7_25 Node1_7_26 250.00000000000003
R_1_7_25_2 Node1_7_25 Node1_8_25 250.00000000000003
R_1_7_25_3 Node1_7_25 GND 16.0
C_1_7_25 Node1_7_25 GND 3.6093750000000004e-07
R_1_7_26_1 Node1_7_26 Node1_7_27 250.00000000000003
R_1_7_26_2 Node1_7_26 Node1_8_26 250.00000000000003
R_1_7_26_3 Node1_7_26 GND 16.0
C_1_7_26 Node1_7_26 GND 3.6093750000000004e-07
R_1_7_27_1 Node1_7_27 Node1_7_28 250.00000000000003
R_1_7_27_2 Node1_7_27 Node1_8_27 250.00000000000003
R_1_7_27_3 Node1_7_27 GND 16.0
C_1_7_27 Node1_7_27 GND 3.6093750000000004e-07
R_1_7_28_1 Node1_7_28 Node1_7_29 250.00000000000003
R_1_7_28_2 Node1_7_28 Node1_8_28 250.00000000000003
R_1_7_28_3 Node1_7_28 GND 16.0
C_1_7_28 Node1_7_28 GND 3.6093750000000004e-07
R_1_7_29_1 Node1_7_29 Node1_7_30 250.00000000000003
R_1_7_29_2 Node1_7_29 Node1_8_29 250.00000000000003
R_1_7_29_3 Node1_7_29 GND 16.0
C_1_7_29 Node1_7_29 GND 3.6093750000000004e-07
R_1_7_30_1 Node1_7_30 Node1_7_31 250.00000000000003
R_1_7_30_2 Node1_7_30 Node1_8_30 250.00000000000003
R_1_7_30_3 Node1_7_30 GND 16.0
C_1_7_30 Node1_7_30 GND 3.6093750000000004e-07
R_1_7_31_1 Node1_7_31 Node1_7_32 250.00000000000003
R_1_7_31_2 Node1_7_31 Node1_8_31 250.00000000000003
R_1_7_31_3 Node1_7_31 GND 16.0
C_1_7_31 Node1_7_31 GND 3.6093750000000004e-07
R_1_7_32_1 Node1_7_32 Node1_7_33 250.00000000000003
R_1_7_32_2 Node1_7_32 Node1_8_32 250.00000000000003
R_1_7_32_3 Node1_7_32 GND 16.0
C_1_7_32 Node1_7_32 GND 3.6093750000000004e-07
R_1_7_33_1 Node1_7_33 Node1_7_34 250.00000000000003
R_1_7_33_2 Node1_7_33 Node1_8_33 250.00000000000003
R_1_7_33_3 Node1_7_33 GND 16.0
C_1_7_33 Node1_7_33 GND 3.6093750000000004e-07
R_1_7_34_1 Node1_7_34 Node1_7_35 250.00000000000003
R_1_7_34_2 Node1_7_34 Node1_8_34 250.00000000000003
R_1_7_34_3 Node1_7_34 GND 16.0
C_1_7_34 Node1_7_34 GND 3.6093750000000004e-07
R_1_7_35_1 Node1_7_35 Node1_7_36 250.00000000000003
R_1_7_35_2 Node1_7_35 Node1_8_35 250.00000000000003
R_1_7_35_3 Node1_7_35 GND 16.0
C_1_7_35 Node1_7_35 GND 3.6093750000000004e-07
R_1_7_36_1 Node1_7_36 Node1_7_37 250.00000000000003
R_1_7_36_2 Node1_7_36 Node1_8_36 250.00000000000003
R_1_7_36_3 Node1_7_36 GND 16.0
C_1_7_36 Node1_7_36 GND 3.6093750000000004e-07
R_1_7_37_1 Node1_7_37 Node1_7_38 250.00000000000003
R_1_7_37_2 Node1_7_37 Node1_8_37 250.00000000000003
R_1_7_37_3 Node1_7_37 GND 16.0
C_1_7_37 Node1_7_37 GND 3.6093750000000004e-07
R_1_7_38_1 Node1_7_38 Node1_7_39 250.00000000000003
R_1_7_38_2 Node1_7_38 Node1_8_38 250.00000000000003
R_1_7_38_3 Node1_7_38 GND 16.0
C_1_7_38 Node1_7_38 GND 3.6093750000000004e-07
R_1_7_39_2 Node1_7_39 Node1_8_39 250.00000000000003
R_1_7_39_3 Node1_7_39 GND 16.0
C_1_7_39 Node1_7_39 GND 3.6093750000000004e-07
R_1_8_0_1 Node1_8_0 Node1_8_1 250.00000000000003
R_1_8_0_2 Node1_8_0 Node1_9_0 250.00000000000003
R_1_8_0_3 Node1_8_0 GND 16.0
C_1_8_0 Node1_8_0 GND 3.6093750000000004e-07
R_1_8_1_1 Node1_8_1 Node1_8_2 250.00000000000003
R_1_8_1_2 Node1_8_1 Node1_9_1 250.00000000000003
R_1_8_1_3 Node1_8_1 GND 16.0
C_1_8_1 Node1_8_1 GND 3.6093750000000004e-07
R_1_8_2_1 Node1_8_2 Node1_8_3 250.00000000000003
R_1_8_2_2 Node1_8_2 Node1_9_2 250.00000000000003
R_1_8_2_3 Node1_8_2 GND 16.0
C_1_8_2 Node1_8_2 GND 3.6093750000000004e-07
R_1_8_3_1 Node1_8_3 Node1_8_4 250.00000000000003
R_1_8_3_2 Node1_8_3 Node1_9_3 250.00000000000003
R_1_8_3_3 Node1_8_3 GND 16.0
C_1_8_3 Node1_8_3 GND 3.6093750000000004e-07
R_1_8_4_1 Node1_8_4 Node1_8_5 250.00000000000003
R_1_8_4_2 Node1_8_4 Node1_9_4 250.00000000000003
R_1_8_4_3 Node1_8_4 GND 16.0
C_1_8_4 Node1_8_4 GND 3.6093750000000004e-07
R_1_8_5_1 Node1_8_5 Node1_8_6 250.00000000000003
R_1_8_5_2 Node1_8_5 Node1_9_5 250.00000000000003
R_1_8_5_3 Node1_8_5 GND 16.0
C_1_8_5 Node1_8_5 GND 3.6093750000000004e-07
R_1_8_6_1 Node1_8_6 Node1_8_7 250.00000000000003
R_1_8_6_2 Node1_8_6 Node1_9_6 250.00000000000003
R_1_8_6_3 Node1_8_6 GND 16.0
C_1_8_6 Node1_8_6 GND 3.6093750000000004e-07
R_1_8_7_1 Node1_8_7 Node1_8_8 250.00000000000003
R_1_8_7_2 Node1_8_7 Node1_9_7 250.00000000000003
R_1_8_7_3 Node1_8_7 GND 16.0
C_1_8_7 Node1_8_7 GND 3.6093750000000004e-07
R_1_8_8_1 Node1_8_8 Node1_8_9 250.00000000000003
R_1_8_8_2 Node1_8_8 Node1_9_8 250.00000000000003
R_1_8_8_3 Node1_8_8 GND 16.0
C_1_8_8 Node1_8_8 GND 3.6093750000000004e-07
R_1_8_9_1 Node1_8_9 Node1_8_10 250.00000000000003
R_1_8_9_2 Node1_8_9 Node1_9_9 250.00000000000003
R_1_8_9_3 Node1_8_9 GND 16.0
C_1_8_9 Node1_8_9 GND 3.6093750000000004e-07
R_1_8_10_1 Node1_8_10 Node1_8_11 250.00000000000003
R_1_8_10_2 Node1_8_10 Node1_9_10 250.00000000000003
R_1_8_10_3 Node1_8_10 GND 16.0
C_1_8_10 Node1_8_10 GND 3.6093750000000004e-07
R_1_8_11_1 Node1_8_11 Node1_8_12 250.00000000000003
R_1_8_11_2 Node1_8_11 Node1_9_11 250.00000000000003
R_1_8_11_3 Node1_8_11 GND 16.0
C_1_8_11 Node1_8_11 GND 3.6093750000000004e-07
R_1_8_12_1 Node1_8_12 Node1_8_13 250.00000000000003
R_1_8_12_2 Node1_8_12 Node1_9_12 250.00000000000003
R_1_8_12_3 Node1_8_12 GND 16.0
C_1_8_12 Node1_8_12 GND 3.6093750000000004e-07
R_1_8_13_1 Node1_8_13 Node1_8_14 250.00000000000003
R_1_8_13_2 Node1_8_13 Node1_9_13 250.00000000000003
R_1_8_13_3 Node1_8_13 GND 16.0
C_1_8_13 Node1_8_13 GND 3.6093750000000004e-07
R_1_8_14_1 Node1_8_14 Node1_8_15 250.00000000000003
R_1_8_14_2 Node1_8_14 Node1_9_14 250.00000000000003
R_1_8_14_3 Node1_8_14 GND 16.0
C_1_8_14 Node1_8_14 GND 3.6093750000000004e-07
R_1_8_15_1 Node1_8_15 Node1_8_16 250.00000000000003
R_1_8_15_2 Node1_8_15 Node1_9_15 250.00000000000003
R_1_8_15_3 Node1_8_15 GND 16.0
C_1_8_15 Node1_8_15 GND 3.6093750000000004e-07
R_1_8_16_1 Node1_8_16 Node1_8_17 250.00000000000003
R_1_8_16_2 Node1_8_16 Node1_9_16 250.00000000000003
R_1_8_16_3 Node1_8_16 GND 16.0
C_1_8_16 Node1_8_16 GND 3.6093750000000004e-07
R_1_8_17_1 Node1_8_17 Node1_8_18 250.00000000000003
R_1_8_17_2 Node1_8_17 Node1_9_17 250.00000000000003
R_1_8_17_3 Node1_8_17 GND 16.0
C_1_8_17 Node1_8_17 GND 3.6093750000000004e-07
R_1_8_18_1 Node1_8_18 Node1_8_19 250.00000000000003
R_1_8_18_2 Node1_8_18 Node1_9_18 250.00000000000003
R_1_8_18_3 Node1_8_18 GND 16.0
C_1_8_18 Node1_8_18 GND 3.6093750000000004e-07
R_1_8_19_1 Node1_8_19 Node1_8_20 250.00000000000003
R_1_8_19_2 Node1_8_19 Node1_9_19 250.00000000000003
R_1_8_19_3 Node1_8_19 GND 16.0
C_1_8_19 Node1_8_19 GND 3.6093750000000004e-07
R_1_8_20_1 Node1_8_20 Node1_8_21 250.00000000000003
R_1_8_20_2 Node1_8_20 Node1_9_20 250.00000000000003
R_1_8_20_3 Node1_8_20 GND 16.0
C_1_8_20 Node1_8_20 GND 3.6093750000000004e-07
R_1_8_21_1 Node1_8_21 Node1_8_22 250.00000000000003
R_1_8_21_2 Node1_8_21 Node1_9_21 250.00000000000003
R_1_8_21_3 Node1_8_21 GND 16.0
C_1_8_21 Node1_8_21 GND 3.6093750000000004e-07
R_1_8_22_1 Node1_8_22 Node1_8_23 250.00000000000003
R_1_8_22_2 Node1_8_22 Node1_9_22 250.00000000000003
R_1_8_22_3 Node1_8_22 GND 16.0
C_1_8_22 Node1_8_22 GND 3.6093750000000004e-07
R_1_8_23_1 Node1_8_23 Node1_8_24 250.00000000000003
R_1_8_23_2 Node1_8_23 Node1_9_23 250.00000000000003
R_1_8_23_3 Node1_8_23 GND 16.0
C_1_8_23 Node1_8_23 GND 3.6093750000000004e-07
R_1_8_24_1 Node1_8_24 Node1_8_25 250.00000000000003
R_1_8_24_2 Node1_8_24 Node1_9_24 250.00000000000003
R_1_8_24_3 Node1_8_24 GND 16.0
C_1_8_24 Node1_8_24 GND 3.6093750000000004e-07
R_1_8_25_1 Node1_8_25 Node1_8_26 250.00000000000003
R_1_8_25_2 Node1_8_25 Node1_9_25 250.00000000000003
R_1_8_25_3 Node1_8_25 GND 16.0
C_1_8_25 Node1_8_25 GND 3.6093750000000004e-07
R_1_8_26_1 Node1_8_26 Node1_8_27 250.00000000000003
R_1_8_26_2 Node1_8_26 Node1_9_26 250.00000000000003
R_1_8_26_3 Node1_8_26 GND 16.0
C_1_8_26 Node1_8_26 GND 3.6093750000000004e-07
R_1_8_27_1 Node1_8_27 Node1_8_28 250.00000000000003
R_1_8_27_2 Node1_8_27 Node1_9_27 250.00000000000003
R_1_8_27_3 Node1_8_27 GND 16.0
C_1_8_27 Node1_8_27 GND 3.6093750000000004e-07
R_1_8_28_1 Node1_8_28 Node1_8_29 250.00000000000003
R_1_8_28_2 Node1_8_28 Node1_9_28 250.00000000000003
R_1_8_28_3 Node1_8_28 GND 16.0
C_1_8_28 Node1_8_28 GND 3.6093750000000004e-07
R_1_8_29_1 Node1_8_29 Node1_8_30 250.00000000000003
R_1_8_29_2 Node1_8_29 Node1_9_29 250.00000000000003
R_1_8_29_3 Node1_8_29 GND 16.0
C_1_8_29 Node1_8_29 GND 3.6093750000000004e-07
R_1_8_30_1 Node1_8_30 Node1_8_31 250.00000000000003
R_1_8_30_2 Node1_8_30 Node1_9_30 250.00000000000003
R_1_8_30_3 Node1_8_30 GND 16.0
C_1_8_30 Node1_8_30 GND 3.6093750000000004e-07
R_1_8_31_1 Node1_8_31 Node1_8_32 250.00000000000003
R_1_8_31_2 Node1_8_31 Node1_9_31 250.00000000000003
R_1_8_31_3 Node1_8_31 GND 16.0
C_1_8_31 Node1_8_31 GND 3.6093750000000004e-07
R_1_8_32_1 Node1_8_32 Node1_8_33 250.00000000000003
R_1_8_32_2 Node1_8_32 Node1_9_32 250.00000000000003
R_1_8_32_3 Node1_8_32 GND 16.0
C_1_8_32 Node1_8_32 GND 3.6093750000000004e-07
R_1_8_33_1 Node1_8_33 Node1_8_34 250.00000000000003
R_1_8_33_2 Node1_8_33 Node1_9_33 250.00000000000003
R_1_8_33_3 Node1_8_33 GND 16.0
C_1_8_33 Node1_8_33 GND 3.6093750000000004e-07
R_1_8_34_1 Node1_8_34 Node1_8_35 250.00000000000003
R_1_8_34_2 Node1_8_34 Node1_9_34 250.00000000000003
R_1_8_34_3 Node1_8_34 GND 16.0
C_1_8_34 Node1_8_34 GND 3.6093750000000004e-07
R_1_8_35_1 Node1_8_35 Node1_8_36 250.00000000000003
R_1_8_35_2 Node1_8_35 Node1_9_35 250.00000000000003
R_1_8_35_3 Node1_8_35 GND 16.0
C_1_8_35 Node1_8_35 GND 3.6093750000000004e-07
R_1_8_36_1 Node1_8_36 Node1_8_37 250.00000000000003
R_1_8_36_2 Node1_8_36 Node1_9_36 250.00000000000003
R_1_8_36_3 Node1_8_36 GND 16.0
C_1_8_36 Node1_8_36 GND 3.6093750000000004e-07
R_1_8_37_1 Node1_8_37 Node1_8_38 250.00000000000003
R_1_8_37_2 Node1_8_37 Node1_9_37 250.00000000000003
R_1_8_37_3 Node1_8_37 GND 16.0
C_1_8_37 Node1_8_37 GND 3.6093750000000004e-07
R_1_8_38_1 Node1_8_38 Node1_8_39 250.00000000000003
R_1_8_38_2 Node1_8_38 Node1_9_38 250.00000000000003
R_1_8_38_3 Node1_8_38 GND 16.0
C_1_8_38 Node1_8_38 GND 3.6093750000000004e-07
R_1_8_39_2 Node1_8_39 Node1_9_39 250.00000000000003
R_1_8_39_3 Node1_8_39 GND 16.0
C_1_8_39 Node1_8_39 GND 3.6093750000000004e-07
R_1_9_0_1 Node1_9_0 Node1_9_1 250.00000000000003
R_1_9_0_2 Node1_9_0 Node1_10_0 250.00000000000003
R_1_9_0_3 Node1_9_0 GND 16.0
C_1_9_0 Node1_9_0 GND 3.6093750000000004e-07
R_1_9_1_1 Node1_9_1 Node1_9_2 250.00000000000003
R_1_9_1_2 Node1_9_1 Node1_10_1 250.00000000000003
R_1_9_1_3 Node1_9_1 GND 16.0
C_1_9_1 Node1_9_1 GND 3.6093750000000004e-07
R_1_9_2_1 Node1_9_2 Node1_9_3 250.00000000000003
R_1_9_2_2 Node1_9_2 Node1_10_2 250.00000000000003
R_1_9_2_3 Node1_9_2 GND 16.0
C_1_9_2 Node1_9_2 GND 3.6093750000000004e-07
R_1_9_3_1 Node1_9_3 Node1_9_4 250.00000000000003
R_1_9_3_2 Node1_9_3 Node1_10_3 250.00000000000003
R_1_9_3_3 Node1_9_3 GND 16.0
C_1_9_3 Node1_9_3 GND 3.6093750000000004e-07
R_1_9_4_1 Node1_9_4 Node1_9_5 250.00000000000003
R_1_9_4_2 Node1_9_4 Node1_10_4 250.00000000000003
R_1_9_4_3 Node1_9_4 GND 16.0
C_1_9_4 Node1_9_4 GND 3.6093750000000004e-07
R_1_9_5_1 Node1_9_5 Node1_9_6 250.00000000000003
R_1_9_5_2 Node1_9_5 Node1_10_5 250.00000000000003
R_1_9_5_3 Node1_9_5 GND 16.0
C_1_9_5 Node1_9_5 GND 3.6093750000000004e-07
R_1_9_6_1 Node1_9_6 Node1_9_7 250.00000000000003
R_1_9_6_2 Node1_9_6 Node1_10_6 250.00000000000003
R_1_9_6_3 Node1_9_6 GND 16.0
C_1_9_6 Node1_9_6 GND 3.6093750000000004e-07
R_1_9_7_1 Node1_9_7 Node1_9_8 250.00000000000003
R_1_9_7_2 Node1_9_7 Node1_10_7 250.00000000000003
R_1_9_7_3 Node1_9_7 GND 16.0
C_1_9_7 Node1_9_7 GND 3.6093750000000004e-07
R_1_9_8_1 Node1_9_8 Node1_9_9 250.00000000000003
R_1_9_8_2 Node1_9_8 Node1_10_8 250.00000000000003
R_1_9_8_3 Node1_9_8 GND 16.0
C_1_9_8 Node1_9_8 GND 3.6093750000000004e-07
R_1_9_9_1 Node1_9_9 Node1_9_10 250.00000000000003
R_1_9_9_2 Node1_9_9 Node1_10_9 250.00000000000003
R_1_9_9_3 Node1_9_9 GND 16.0
C_1_9_9 Node1_9_9 GND 3.6093750000000004e-07
R_1_9_10_1 Node1_9_10 Node1_9_11 250.00000000000003
R_1_9_10_2 Node1_9_10 Node1_10_10 250.00000000000003
R_1_9_10_3 Node1_9_10 GND 16.0
C_1_9_10 Node1_9_10 GND 3.6093750000000004e-07
R_1_9_11_1 Node1_9_11 Node1_9_12 250.00000000000003
R_1_9_11_2 Node1_9_11 Node1_10_11 250.00000000000003
R_1_9_11_3 Node1_9_11 GND 16.0
C_1_9_11 Node1_9_11 GND 3.6093750000000004e-07
R_1_9_12_1 Node1_9_12 Node1_9_13 250.00000000000003
R_1_9_12_2 Node1_9_12 Node1_10_12 250.00000000000003
R_1_9_12_3 Node1_9_12 GND 16.0
C_1_9_12 Node1_9_12 GND 3.6093750000000004e-07
R_1_9_13_1 Node1_9_13 Node1_9_14 250.00000000000003
R_1_9_13_2 Node1_9_13 Node1_10_13 250.00000000000003
R_1_9_13_3 Node1_9_13 GND 16.0
C_1_9_13 Node1_9_13 GND 3.6093750000000004e-07
R_1_9_14_1 Node1_9_14 Node1_9_15 250.00000000000003
R_1_9_14_2 Node1_9_14 Node1_10_14 250.00000000000003
R_1_9_14_3 Node1_9_14 GND 16.0
C_1_9_14 Node1_9_14 GND 3.6093750000000004e-07
R_1_9_15_1 Node1_9_15 Node1_9_16 250.00000000000003
R_1_9_15_2 Node1_9_15 Node1_10_15 250.00000000000003
R_1_9_15_3 Node1_9_15 GND 16.0
C_1_9_15 Node1_9_15 GND 3.6093750000000004e-07
R_1_9_16_1 Node1_9_16 Node1_9_17 250.00000000000003
R_1_9_16_2 Node1_9_16 Node1_10_16 250.00000000000003
R_1_9_16_3 Node1_9_16 GND 16.0
C_1_9_16 Node1_9_16 GND 3.6093750000000004e-07
R_1_9_17_1 Node1_9_17 Node1_9_18 250.00000000000003
R_1_9_17_2 Node1_9_17 Node1_10_17 250.00000000000003
R_1_9_17_3 Node1_9_17 GND 16.0
C_1_9_17 Node1_9_17 GND 3.6093750000000004e-07
R_1_9_18_1 Node1_9_18 Node1_9_19 250.00000000000003
R_1_9_18_2 Node1_9_18 Node1_10_18 250.00000000000003
R_1_9_18_3 Node1_9_18 GND 16.0
C_1_9_18 Node1_9_18 GND 3.6093750000000004e-07
R_1_9_19_1 Node1_9_19 Node1_9_20 250.00000000000003
R_1_9_19_2 Node1_9_19 Node1_10_19 250.00000000000003
R_1_9_19_3 Node1_9_19 GND 16.0
C_1_9_19 Node1_9_19 GND 3.6093750000000004e-07
R_1_9_20_1 Node1_9_20 Node1_9_21 250.00000000000003
R_1_9_20_2 Node1_9_20 Node1_10_20 250.00000000000003
R_1_9_20_3 Node1_9_20 GND 16.0
C_1_9_20 Node1_9_20 GND 3.6093750000000004e-07
R_1_9_21_1 Node1_9_21 Node1_9_22 250.00000000000003
R_1_9_21_2 Node1_9_21 Node1_10_21 250.00000000000003
R_1_9_21_3 Node1_9_21 GND 16.0
C_1_9_21 Node1_9_21 GND 3.6093750000000004e-07
R_1_9_22_1 Node1_9_22 Node1_9_23 250.00000000000003
R_1_9_22_2 Node1_9_22 Node1_10_22 250.00000000000003
R_1_9_22_3 Node1_9_22 GND 16.0
C_1_9_22 Node1_9_22 GND 3.6093750000000004e-07
R_1_9_23_1 Node1_9_23 Node1_9_24 250.00000000000003
R_1_9_23_2 Node1_9_23 Node1_10_23 250.00000000000003
R_1_9_23_3 Node1_9_23 GND 16.0
C_1_9_23 Node1_9_23 GND 3.6093750000000004e-07
R_1_9_24_1 Node1_9_24 Node1_9_25 250.00000000000003
R_1_9_24_2 Node1_9_24 Node1_10_24 250.00000000000003
R_1_9_24_3 Node1_9_24 GND 16.0
C_1_9_24 Node1_9_24 GND 3.6093750000000004e-07
R_1_9_25_1 Node1_9_25 Node1_9_26 250.00000000000003
R_1_9_25_2 Node1_9_25 Node1_10_25 250.00000000000003
R_1_9_25_3 Node1_9_25 GND 16.0
C_1_9_25 Node1_9_25 GND 3.6093750000000004e-07
R_1_9_26_1 Node1_9_26 Node1_9_27 250.00000000000003
R_1_9_26_2 Node1_9_26 Node1_10_26 250.00000000000003
R_1_9_26_3 Node1_9_26 GND 16.0
C_1_9_26 Node1_9_26 GND 3.6093750000000004e-07
R_1_9_27_1 Node1_9_27 Node1_9_28 250.00000000000003
R_1_9_27_2 Node1_9_27 Node1_10_27 250.00000000000003
R_1_9_27_3 Node1_9_27 GND 16.0
C_1_9_27 Node1_9_27 GND 3.6093750000000004e-07
R_1_9_28_1 Node1_9_28 Node1_9_29 250.00000000000003
R_1_9_28_2 Node1_9_28 Node1_10_28 250.00000000000003
R_1_9_28_3 Node1_9_28 GND 16.0
C_1_9_28 Node1_9_28 GND 3.6093750000000004e-07
R_1_9_29_1 Node1_9_29 Node1_9_30 250.00000000000003
R_1_9_29_2 Node1_9_29 Node1_10_29 250.00000000000003
R_1_9_29_3 Node1_9_29 GND 16.0
C_1_9_29 Node1_9_29 GND 3.6093750000000004e-07
R_1_9_30_1 Node1_9_30 Node1_9_31 250.00000000000003
R_1_9_30_2 Node1_9_30 Node1_10_30 250.00000000000003
R_1_9_30_3 Node1_9_30 GND 16.0
C_1_9_30 Node1_9_30 GND 3.6093750000000004e-07
R_1_9_31_1 Node1_9_31 Node1_9_32 250.00000000000003
R_1_9_31_2 Node1_9_31 Node1_10_31 250.00000000000003
R_1_9_31_3 Node1_9_31 GND 16.0
C_1_9_31 Node1_9_31 GND 3.6093750000000004e-07
R_1_9_32_1 Node1_9_32 Node1_9_33 250.00000000000003
R_1_9_32_2 Node1_9_32 Node1_10_32 250.00000000000003
R_1_9_32_3 Node1_9_32 GND 16.0
C_1_9_32 Node1_9_32 GND 3.6093750000000004e-07
R_1_9_33_1 Node1_9_33 Node1_9_34 250.00000000000003
R_1_9_33_2 Node1_9_33 Node1_10_33 250.00000000000003
R_1_9_33_3 Node1_9_33 GND 16.0
C_1_9_33 Node1_9_33 GND 3.6093750000000004e-07
R_1_9_34_1 Node1_9_34 Node1_9_35 250.00000000000003
R_1_9_34_2 Node1_9_34 Node1_10_34 250.00000000000003
R_1_9_34_3 Node1_9_34 GND 16.0
C_1_9_34 Node1_9_34 GND 3.6093750000000004e-07
R_1_9_35_1 Node1_9_35 Node1_9_36 250.00000000000003
R_1_9_35_2 Node1_9_35 Node1_10_35 250.00000000000003
R_1_9_35_3 Node1_9_35 GND 16.0
C_1_9_35 Node1_9_35 GND 3.6093750000000004e-07
R_1_9_36_1 Node1_9_36 Node1_9_37 250.00000000000003
R_1_9_36_2 Node1_9_36 Node1_10_36 250.00000000000003
R_1_9_36_3 Node1_9_36 GND 16.0
C_1_9_36 Node1_9_36 GND 3.6093750000000004e-07
R_1_9_37_1 Node1_9_37 Node1_9_38 250.00000000000003
R_1_9_37_2 Node1_9_37 Node1_10_37 250.00000000000003
R_1_9_37_3 Node1_9_37 GND 16.0
C_1_9_37 Node1_9_37 GND 3.6093750000000004e-07
R_1_9_38_1 Node1_9_38 Node1_9_39 250.00000000000003
R_1_9_38_2 Node1_9_38 Node1_10_38 250.00000000000003
R_1_9_38_3 Node1_9_38 GND 16.0
C_1_9_38 Node1_9_38 GND 3.6093750000000004e-07
R_1_9_39_2 Node1_9_39 Node1_10_39 250.00000000000003
R_1_9_39_3 Node1_9_39 GND 16.0
C_1_9_39 Node1_9_39 GND 3.6093750000000004e-07
R_1_10_0_1 Node1_10_0 Node1_10_1 250.00000000000003
R_1_10_0_2 Node1_10_0 Node1_11_0 250.00000000000003
R_1_10_0_3 Node1_10_0 GND 16.0
C_1_10_0 Node1_10_0 GND 3.6093750000000004e-07
R_1_10_1_1 Node1_10_1 Node1_10_2 250.00000000000003
R_1_10_1_2 Node1_10_1 Node1_11_1 250.00000000000003
R_1_10_1_3 Node1_10_1 GND 16.0
C_1_10_1 Node1_10_1 GND 3.6093750000000004e-07
R_1_10_2_1 Node1_10_2 Node1_10_3 250.00000000000003
R_1_10_2_2 Node1_10_2 Node1_11_2 250.00000000000003
R_1_10_2_3 Node1_10_2 GND 16.0
C_1_10_2 Node1_10_2 GND 3.6093750000000004e-07
R_1_10_3_1 Node1_10_3 Node1_10_4 250.00000000000003
R_1_10_3_2 Node1_10_3 Node1_11_3 250.00000000000003
R_1_10_3_3 Node1_10_3 GND 16.0
C_1_10_3 Node1_10_3 GND 3.6093750000000004e-07
R_1_10_4_1 Node1_10_4 Node1_10_5 250.00000000000003
R_1_10_4_2 Node1_10_4 Node1_11_4 250.00000000000003
R_1_10_4_3 Node1_10_4 GND 16.0
C_1_10_4 Node1_10_4 GND 3.6093750000000004e-07
R_1_10_5_1 Node1_10_5 Node1_10_6 250.00000000000003
R_1_10_5_2 Node1_10_5 Node1_11_5 250.00000000000003
R_1_10_5_3 Node1_10_5 GND 16.0
C_1_10_5 Node1_10_5 GND 3.6093750000000004e-07
R_1_10_6_1 Node1_10_6 Node1_10_7 250.00000000000003
R_1_10_6_2 Node1_10_6 Node1_11_6 250.00000000000003
R_1_10_6_3 Node1_10_6 GND 16.0
C_1_10_6 Node1_10_6 GND 3.6093750000000004e-07
R_1_10_7_1 Node1_10_7 Node1_10_8 250.00000000000003
R_1_10_7_2 Node1_10_7 Node1_11_7 250.00000000000003
R_1_10_7_3 Node1_10_7 GND 16.0
C_1_10_7 Node1_10_7 GND 3.6093750000000004e-07
R_1_10_8_1 Node1_10_8 Node1_10_9 250.00000000000003
R_1_10_8_2 Node1_10_8 Node1_11_8 250.00000000000003
R_1_10_8_3 Node1_10_8 GND 16.0
C_1_10_8 Node1_10_8 GND 3.6093750000000004e-07
R_1_10_9_1 Node1_10_9 Node1_10_10 250.00000000000003
R_1_10_9_2 Node1_10_9 Node1_11_9 250.00000000000003
R_1_10_9_3 Node1_10_9 GND 16.0
C_1_10_9 Node1_10_9 GND 3.6093750000000004e-07
R_1_10_10_1 Node1_10_10 Node1_10_11 250.00000000000003
R_1_10_10_2 Node1_10_10 Node1_11_10 250.00000000000003
R_1_10_10_3 Node1_10_10 GND 16.0
C_1_10_10 Node1_10_10 GND 3.6093750000000004e-07
R_1_10_11_1 Node1_10_11 Node1_10_12 250.00000000000003
R_1_10_11_2 Node1_10_11 Node1_11_11 250.00000000000003
R_1_10_11_3 Node1_10_11 GND 16.0
C_1_10_11 Node1_10_11 GND 3.6093750000000004e-07
R_1_10_12_1 Node1_10_12 Node1_10_13 250.00000000000003
R_1_10_12_2 Node1_10_12 Node1_11_12 250.00000000000003
R_1_10_12_3 Node1_10_12 GND 16.0
C_1_10_12 Node1_10_12 GND 3.6093750000000004e-07
R_1_10_13_1 Node1_10_13 Node1_10_14 250.00000000000003
R_1_10_13_2 Node1_10_13 Node1_11_13 250.00000000000003
R_1_10_13_3 Node1_10_13 GND 16.0
C_1_10_13 Node1_10_13 GND 3.6093750000000004e-07
R_1_10_14_1 Node1_10_14 Node1_10_15 250.00000000000003
R_1_10_14_2 Node1_10_14 Node1_11_14 250.00000000000003
R_1_10_14_3 Node1_10_14 GND 16.0
C_1_10_14 Node1_10_14 GND 3.6093750000000004e-07
R_1_10_15_1 Node1_10_15 Node1_10_16 250.00000000000003
R_1_10_15_2 Node1_10_15 Node1_11_15 250.00000000000003
R_1_10_15_3 Node1_10_15 GND 16.0
C_1_10_15 Node1_10_15 GND 3.6093750000000004e-07
R_1_10_16_1 Node1_10_16 Node1_10_17 250.00000000000003
R_1_10_16_2 Node1_10_16 Node1_11_16 250.00000000000003
R_1_10_16_3 Node1_10_16 GND 16.0
C_1_10_16 Node1_10_16 GND 3.6093750000000004e-07
R_1_10_17_1 Node1_10_17 Node1_10_18 250.00000000000003
R_1_10_17_2 Node1_10_17 Node1_11_17 250.00000000000003
R_1_10_17_3 Node1_10_17 GND 16.0
C_1_10_17 Node1_10_17 GND 3.6093750000000004e-07
R_1_10_18_1 Node1_10_18 Node1_10_19 250.00000000000003
R_1_10_18_2 Node1_10_18 Node1_11_18 250.00000000000003
R_1_10_18_3 Node1_10_18 GND 16.0
C_1_10_18 Node1_10_18 GND 3.6093750000000004e-07
R_1_10_19_1 Node1_10_19 Node1_10_20 250.00000000000003
R_1_10_19_2 Node1_10_19 Node1_11_19 250.00000000000003
R_1_10_19_3 Node1_10_19 GND 16.0
C_1_10_19 Node1_10_19 GND 3.6093750000000004e-07
R_1_10_20_1 Node1_10_20 Node1_10_21 250.00000000000003
R_1_10_20_2 Node1_10_20 Node1_11_20 250.00000000000003
R_1_10_20_3 Node1_10_20 GND 16.0
C_1_10_20 Node1_10_20 GND 3.6093750000000004e-07
R_1_10_21_1 Node1_10_21 Node1_10_22 250.00000000000003
R_1_10_21_2 Node1_10_21 Node1_11_21 250.00000000000003
R_1_10_21_3 Node1_10_21 GND 16.0
C_1_10_21 Node1_10_21 GND 3.6093750000000004e-07
R_1_10_22_1 Node1_10_22 Node1_10_23 250.00000000000003
R_1_10_22_2 Node1_10_22 Node1_11_22 250.00000000000003
R_1_10_22_3 Node1_10_22 GND 16.0
C_1_10_22 Node1_10_22 GND 3.6093750000000004e-07
R_1_10_23_1 Node1_10_23 Node1_10_24 250.00000000000003
R_1_10_23_2 Node1_10_23 Node1_11_23 250.00000000000003
R_1_10_23_3 Node1_10_23 GND 16.0
C_1_10_23 Node1_10_23 GND 3.6093750000000004e-07
R_1_10_24_1 Node1_10_24 Node1_10_25 250.00000000000003
R_1_10_24_2 Node1_10_24 Node1_11_24 250.00000000000003
R_1_10_24_3 Node1_10_24 GND 16.0
C_1_10_24 Node1_10_24 GND 3.6093750000000004e-07
R_1_10_25_1 Node1_10_25 Node1_10_26 250.00000000000003
R_1_10_25_2 Node1_10_25 Node1_11_25 250.00000000000003
R_1_10_25_3 Node1_10_25 GND 16.0
C_1_10_25 Node1_10_25 GND 3.6093750000000004e-07
R_1_10_26_1 Node1_10_26 Node1_10_27 250.00000000000003
R_1_10_26_2 Node1_10_26 Node1_11_26 250.00000000000003
R_1_10_26_3 Node1_10_26 GND 16.0
C_1_10_26 Node1_10_26 GND 3.6093750000000004e-07
R_1_10_27_1 Node1_10_27 Node1_10_28 250.00000000000003
R_1_10_27_2 Node1_10_27 Node1_11_27 250.00000000000003
R_1_10_27_3 Node1_10_27 GND 16.0
C_1_10_27 Node1_10_27 GND 3.6093750000000004e-07
R_1_10_28_1 Node1_10_28 Node1_10_29 250.00000000000003
R_1_10_28_2 Node1_10_28 Node1_11_28 250.00000000000003
R_1_10_28_3 Node1_10_28 GND 16.0
C_1_10_28 Node1_10_28 GND 3.6093750000000004e-07
R_1_10_29_1 Node1_10_29 Node1_10_30 250.00000000000003
R_1_10_29_2 Node1_10_29 Node1_11_29 250.00000000000003
R_1_10_29_3 Node1_10_29 GND 16.0
C_1_10_29 Node1_10_29 GND 3.6093750000000004e-07
R_1_10_30_1 Node1_10_30 Node1_10_31 250.00000000000003
R_1_10_30_2 Node1_10_30 Node1_11_30 250.00000000000003
R_1_10_30_3 Node1_10_30 GND 16.0
C_1_10_30 Node1_10_30 GND 3.6093750000000004e-07
R_1_10_31_1 Node1_10_31 Node1_10_32 250.00000000000003
R_1_10_31_2 Node1_10_31 Node1_11_31 250.00000000000003
R_1_10_31_3 Node1_10_31 GND 16.0
C_1_10_31 Node1_10_31 GND 3.6093750000000004e-07
R_1_10_32_1 Node1_10_32 Node1_10_33 250.00000000000003
R_1_10_32_2 Node1_10_32 Node1_11_32 250.00000000000003
R_1_10_32_3 Node1_10_32 GND 16.0
C_1_10_32 Node1_10_32 GND 3.6093750000000004e-07
R_1_10_33_1 Node1_10_33 Node1_10_34 250.00000000000003
R_1_10_33_2 Node1_10_33 Node1_11_33 250.00000000000003
R_1_10_33_3 Node1_10_33 GND 16.0
C_1_10_33 Node1_10_33 GND 3.6093750000000004e-07
R_1_10_34_1 Node1_10_34 Node1_10_35 250.00000000000003
R_1_10_34_2 Node1_10_34 Node1_11_34 250.00000000000003
R_1_10_34_3 Node1_10_34 GND 16.0
C_1_10_34 Node1_10_34 GND 3.6093750000000004e-07
R_1_10_35_1 Node1_10_35 Node1_10_36 250.00000000000003
R_1_10_35_2 Node1_10_35 Node1_11_35 250.00000000000003
R_1_10_35_3 Node1_10_35 GND 16.0
C_1_10_35 Node1_10_35 GND 3.6093750000000004e-07
R_1_10_36_1 Node1_10_36 Node1_10_37 250.00000000000003
R_1_10_36_2 Node1_10_36 Node1_11_36 250.00000000000003
R_1_10_36_3 Node1_10_36 GND 16.0
C_1_10_36 Node1_10_36 GND 3.6093750000000004e-07
R_1_10_37_1 Node1_10_37 Node1_10_38 250.00000000000003
R_1_10_37_2 Node1_10_37 Node1_11_37 250.00000000000003
R_1_10_37_3 Node1_10_37 GND 16.0
C_1_10_37 Node1_10_37 GND 3.6093750000000004e-07
R_1_10_38_1 Node1_10_38 Node1_10_39 250.00000000000003
R_1_10_38_2 Node1_10_38 Node1_11_38 250.00000000000003
R_1_10_38_3 Node1_10_38 GND 16.0
C_1_10_38 Node1_10_38 GND 3.6093750000000004e-07
R_1_10_39_2 Node1_10_39 Node1_11_39 250.00000000000003
R_1_10_39_3 Node1_10_39 GND 16.0
C_1_10_39 Node1_10_39 GND 3.6093750000000004e-07
R_1_11_0_1 Node1_11_0 Node1_11_1 250.00000000000003
R_1_11_0_2 Node1_11_0 Node1_12_0 250.00000000000003
R_1_11_0_3 Node1_11_0 GND 16.0
C_1_11_0 Node1_11_0 GND 3.6093750000000004e-07
R_1_11_1_1 Node1_11_1 Node1_11_2 250.00000000000003
R_1_11_1_2 Node1_11_1 Node1_12_1 250.00000000000003
R_1_11_1_3 Node1_11_1 GND 16.0
C_1_11_1 Node1_11_1 GND 3.6093750000000004e-07
R_1_11_2_1 Node1_11_2 Node1_11_3 250.00000000000003
R_1_11_2_2 Node1_11_2 Node1_12_2 250.00000000000003
R_1_11_2_3 Node1_11_2 GND 16.0
C_1_11_2 Node1_11_2 GND 3.6093750000000004e-07
R_1_11_3_1 Node1_11_3 Node1_11_4 250.00000000000003
R_1_11_3_2 Node1_11_3 Node1_12_3 250.00000000000003
R_1_11_3_3 Node1_11_3 GND 16.0
C_1_11_3 Node1_11_3 GND 3.6093750000000004e-07
R_1_11_4_1 Node1_11_4 Node1_11_5 250.00000000000003
R_1_11_4_2 Node1_11_4 Node1_12_4 250.00000000000003
R_1_11_4_3 Node1_11_4 GND 16.0
C_1_11_4 Node1_11_4 GND 3.6093750000000004e-07
R_1_11_5_1 Node1_11_5 Node1_11_6 250.00000000000003
R_1_11_5_2 Node1_11_5 Node1_12_5 250.00000000000003
R_1_11_5_3 Node1_11_5 GND 16.0
C_1_11_5 Node1_11_5 GND 3.6093750000000004e-07
R_1_11_6_1 Node1_11_6 Node1_11_7 250.00000000000003
R_1_11_6_2 Node1_11_6 Node1_12_6 250.00000000000003
R_1_11_6_3 Node1_11_6 GND 16.0
C_1_11_6 Node1_11_6 GND 3.6093750000000004e-07
R_1_11_7_1 Node1_11_7 Node1_11_8 250.00000000000003
R_1_11_7_2 Node1_11_7 Node1_12_7 250.00000000000003
R_1_11_7_3 Node1_11_7 GND 16.0
C_1_11_7 Node1_11_7 GND 3.6093750000000004e-07
R_1_11_8_1 Node1_11_8 Node1_11_9 250.00000000000003
R_1_11_8_2 Node1_11_8 Node1_12_8 250.00000000000003
R_1_11_8_3 Node1_11_8 GND 16.0
C_1_11_8 Node1_11_8 GND 3.6093750000000004e-07
R_1_11_9_1 Node1_11_9 Node1_11_10 250.00000000000003
R_1_11_9_2 Node1_11_9 Node1_12_9 250.00000000000003
R_1_11_9_3 Node1_11_9 GND 16.0
C_1_11_9 Node1_11_9 GND 3.6093750000000004e-07
R_1_11_10_1 Node1_11_10 Node1_11_11 250.00000000000003
R_1_11_10_2 Node1_11_10 Node1_12_10 250.00000000000003
R_1_11_10_3 Node1_11_10 GND 16.0
C_1_11_10 Node1_11_10 GND 3.6093750000000004e-07
R_1_11_11_1 Node1_11_11 Node1_11_12 250.00000000000003
R_1_11_11_2 Node1_11_11 Node1_12_11 250.00000000000003
R_1_11_11_3 Node1_11_11 GND 16.0
C_1_11_11 Node1_11_11 GND 3.6093750000000004e-07
R_1_11_12_1 Node1_11_12 Node1_11_13 250.00000000000003
R_1_11_12_2 Node1_11_12 Node1_12_12 250.00000000000003
R_1_11_12_3 Node1_11_12 GND 16.0
C_1_11_12 Node1_11_12 GND 3.6093750000000004e-07
R_1_11_13_1 Node1_11_13 Node1_11_14 250.00000000000003
R_1_11_13_2 Node1_11_13 Node1_12_13 250.00000000000003
R_1_11_13_3 Node1_11_13 GND 16.0
C_1_11_13 Node1_11_13 GND 3.6093750000000004e-07
R_1_11_14_1 Node1_11_14 Node1_11_15 250.00000000000003
R_1_11_14_2 Node1_11_14 Node1_12_14 250.00000000000003
R_1_11_14_3 Node1_11_14 GND 16.0
C_1_11_14 Node1_11_14 GND 3.6093750000000004e-07
R_1_11_15_1 Node1_11_15 Node1_11_16 250.00000000000003
R_1_11_15_2 Node1_11_15 Node1_12_15 250.00000000000003
R_1_11_15_3 Node1_11_15 GND 16.0
C_1_11_15 Node1_11_15 GND 3.6093750000000004e-07
R_1_11_16_1 Node1_11_16 Node1_11_17 250.00000000000003
R_1_11_16_2 Node1_11_16 Node1_12_16 250.00000000000003
R_1_11_16_3 Node1_11_16 GND 16.0
C_1_11_16 Node1_11_16 GND 3.6093750000000004e-07
R_1_11_17_1 Node1_11_17 Node1_11_18 250.00000000000003
R_1_11_17_2 Node1_11_17 Node1_12_17 250.00000000000003
R_1_11_17_3 Node1_11_17 GND 16.0
C_1_11_17 Node1_11_17 GND 3.6093750000000004e-07
R_1_11_18_1 Node1_11_18 Node1_11_19 250.00000000000003
R_1_11_18_2 Node1_11_18 Node1_12_18 250.00000000000003
R_1_11_18_3 Node1_11_18 GND 16.0
C_1_11_18 Node1_11_18 GND 3.6093750000000004e-07
R_1_11_19_1 Node1_11_19 Node1_11_20 250.00000000000003
R_1_11_19_2 Node1_11_19 Node1_12_19 250.00000000000003
R_1_11_19_3 Node1_11_19 GND 16.0
C_1_11_19 Node1_11_19 GND 3.6093750000000004e-07
R_1_11_20_1 Node1_11_20 Node1_11_21 250.00000000000003
R_1_11_20_2 Node1_11_20 Node1_12_20 250.00000000000003
R_1_11_20_3 Node1_11_20 GND 16.0
C_1_11_20 Node1_11_20 GND 3.6093750000000004e-07
R_1_11_21_1 Node1_11_21 Node1_11_22 250.00000000000003
R_1_11_21_2 Node1_11_21 Node1_12_21 250.00000000000003
R_1_11_21_3 Node1_11_21 GND 16.0
C_1_11_21 Node1_11_21 GND 3.6093750000000004e-07
R_1_11_22_1 Node1_11_22 Node1_11_23 250.00000000000003
R_1_11_22_2 Node1_11_22 Node1_12_22 250.00000000000003
R_1_11_22_3 Node1_11_22 GND 16.0
C_1_11_22 Node1_11_22 GND 3.6093750000000004e-07
R_1_11_23_1 Node1_11_23 Node1_11_24 250.00000000000003
R_1_11_23_2 Node1_11_23 Node1_12_23 250.00000000000003
R_1_11_23_3 Node1_11_23 GND 16.0
C_1_11_23 Node1_11_23 GND 3.6093750000000004e-07
R_1_11_24_1 Node1_11_24 Node1_11_25 250.00000000000003
R_1_11_24_2 Node1_11_24 Node1_12_24 250.00000000000003
R_1_11_24_3 Node1_11_24 GND 16.0
C_1_11_24 Node1_11_24 GND 3.6093750000000004e-07
R_1_11_25_1 Node1_11_25 Node1_11_26 250.00000000000003
R_1_11_25_2 Node1_11_25 Node1_12_25 250.00000000000003
R_1_11_25_3 Node1_11_25 GND 16.0
C_1_11_25 Node1_11_25 GND 3.6093750000000004e-07
R_1_11_26_1 Node1_11_26 Node1_11_27 250.00000000000003
R_1_11_26_2 Node1_11_26 Node1_12_26 250.00000000000003
R_1_11_26_3 Node1_11_26 GND 16.0
C_1_11_26 Node1_11_26 GND 3.6093750000000004e-07
R_1_11_27_1 Node1_11_27 Node1_11_28 250.00000000000003
R_1_11_27_2 Node1_11_27 Node1_12_27 250.00000000000003
R_1_11_27_3 Node1_11_27 GND 16.0
C_1_11_27 Node1_11_27 GND 3.6093750000000004e-07
R_1_11_28_1 Node1_11_28 Node1_11_29 250.00000000000003
R_1_11_28_2 Node1_11_28 Node1_12_28 250.00000000000003
R_1_11_28_3 Node1_11_28 GND 16.0
C_1_11_28 Node1_11_28 GND 3.6093750000000004e-07
R_1_11_29_1 Node1_11_29 Node1_11_30 250.00000000000003
R_1_11_29_2 Node1_11_29 Node1_12_29 250.00000000000003
R_1_11_29_3 Node1_11_29 GND 16.0
C_1_11_29 Node1_11_29 GND 3.6093750000000004e-07
R_1_11_30_1 Node1_11_30 Node1_11_31 250.00000000000003
R_1_11_30_2 Node1_11_30 Node1_12_30 250.00000000000003
R_1_11_30_3 Node1_11_30 GND 16.0
C_1_11_30 Node1_11_30 GND 3.6093750000000004e-07
R_1_11_31_1 Node1_11_31 Node1_11_32 250.00000000000003
R_1_11_31_2 Node1_11_31 Node1_12_31 250.00000000000003
R_1_11_31_3 Node1_11_31 GND 16.0
C_1_11_31 Node1_11_31 GND 3.6093750000000004e-07
R_1_11_32_1 Node1_11_32 Node1_11_33 250.00000000000003
R_1_11_32_2 Node1_11_32 Node1_12_32 250.00000000000003
R_1_11_32_3 Node1_11_32 GND 16.0
C_1_11_32 Node1_11_32 GND 3.6093750000000004e-07
R_1_11_33_1 Node1_11_33 Node1_11_34 250.00000000000003
R_1_11_33_2 Node1_11_33 Node1_12_33 250.00000000000003
R_1_11_33_3 Node1_11_33 GND 16.0
C_1_11_33 Node1_11_33 GND 3.6093750000000004e-07
R_1_11_34_1 Node1_11_34 Node1_11_35 250.00000000000003
R_1_11_34_2 Node1_11_34 Node1_12_34 250.00000000000003
R_1_11_34_3 Node1_11_34 GND 16.0
C_1_11_34 Node1_11_34 GND 3.6093750000000004e-07
R_1_11_35_1 Node1_11_35 Node1_11_36 250.00000000000003
R_1_11_35_2 Node1_11_35 Node1_12_35 250.00000000000003
R_1_11_35_3 Node1_11_35 GND 16.0
C_1_11_35 Node1_11_35 GND 3.6093750000000004e-07
R_1_11_36_1 Node1_11_36 Node1_11_37 250.00000000000003
R_1_11_36_2 Node1_11_36 Node1_12_36 250.00000000000003
R_1_11_36_3 Node1_11_36 GND 16.0
C_1_11_36 Node1_11_36 GND 3.6093750000000004e-07
R_1_11_37_1 Node1_11_37 Node1_11_38 250.00000000000003
R_1_11_37_2 Node1_11_37 Node1_12_37 250.00000000000003
R_1_11_37_3 Node1_11_37 GND 16.0
C_1_11_37 Node1_11_37 GND 3.6093750000000004e-07
R_1_11_38_1 Node1_11_38 Node1_11_39 250.00000000000003
R_1_11_38_2 Node1_11_38 Node1_12_38 250.00000000000003
R_1_11_38_3 Node1_11_38 GND 16.0
C_1_11_38 Node1_11_38 GND 3.6093750000000004e-07
R_1_11_39_2 Node1_11_39 Node1_12_39 250.00000000000003
R_1_11_39_3 Node1_11_39 GND 16.0
C_1_11_39 Node1_11_39 GND 3.6093750000000004e-07
R_1_12_0_1 Node1_12_0 Node1_12_1 250.00000000000003
R_1_12_0_2 Node1_12_0 Node1_13_0 250.00000000000003
R_1_12_0_3 Node1_12_0 GND 16.0
C_1_12_0 Node1_12_0 GND 3.6093750000000004e-07
R_1_12_1_1 Node1_12_1 Node1_12_2 250.00000000000003
R_1_12_1_2 Node1_12_1 Node1_13_1 250.00000000000003
R_1_12_1_3 Node1_12_1 GND 16.0
C_1_12_1 Node1_12_1 GND 3.6093750000000004e-07
R_1_12_2_1 Node1_12_2 Node1_12_3 250.00000000000003
R_1_12_2_2 Node1_12_2 Node1_13_2 250.00000000000003
R_1_12_2_3 Node1_12_2 GND 16.0
C_1_12_2 Node1_12_2 GND 3.6093750000000004e-07
R_1_12_3_1 Node1_12_3 Node1_12_4 250.00000000000003
R_1_12_3_2 Node1_12_3 Node1_13_3 250.00000000000003
R_1_12_3_3 Node1_12_3 GND 16.0
C_1_12_3 Node1_12_3 GND 3.6093750000000004e-07
R_1_12_4_1 Node1_12_4 Node1_12_5 250.00000000000003
R_1_12_4_2 Node1_12_4 Node1_13_4 250.00000000000003
R_1_12_4_3 Node1_12_4 GND 16.0
C_1_12_4 Node1_12_4 GND 3.6093750000000004e-07
R_1_12_5_1 Node1_12_5 Node1_12_6 250.00000000000003
R_1_12_5_2 Node1_12_5 Node1_13_5 250.00000000000003
R_1_12_5_3 Node1_12_5 GND 16.0
C_1_12_5 Node1_12_5 GND 3.6093750000000004e-07
R_1_12_6_1 Node1_12_6 Node1_12_7 250.00000000000003
R_1_12_6_2 Node1_12_6 Node1_13_6 250.00000000000003
R_1_12_6_3 Node1_12_6 GND 16.0
C_1_12_6 Node1_12_6 GND 3.6093750000000004e-07
R_1_12_7_1 Node1_12_7 Node1_12_8 250.00000000000003
R_1_12_7_2 Node1_12_7 Node1_13_7 250.00000000000003
R_1_12_7_3 Node1_12_7 GND 16.0
C_1_12_7 Node1_12_7 GND 3.6093750000000004e-07
R_1_12_8_1 Node1_12_8 Node1_12_9 250.00000000000003
R_1_12_8_2 Node1_12_8 Node1_13_8 250.00000000000003
R_1_12_8_3 Node1_12_8 GND 16.0
C_1_12_8 Node1_12_8 GND 3.6093750000000004e-07
R_1_12_9_1 Node1_12_9 Node1_12_10 250.00000000000003
R_1_12_9_2 Node1_12_9 Node1_13_9 250.00000000000003
R_1_12_9_3 Node1_12_9 GND 16.0
C_1_12_9 Node1_12_9 GND 3.6093750000000004e-07
R_1_12_10_1 Node1_12_10 Node1_12_11 250.00000000000003
R_1_12_10_2 Node1_12_10 Node1_13_10 250.00000000000003
R_1_12_10_3 Node1_12_10 GND 16.0
C_1_12_10 Node1_12_10 GND 3.6093750000000004e-07
R_1_12_11_1 Node1_12_11 Node1_12_12 250.00000000000003
R_1_12_11_2 Node1_12_11 Node1_13_11 250.00000000000003
R_1_12_11_3 Node1_12_11 GND 16.0
C_1_12_11 Node1_12_11 GND 3.6093750000000004e-07
R_1_12_12_1 Node1_12_12 Node1_12_13 250.00000000000003
R_1_12_12_2 Node1_12_12 Node1_13_12 250.00000000000003
R_1_12_12_3 Node1_12_12 GND 16.0
C_1_12_12 Node1_12_12 GND 3.6093750000000004e-07
R_1_12_13_1 Node1_12_13 Node1_12_14 250.00000000000003
R_1_12_13_2 Node1_12_13 Node1_13_13 250.00000000000003
R_1_12_13_3 Node1_12_13 GND 16.0
C_1_12_13 Node1_12_13 GND 3.6093750000000004e-07
R_1_12_14_1 Node1_12_14 Node1_12_15 250.00000000000003
R_1_12_14_2 Node1_12_14 Node1_13_14 250.00000000000003
R_1_12_14_3 Node1_12_14 GND 16.0
C_1_12_14 Node1_12_14 GND 3.6093750000000004e-07
R_1_12_15_1 Node1_12_15 Node1_12_16 250.00000000000003
R_1_12_15_2 Node1_12_15 Node1_13_15 250.00000000000003
R_1_12_15_3 Node1_12_15 GND 16.0
C_1_12_15 Node1_12_15 GND 3.6093750000000004e-07
R_1_12_16_1 Node1_12_16 Node1_12_17 250.00000000000003
R_1_12_16_2 Node1_12_16 Node1_13_16 250.00000000000003
R_1_12_16_3 Node1_12_16 GND 16.0
C_1_12_16 Node1_12_16 GND 3.6093750000000004e-07
R_1_12_17_1 Node1_12_17 Node1_12_18 250.00000000000003
R_1_12_17_2 Node1_12_17 Node1_13_17 250.00000000000003
R_1_12_17_3 Node1_12_17 GND 16.0
C_1_12_17 Node1_12_17 GND 3.6093750000000004e-07
R_1_12_18_1 Node1_12_18 Node1_12_19 250.00000000000003
R_1_12_18_2 Node1_12_18 Node1_13_18 250.00000000000003
R_1_12_18_3 Node1_12_18 GND 16.0
C_1_12_18 Node1_12_18 GND 3.6093750000000004e-07
R_1_12_19_1 Node1_12_19 Node1_12_20 250.00000000000003
R_1_12_19_2 Node1_12_19 Node1_13_19 250.00000000000003
R_1_12_19_3 Node1_12_19 GND 16.0
C_1_12_19 Node1_12_19 GND 3.6093750000000004e-07
R_1_12_20_1 Node1_12_20 Node1_12_21 250.00000000000003
R_1_12_20_2 Node1_12_20 Node1_13_20 250.00000000000003
R_1_12_20_3 Node1_12_20 GND 16.0
C_1_12_20 Node1_12_20 GND 3.6093750000000004e-07
R_1_12_21_1 Node1_12_21 Node1_12_22 250.00000000000003
R_1_12_21_2 Node1_12_21 Node1_13_21 250.00000000000003
R_1_12_21_3 Node1_12_21 GND 16.0
C_1_12_21 Node1_12_21 GND 3.6093750000000004e-07
R_1_12_22_1 Node1_12_22 Node1_12_23 250.00000000000003
R_1_12_22_2 Node1_12_22 Node1_13_22 250.00000000000003
R_1_12_22_3 Node1_12_22 GND 16.0
C_1_12_22 Node1_12_22 GND 3.6093750000000004e-07
R_1_12_23_1 Node1_12_23 Node1_12_24 250.00000000000003
R_1_12_23_2 Node1_12_23 Node1_13_23 250.00000000000003
R_1_12_23_3 Node1_12_23 GND 16.0
C_1_12_23 Node1_12_23 GND 3.6093750000000004e-07
R_1_12_24_1 Node1_12_24 Node1_12_25 250.00000000000003
R_1_12_24_2 Node1_12_24 Node1_13_24 250.00000000000003
R_1_12_24_3 Node1_12_24 GND 16.0
C_1_12_24 Node1_12_24 GND 3.6093750000000004e-07
R_1_12_25_1 Node1_12_25 Node1_12_26 250.00000000000003
R_1_12_25_2 Node1_12_25 Node1_13_25 250.00000000000003
R_1_12_25_3 Node1_12_25 GND 16.0
C_1_12_25 Node1_12_25 GND 3.6093750000000004e-07
R_1_12_26_1 Node1_12_26 Node1_12_27 250.00000000000003
R_1_12_26_2 Node1_12_26 Node1_13_26 250.00000000000003
R_1_12_26_3 Node1_12_26 GND 16.0
C_1_12_26 Node1_12_26 GND 3.6093750000000004e-07
R_1_12_27_1 Node1_12_27 Node1_12_28 250.00000000000003
R_1_12_27_2 Node1_12_27 Node1_13_27 250.00000000000003
R_1_12_27_3 Node1_12_27 GND 16.0
C_1_12_27 Node1_12_27 GND 3.6093750000000004e-07
R_1_12_28_1 Node1_12_28 Node1_12_29 250.00000000000003
R_1_12_28_2 Node1_12_28 Node1_13_28 250.00000000000003
R_1_12_28_3 Node1_12_28 GND 16.0
C_1_12_28 Node1_12_28 GND 3.6093750000000004e-07
R_1_12_29_1 Node1_12_29 Node1_12_30 250.00000000000003
R_1_12_29_2 Node1_12_29 Node1_13_29 250.00000000000003
R_1_12_29_3 Node1_12_29 GND 16.0
C_1_12_29 Node1_12_29 GND 3.6093750000000004e-07
R_1_12_30_1 Node1_12_30 Node1_12_31 250.00000000000003
R_1_12_30_2 Node1_12_30 Node1_13_30 250.00000000000003
R_1_12_30_3 Node1_12_30 GND 16.0
C_1_12_30 Node1_12_30 GND 3.6093750000000004e-07
R_1_12_31_1 Node1_12_31 Node1_12_32 250.00000000000003
R_1_12_31_2 Node1_12_31 Node1_13_31 250.00000000000003
R_1_12_31_3 Node1_12_31 GND 16.0
C_1_12_31 Node1_12_31 GND 3.6093750000000004e-07
R_1_12_32_1 Node1_12_32 Node1_12_33 250.00000000000003
R_1_12_32_2 Node1_12_32 Node1_13_32 250.00000000000003
R_1_12_32_3 Node1_12_32 GND 16.0
C_1_12_32 Node1_12_32 GND 3.6093750000000004e-07
R_1_12_33_1 Node1_12_33 Node1_12_34 250.00000000000003
R_1_12_33_2 Node1_12_33 Node1_13_33 250.00000000000003
R_1_12_33_3 Node1_12_33 GND 16.0
C_1_12_33 Node1_12_33 GND 3.6093750000000004e-07
R_1_12_34_1 Node1_12_34 Node1_12_35 250.00000000000003
R_1_12_34_2 Node1_12_34 Node1_13_34 250.00000000000003
R_1_12_34_3 Node1_12_34 GND 16.0
C_1_12_34 Node1_12_34 GND 3.6093750000000004e-07
R_1_12_35_1 Node1_12_35 Node1_12_36 250.00000000000003
R_1_12_35_2 Node1_12_35 Node1_13_35 250.00000000000003
R_1_12_35_3 Node1_12_35 GND 16.0
C_1_12_35 Node1_12_35 GND 3.6093750000000004e-07
R_1_12_36_1 Node1_12_36 Node1_12_37 250.00000000000003
R_1_12_36_2 Node1_12_36 Node1_13_36 250.00000000000003
R_1_12_36_3 Node1_12_36 GND 16.0
C_1_12_36 Node1_12_36 GND 3.6093750000000004e-07
R_1_12_37_1 Node1_12_37 Node1_12_38 250.00000000000003
R_1_12_37_2 Node1_12_37 Node1_13_37 250.00000000000003
R_1_12_37_3 Node1_12_37 GND 16.0
C_1_12_37 Node1_12_37 GND 3.6093750000000004e-07
R_1_12_38_1 Node1_12_38 Node1_12_39 250.00000000000003
R_1_12_38_2 Node1_12_38 Node1_13_38 250.00000000000003
R_1_12_38_3 Node1_12_38 GND 16.0
C_1_12_38 Node1_12_38 GND 3.6093750000000004e-07
R_1_12_39_2 Node1_12_39 Node1_13_39 250.00000000000003
R_1_12_39_3 Node1_12_39 GND 16.0
C_1_12_39 Node1_12_39 GND 3.6093750000000004e-07
R_1_13_0_1 Node1_13_0 Node1_13_1 250.00000000000003
R_1_13_0_2 Node1_13_0 Node1_14_0 250.00000000000003
R_1_13_0_3 Node1_13_0 GND 16.0
C_1_13_0 Node1_13_0 GND 3.6093750000000004e-07
R_1_13_1_1 Node1_13_1 Node1_13_2 250.00000000000003
R_1_13_1_2 Node1_13_1 Node1_14_1 250.00000000000003
R_1_13_1_3 Node1_13_1 GND 16.0
C_1_13_1 Node1_13_1 GND 3.6093750000000004e-07
R_1_13_2_1 Node1_13_2 Node1_13_3 250.00000000000003
R_1_13_2_2 Node1_13_2 Node1_14_2 250.00000000000003
R_1_13_2_3 Node1_13_2 GND 16.0
C_1_13_2 Node1_13_2 GND 3.6093750000000004e-07
R_1_13_3_1 Node1_13_3 Node1_13_4 250.00000000000003
R_1_13_3_2 Node1_13_3 Node1_14_3 250.00000000000003
R_1_13_3_3 Node1_13_3 GND 16.0
C_1_13_3 Node1_13_3 GND 3.6093750000000004e-07
R_1_13_4_1 Node1_13_4 Node1_13_5 250.00000000000003
R_1_13_4_2 Node1_13_4 Node1_14_4 250.00000000000003
R_1_13_4_3 Node1_13_4 GND 16.0
C_1_13_4 Node1_13_4 GND 3.6093750000000004e-07
R_1_13_5_1 Node1_13_5 Node1_13_6 250.00000000000003
R_1_13_5_2 Node1_13_5 Node1_14_5 250.00000000000003
R_1_13_5_3 Node1_13_5 GND 16.0
C_1_13_5 Node1_13_5 GND 3.6093750000000004e-07
R_1_13_6_1 Node1_13_6 Node1_13_7 250.00000000000003
R_1_13_6_2 Node1_13_6 Node1_14_6 250.00000000000003
R_1_13_6_3 Node1_13_6 GND 16.0
C_1_13_6 Node1_13_6 GND 3.6093750000000004e-07
R_1_13_7_1 Node1_13_7 Node1_13_8 250.00000000000003
R_1_13_7_2 Node1_13_7 Node1_14_7 250.00000000000003
R_1_13_7_3 Node1_13_7 GND 16.0
C_1_13_7 Node1_13_7 GND 3.6093750000000004e-07
R_1_13_8_1 Node1_13_8 Node1_13_9 250.00000000000003
R_1_13_8_2 Node1_13_8 Node1_14_8 250.00000000000003
R_1_13_8_3 Node1_13_8 GND 16.0
C_1_13_8 Node1_13_8 GND 3.6093750000000004e-07
R_1_13_9_1 Node1_13_9 Node1_13_10 250.00000000000003
R_1_13_9_2 Node1_13_9 Node1_14_9 250.00000000000003
R_1_13_9_3 Node1_13_9 GND 16.0
C_1_13_9 Node1_13_9 GND 3.6093750000000004e-07
R_1_13_10_1 Node1_13_10 Node1_13_11 250.00000000000003
R_1_13_10_2 Node1_13_10 Node1_14_10 250.00000000000003
R_1_13_10_3 Node1_13_10 GND 16.0
C_1_13_10 Node1_13_10 GND 3.6093750000000004e-07
R_1_13_11_1 Node1_13_11 Node1_13_12 250.00000000000003
R_1_13_11_2 Node1_13_11 Node1_14_11 250.00000000000003
R_1_13_11_3 Node1_13_11 GND 16.0
C_1_13_11 Node1_13_11 GND 3.6093750000000004e-07
R_1_13_12_1 Node1_13_12 Node1_13_13 250.00000000000003
R_1_13_12_2 Node1_13_12 Node1_14_12 250.00000000000003
R_1_13_12_3 Node1_13_12 GND 16.0
C_1_13_12 Node1_13_12 GND 3.6093750000000004e-07
R_1_13_13_1 Node1_13_13 Node1_13_14 250.00000000000003
R_1_13_13_2 Node1_13_13 Node1_14_13 250.00000000000003
R_1_13_13_3 Node1_13_13 GND 16.0
C_1_13_13 Node1_13_13 GND 3.6093750000000004e-07
R_1_13_14_1 Node1_13_14 Node1_13_15 250.00000000000003
R_1_13_14_2 Node1_13_14 Node1_14_14 250.00000000000003
R_1_13_14_3 Node1_13_14 GND 16.0
C_1_13_14 Node1_13_14 GND 3.6093750000000004e-07
R_1_13_15_1 Node1_13_15 Node1_13_16 250.00000000000003
R_1_13_15_2 Node1_13_15 Node1_14_15 250.00000000000003
R_1_13_15_3 Node1_13_15 GND 16.0
C_1_13_15 Node1_13_15 GND 3.6093750000000004e-07
R_1_13_16_1 Node1_13_16 Node1_13_17 250.00000000000003
R_1_13_16_2 Node1_13_16 Node1_14_16 250.00000000000003
R_1_13_16_3 Node1_13_16 GND 16.0
C_1_13_16 Node1_13_16 GND 3.6093750000000004e-07
R_1_13_17_1 Node1_13_17 Node1_13_18 250.00000000000003
R_1_13_17_2 Node1_13_17 Node1_14_17 250.00000000000003
R_1_13_17_3 Node1_13_17 GND 16.0
C_1_13_17 Node1_13_17 GND 3.6093750000000004e-07
R_1_13_18_1 Node1_13_18 Node1_13_19 250.00000000000003
R_1_13_18_2 Node1_13_18 Node1_14_18 250.00000000000003
R_1_13_18_3 Node1_13_18 GND 16.0
C_1_13_18 Node1_13_18 GND 3.6093750000000004e-07
R_1_13_19_1 Node1_13_19 Node1_13_20 250.00000000000003
R_1_13_19_2 Node1_13_19 Node1_14_19 250.00000000000003
R_1_13_19_3 Node1_13_19 GND 16.0
C_1_13_19 Node1_13_19 GND 3.6093750000000004e-07
R_1_13_20_1 Node1_13_20 Node1_13_21 250.00000000000003
R_1_13_20_2 Node1_13_20 Node1_14_20 250.00000000000003
R_1_13_20_3 Node1_13_20 GND 16.0
C_1_13_20 Node1_13_20 GND 3.6093750000000004e-07
R_1_13_21_1 Node1_13_21 Node1_13_22 250.00000000000003
R_1_13_21_2 Node1_13_21 Node1_14_21 250.00000000000003
R_1_13_21_3 Node1_13_21 GND 16.0
C_1_13_21 Node1_13_21 GND 3.6093750000000004e-07
R_1_13_22_1 Node1_13_22 Node1_13_23 250.00000000000003
R_1_13_22_2 Node1_13_22 Node1_14_22 250.00000000000003
R_1_13_22_3 Node1_13_22 GND 16.0
C_1_13_22 Node1_13_22 GND 3.6093750000000004e-07
R_1_13_23_1 Node1_13_23 Node1_13_24 250.00000000000003
R_1_13_23_2 Node1_13_23 Node1_14_23 250.00000000000003
R_1_13_23_3 Node1_13_23 GND 16.0
C_1_13_23 Node1_13_23 GND 3.6093750000000004e-07
R_1_13_24_1 Node1_13_24 Node1_13_25 250.00000000000003
R_1_13_24_2 Node1_13_24 Node1_14_24 250.00000000000003
R_1_13_24_3 Node1_13_24 GND 16.0
C_1_13_24 Node1_13_24 GND 3.6093750000000004e-07
R_1_13_25_1 Node1_13_25 Node1_13_26 250.00000000000003
R_1_13_25_2 Node1_13_25 Node1_14_25 250.00000000000003
R_1_13_25_3 Node1_13_25 GND 16.0
C_1_13_25 Node1_13_25 GND 3.6093750000000004e-07
R_1_13_26_1 Node1_13_26 Node1_13_27 250.00000000000003
R_1_13_26_2 Node1_13_26 Node1_14_26 250.00000000000003
R_1_13_26_3 Node1_13_26 GND 16.0
C_1_13_26 Node1_13_26 GND 3.6093750000000004e-07
R_1_13_27_1 Node1_13_27 Node1_13_28 250.00000000000003
R_1_13_27_2 Node1_13_27 Node1_14_27 250.00000000000003
R_1_13_27_3 Node1_13_27 GND 16.0
C_1_13_27 Node1_13_27 GND 3.6093750000000004e-07
R_1_13_28_1 Node1_13_28 Node1_13_29 250.00000000000003
R_1_13_28_2 Node1_13_28 Node1_14_28 250.00000000000003
R_1_13_28_3 Node1_13_28 GND 16.0
C_1_13_28 Node1_13_28 GND 3.6093750000000004e-07
R_1_13_29_1 Node1_13_29 Node1_13_30 250.00000000000003
R_1_13_29_2 Node1_13_29 Node1_14_29 250.00000000000003
R_1_13_29_3 Node1_13_29 GND 16.0
C_1_13_29 Node1_13_29 GND 3.6093750000000004e-07
R_1_13_30_1 Node1_13_30 Node1_13_31 250.00000000000003
R_1_13_30_2 Node1_13_30 Node1_14_30 250.00000000000003
R_1_13_30_3 Node1_13_30 GND 16.0
C_1_13_30 Node1_13_30 GND 3.6093750000000004e-07
R_1_13_31_1 Node1_13_31 Node1_13_32 250.00000000000003
R_1_13_31_2 Node1_13_31 Node1_14_31 250.00000000000003
R_1_13_31_3 Node1_13_31 GND 16.0
C_1_13_31 Node1_13_31 GND 3.6093750000000004e-07
R_1_13_32_1 Node1_13_32 Node1_13_33 250.00000000000003
R_1_13_32_2 Node1_13_32 Node1_14_32 250.00000000000003
R_1_13_32_3 Node1_13_32 GND 16.0
C_1_13_32 Node1_13_32 GND 3.6093750000000004e-07
R_1_13_33_1 Node1_13_33 Node1_13_34 250.00000000000003
R_1_13_33_2 Node1_13_33 Node1_14_33 250.00000000000003
R_1_13_33_3 Node1_13_33 GND 16.0
C_1_13_33 Node1_13_33 GND 3.6093750000000004e-07
R_1_13_34_1 Node1_13_34 Node1_13_35 250.00000000000003
R_1_13_34_2 Node1_13_34 Node1_14_34 250.00000000000003
R_1_13_34_3 Node1_13_34 GND 16.0
C_1_13_34 Node1_13_34 GND 3.6093750000000004e-07
R_1_13_35_1 Node1_13_35 Node1_13_36 250.00000000000003
R_1_13_35_2 Node1_13_35 Node1_14_35 250.00000000000003
R_1_13_35_3 Node1_13_35 GND 16.0
C_1_13_35 Node1_13_35 GND 3.6093750000000004e-07
R_1_13_36_1 Node1_13_36 Node1_13_37 250.00000000000003
R_1_13_36_2 Node1_13_36 Node1_14_36 250.00000000000003
R_1_13_36_3 Node1_13_36 GND 16.0
C_1_13_36 Node1_13_36 GND 3.6093750000000004e-07
R_1_13_37_1 Node1_13_37 Node1_13_38 250.00000000000003
R_1_13_37_2 Node1_13_37 Node1_14_37 250.00000000000003
R_1_13_37_3 Node1_13_37 GND 16.0
C_1_13_37 Node1_13_37 GND 3.6093750000000004e-07
R_1_13_38_1 Node1_13_38 Node1_13_39 250.00000000000003
R_1_13_38_2 Node1_13_38 Node1_14_38 250.00000000000003
R_1_13_38_3 Node1_13_38 GND 16.0
C_1_13_38 Node1_13_38 GND 3.6093750000000004e-07
R_1_13_39_2 Node1_13_39 Node1_14_39 250.00000000000003
R_1_13_39_3 Node1_13_39 GND 16.0
C_1_13_39 Node1_13_39 GND 3.6093750000000004e-07
R_1_14_0_1 Node1_14_0 Node1_14_1 250.00000000000003
R_1_14_0_2 Node1_14_0 Node1_15_0 250.00000000000003
R_1_14_0_3 Node1_14_0 GND 16.0
C_1_14_0 Node1_14_0 GND 3.6093750000000004e-07
R_1_14_1_1 Node1_14_1 Node1_14_2 250.00000000000003
R_1_14_1_2 Node1_14_1 Node1_15_1 250.00000000000003
R_1_14_1_3 Node1_14_1 GND 16.0
C_1_14_1 Node1_14_1 GND 3.6093750000000004e-07
R_1_14_2_1 Node1_14_2 Node1_14_3 250.00000000000003
R_1_14_2_2 Node1_14_2 Node1_15_2 250.00000000000003
R_1_14_2_3 Node1_14_2 GND 16.0
C_1_14_2 Node1_14_2 GND 3.6093750000000004e-07
R_1_14_3_1 Node1_14_3 Node1_14_4 250.00000000000003
R_1_14_3_2 Node1_14_3 Node1_15_3 250.00000000000003
R_1_14_3_3 Node1_14_3 GND 16.0
C_1_14_3 Node1_14_3 GND 3.6093750000000004e-07
R_1_14_4_1 Node1_14_4 Node1_14_5 250.00000000000003
R_1_14_4_2 Node1_14_4 Node1_15_4 250.00000000000003
R_1_14_4_3 Node1_14_4 GND 16.0
C_1_14_4 Node1_14_4 GND 3.6093750000000004e-07
R_1_14_5_1 Node1_14_5 Node1_14_6 250.00000000000003
R_1_14_5_2 Node1_14_5 Node1_15_5 250.00000000000003
R_1_14_5_3 Node1_14_5 GND 16.0
C_1_14_5 Node1_14_5 GND 3.6093750000000004e-07
R_1_14_6_1 Node1_14_6 Node1_14_7 250.00000000000003
R_1_14_6_2 Node1_14_6 Node1_15_6 250.00000000000003
R_1_14_6_3 Node1_14_6 GND 16.0
C_1_14_6 Node1_14_6 GND 3.6093750000000004e-07
R_1_14_7_1 Node1_14_7 Node1_14_8 250.00000000000003
R_1_14_7_2 Node1_14_7 Node1_15_7 250.00000000000003
R_1_14_7_3 Node1_14_7 GND 16.0
C_1_14_7 Node1_14_7 GND 3.6093750000000004e-07
R_1_14_8_1 Node1_14_8 Node1_14_9 250.00000000000003
R_1_14_8_2 Node1_14_8 Node1_15_8 250.00000000000003
R_1_14_8_3 Node1_14_8 GND 16.0
C_1_14_8 Node1_14_8 GND 3.6093750000000004e-07
R_1_14_9_1 Node1_14_9 Node1_14_10 250.00000000000003
R_1_14_9_2 Node1_14_9 Node1_15_9 250.00000000000003
R_1_14_9_3 Node1_14_9 GND 16.0
C_1_14_9 Node1_14_9 GND 3.6093750000000004e-07
R_1_14_10_1 Node1_14_10 Node1_14_11 250.00000000000003
R_1_14_10_2 Node1_14_10 Node1_15_10 250.00000000000003
R_1_14_10_3 Node1_14_10 GND 16.0
C_1_14_10 Node1_14_10 GND 3.6093750000000004e-07
R_1_14_11_1 Node1_14_11 Node1_14_12 250.00000000000003
R_1_14_11_2 Node1_14_11 Node1_15_11 250.00000000000003
R_1_14_11_3 Node1_14_11 GND 16.0
C_1_14_11 Node1_14_11 GND 3.6093750000000004e-07
R_1_14_12_1 Node1_14_12 Node1_14_13 250.00000000000003
R_1_14_12_2 Node1_14_12 Node1_15_12 250.00000000000003
R_1_14_12_3 Node1_14_12 GND 16.0
C_1_14_12 Node1_14_12 GND 3.6093750000000004e-07
R_1_14_13_1 Node1_14_13 Node1_14_14 250.00000000000003
R_1_14_13_2 Node1_14_13 Node1_15_13 250.00000000000003
R_1_14_13_3 Node1_14_13 GND 16.0
C_1_14_13 Node1_14_13 GND 3.6093750000000004e-07
R_1_14_14_1 Node1_14_14 Node1_14_15 250.00000000000003
R_1_14_14_2 Node1_14_14 Node1_15_14 250.00000000000003
R_1_14_14_3 Node1_14_14 GND 16.0
C_1_14_14 Node1_14_14 GND 3.6093750000000004e-07
R_1_14_15_1 Node1_14_15 Node1_14_16 250.00000000000003
R_1_14_15_2 Node1_14_15 Node1_15_15 250.00000000000003
R_1_14_15_3 Node1_14_15 GND 16.0
C_1_14_15 Node1_14_15 GND 3.6093750000000004e-07
R_1_14_16_1 Node1_14_16 Node1_14_17 250.00000000000003
R_1_14_16_2 Node1_14_16 Node1_15_16 250.00000000000003
R_1_14_16_3 Node1_14_16 GND 16.0
C_1_14_16 Node1_14_16 GND 3.6093750000000004e-07
R_1_14_17_1 Node1_14_17 Node1_14_18 250.00000000000003
R_1_14_17_2 Node1_14_17 Node1_15_17 250.00000000000003
R_1_14_17_3 Node1_14_17 GND 16.0
C_1_14_17 Node1_14_17 GND 3.6093750000000004e-07
R_1_14_18_1 Node1_14_18 Node1_14_19 250.00000000000003
R_1_14_18_2 Node1_14_18 Node1_15_18 250.00000000000003
R_1_14_18_3 Node1_14_18 GND 16.0
C_1_14_18 Node1_14_18 GND 3.6093750000000004e-07
R_1_14_19_1 Node1_14_19 Node1_14_20 250.00000000000003
R_1_14_19_2 Node1_14_19 Node1_15_19 250.00000000000003
R_1_14_19_3 Node1_14_19 GND 16.0
C_1_14_19 Node1_14_19 GND 3.6093750000000004e-07
R_1_14_20_1 Node1_14_20 Node1_14_21 250.00000000000003
R_1_14_20_2 Node1_14_20 Node1_15_20 250.00000000000003
R_1_14_20_3 Node1_14_20 GND 16.0
C_1_14_20 Node1_14_20 GND 3.6093750000000004e-07
R_1_14_21_1 Node1_14_21 Node1_14_22 250.00000000000003
R_1_14_21_2 Node1_14_21 Node1_15_21 250.00000000000003
R_1_14_21_3 Node1_14_21 GND 16.0
C_1_14_21 Node1_14_21 GND 3.6093750000000004e-07
R_1_14_22_1 Node1_14_22 Node1_14_23 250.00000000000003
R_1_14_22_2 Node1_14_22 Node1_15_22 250.00000000000003
R_1_14_22_3 Node1_14_22 GND 16.0
C_1_14_22 Node1_14_22 GND 3.6093750000000004e-07
R_1_14_23_1 Node1_14_23 Node1_14_24 250.00000000000003
R_1_14_23_2 Node1_14_23 Node1_15_23 250.00000000000003
R_1_14_23_3 Node1_14_23 GND 16.0
C_1_14_23 Node1_14_23 GND 3.6093750000000004e-07
R_1_14_24_1 Node1_14_24 Node1_14_25 250.00000000000003
R_1_14_24_2 Node1_14_24 Node1_15_24 250.00000000000003
R_1_14_24_3 Node1_14_24 GND 16.0
C_1_14_24 Node1_14_24 GND 3.6093750000000004e-07
R_1_14_25_1 Node1_14_25 Node1_14_26 250.00000000000003
R_1_14_25_2 Node1_14_25 Node1_15_25 250.00000000000003
R_1_14_25_3 Node1_14_25 GND 16.0
C_1_14_25 Node1_14_25 GND 3.6093750000000004e-07
R_1_14_26_1 Node1_14_26 Node1_14_27 250.00000000000003
R_1_14_26_2 Node1_14_26 Node1_15_26 250.00000000000003
R_1_14_26_3 Node1_14_26 GND 16.0
C_1_14_26 Node1_14_26 GND 3.6093750000000004e-07
R_1_14_27_1 Node1_14_27 Node1_14_28 250.00000000000003
R_1_14_27_2 Node1_14_27 Node1_15_27 250.00000000000003
R_1_14_27_3 Node1_14_27 GND 16.0
C_1_14_27 Node1_14_27 GND 3.6093750000000004e-07
R_1_14_28_1 Node1_14_28 Node1_14_29 250.00000000000003
R_1_14_28_2 Node1_14_28 Node1_15_28 250.00000000000003
R_1_14_28_3 Node1_14_28 GND 16.0
C_1_14_28 Node1_14_28 GND 3.6093750000000004e-07
R_1_14_29_1 Node1_14_29 Node1_14_30 250.00000000000003
R_1_14_29_2 Node1_14_29 Node1_15_29 250.00000000000003
R_1_14_29_3 Node1_14_29 GND 16.0
C_1_14_29 Node1_14_29 GND 3.6093750000000004e-07
R_1_14_30_1 Node1_14_30 Node1_14_31 250.00000000000003
R_1_14_30_2 Node1_14_30 Node1_15_30 250.00000000000003
R_1_14_30_3 Node1_14_30 GND 16.0
C_1_14_30 Node1_14_30 GND 3.6093750000000004e-07
R_1_14_31_1 Node1_14_31 Node1_14_32 250.00000000000003
R_1_14_31_2 Node1_14_31 Node1_15_31 250.00000000000003
R_1_14_31_3 Node1_14_31 GND 16.0
C_1_14_31 Node1_14_31 GND 3.6093750000000004e-07
R_1_14_32_1 Node1_14_32 Node1_14_33 250.00000000000003
R_1_14_32_2 Node1_14_32 Node1_15_32 250.00000000000003
R_1_14_32_3 Node1_14_32 GND 16.0
C_1_14_32 Node1_14_32 GND 3.6093750000000004e-07
R_1_14_33_1 Node1_14_33 Node1_14_34 250.00000000000003
R_1_14_33_2 Node1_14_33 Node1_15_33 250.00000000000003
R_1_14_33_3 Node1_14_33 GND 16.0
C_1_14_33 Node1_14_33 GND 3.6093750000000004e-07
R_1_14_34_1 Node1_14_34 Node1_14_35 250.00000000000003
R_1_14_34_2 Node1_14_34 Node1_15_34 250.00000000000003
R_1_14_34_3 Node1_14_34 GND 16.0
C_1_14_34 Node1_14_34 GND 3.6093750000000004e-07
R_1_14_35_1 Node1_14_35 Node1_14_36 250.00000000000003
R_1_14_35_2 Node1_14_35 Node1_15_35 250.00000000000003
R_1_14_35_3 Node1_14_35 GND 16.0
C_1_14_35 Node1_14_35 GND 3.6093750000000004e-07
R_1_14_36_1 Node1_14_36 Node1_14_37 250.00000000000003
R_1_14_36_2 Node1_14_36 Node1_15_36 250.00000000000003
R_1_14_36_3 Node1_14_36 GND 16.0
C_1_14_36 Node1_14_36 GND 3.6093750000000004e-07
R_1_14_37_1 Node1_14_37 Node1_14_38 250.00000000000003
R_1_14_37_2 Node1_14_37 Node1_15_37 250.00000000000003
R_1_14_37_3 Node1_14_37 GND 16.0
C_1_14_37 Node1_14_37 GND 3.6093750000000004e-07
R_1_14_38_1 Node1_14_38 Node1_14_39 250.00000000000003
R_1_14_38_2 Node1_14_38 Node1_15_38 250.00000000000003
R_1_14_38_3 Node1_14_38 GND 16.0
C_1_14_38 Node1_14_38 GND 3.6093750000000004e-07
R_1_14_39_2 Node1_14_39 Node1_15_39 250.00000000000003
R_1_14_39_3 Node1_14_39 GND 16.0
C_1_14_39 Node1_14_39 GND 3.6093750000000004e-07
R_1_15_0_1 Node1_15_0 Node1_15_1 250.00000000000003
R_1_15_0_2 Node1_15_0 Node1_16_0 250.00000000000003
R_1_15_0_3 Node1_15_0 GND 16.0
C_1_15_0 Node1_15_0 GND 3.6093750000000004e-07
R_1_15_1_1 Node1_15_1 Node1_15_2 250.00000000000003
R_1_15_1_2 Node1_15_1 Node1_16_1 250.00000000000003
R_1_15_1_3 Node1_15_1 GND 16.0
C_1_15_1 Node1_15_1 GND 3.6093750000000004e-07
R_1_15_2_1 Node1_15_2 Node1_15_3 250.00000000000003
R_1_15_2_2 Node1_15_2 Node1_16_2 250.00000000000003
R_1_15_2_3 Node1_15_2 GND 16.0
C_1_15_2 Node1_15_2 GND 3.6093750000000004e-07
R_1_15_3_1 Node1_15_3 Node1_15_4 250.00000000000003
R_1_15_3_2 Node1_15_3 Node1_16_3 250.00000000000003
R_1_15_3_3 Node1_15_3 GND 16.0
C_1_15_3 Node1_15_3 GND 3.6093750000000004e-07
R_1_15_4_1 Node1_15_4 Node1_15_5 250.00000000000003
R_1_15_4_2 Node1_15_4 Node1_16_4 250.00000000000003
R_1_15_4_3 Node1_15_4 GND 16.0
C_1_15_4 Node1_15_4 GND 3.6093750000000004e-07
R_1_15_5_1 Node1_15_5 Node1_15_6 250.00000000000003
R_1_15_5_2 Node1_15_5 Node1_16_5 250.00000000000003
R_1_15_5_3 Node1_15_5 GND 16.0
C_1_15_5 Node1_15_5 GND 3.6093750000000004e-07
R_1_15_6_1 Node1_15_6 Node1_15_7 250.00000000000003
R_1_15_6_2 Node1_15_6 Node1_16_6 250.00000000000003
R_1_15_6_3 Node1_15_6 GND 16.0
C_1_15_6 Node1_15_6 GND 3.6093750000000004e-07
R_1_15_7_1 Node1_15_7 Node1_15_8 250.00000000000003
R_1_15_7_2 Node1_15_7 Node1_16_7 250.00000000000003
R_1_15_7_3 Node1_15_7 GND 16.0
C_1_15_7 Node1_15_7 GND 3.6093750000000004e-07
R_1_15_8_1 Node1_15_8 Node1_15_9 250.00000000000003
R_1_15_8_2 Node1_15_8 Node1_16_8 250.00000000000003
R_1_15_8_3 Node1_15_8 GND 16.0
C_1_15_8 Node1_15_8 GND 3.6093750000000004e-07
R_1_15_9_1 Node1_15_9 Node1_15_10 250.00000000000003
R_1_15_9_2 Node1_15_9 Node1_16_9 250.00000000000003
R_1_15_9_3 Node1_15_9 GND 16.0
C_1_15_9 Node1_15_9 GND 3.6093750000000004e-07
R_1_15_10_1 Node1_15_10 Node1_15_11 250.00000000000003
R_1_15_10_2 Node1_15_10 Node1_16_10 250.00000000000003
R_1_15_10_3 Node1_15_10 GND 16.0
C_1_15_10 Node1_15_10 GND 3.6093750000000004e-07
R_1_15_11_1 Node1_15_11 Node1_15_12 250.00000000000003
R_1_15_11_2 Node1_15_11 Node1_16_11 250.00000000000003
R_1_15_11_3 Node1_15_11 GND 16.0
C_1_15_11 Node1_15_11 GND 3.6093750000000004e-07
R_1_15_12_1 Node1_15_12 Node1_15_13 250.00000000000003
R_1_15_12_2 Node1_15_12 Node1_16_12 250.00000000000003
R_1_15_12_3 Node1_15_12 GND 16.0
C_1_15_12 Node1_15_12 GND 3.6093750000000004e-07
R_1_15_13_1 Node1_15_13 Node1_15_14 250.00000000000003
R_1_15_13_2 Node1_15_13 Node1_16_13 250.00000000000003
R_1_15_13_3 Node1_15_13 GND 16.0
C_1_15_13 Node1_15_13 GND 3.6093750000000004e-07
R_1_15_14_1 Node1_15_14 Node1_15_15 250.00000000000003
R_1_15_14_2 Node1_15_14 Node1_16_14 250.00000000000003
R_1_15_14_3 Node1_15_14 GND 16.0
C_1_15_14 Node1_15_14 GND 3.6093750000000004e-07
R_1_15_15_1 Node1_15_15 Node1_15_16 250.00000000000003
R_1_15_15_2 Node1_15_15 Node1_16_15 250.00000000000003
R_1_15_15_3 Node1_15_15 GND 16.0
C_1_15_15 Node1_15_15 GND 3.6093750000000004e-07
R_1_15_16_1 Node1_15_16 Node1_15_17 250.00000000000003
R_1_15_16_2 Node1_15_16 Node1_16_16 250.00000000000003
R_1_15_16_3 Node1_15_16 GND 16.0
C_1_15_16 Node1_15_16 GND 3.6093750000000004e-07
R_1_15_17_1 Node1_15_17 Node1_15_18 250.00000000000003
R_1_15_17_2 Node1_15_17 Node1_16_17 250.00000000000003
R_1_15_17_3 Node1_15_17 GND 16.0
C_1_15_17 Node1_15_17 GND 3.6093750000000004e-07
R_1_15_18_1 Node1_15_18 Node1_15_19 250.00000000000003
R_1_15_18_2 Node1_15_18 Node1_16_18 250.00000000000003
R_1_15_18_3 Node1_15_18 GND 16.0
C_1_15_18 Node1_15_18 GND 3.6093750000000004e-07
R_1_15_19_1 Node1_15_19 Node1_15_20 250.00000000000003
R_1_15_19_2 Node1_15_19 Node1_16_19 250.00000000000003
R_1_15_19_3 Node1_15_19 GND 16.0
C_1_15_19 Node1_15_19 GND 3.6093750000000004e-07
R_1_15_20_1 Node1_15_20 Node1_15_21 250.00000000000003
R_1_15_20_2 Node1_15_20 Node1_16_20 250.00000000000003
R_1_15_20_3 Node1_15_20 GND 16.0
C_1_15_20 Node1_15_20 GND 3.6093750000000004e-07
R_1_15_21_1 Node1_15_21 Node1_15_22 250.00000000000003
R_1_15_21_2 Node1_15_21 Node1_16_21 250.00000000000003
R_1_15_21_3 Node1_15_21 GND 16.0
C_1_15_21 Node1_15_21 GND 3.6093750000000004e-07
R_1_15_22_1 Node1_15_22 Node1_15_23 250.00000000000003
R_1_15_22_2 Node1_15_22 Node1_16_22 250.00000000000003
R_1_15_22_3 Node1_15_22 GND 16.0
C_1_15_22 Node1_15_22 GND 3.6093750000000004e-07
R_1_15_23_1 Node1_15_23 Node1_15_24 250.00000000000003
R_1_15_23_2 Node1_15_23 Node1_16_23 250.00000000000003
R_1_15_23_3 Node1_15_23 GND 16.0
C_1_15_23 Node1_15_23 GND 3.6093750000000004e-07
R_1_15_24_1 Node1_15_24 Node1_15_25 250.00000000000003
R_1_15_24_2 Node1_15_24 Node1_16_24 250.00000000000003
R_1_15_24_3 Node1_15_24 GND 16.0
C_1_15_24 Node1_15_24 GND 3.6093750000000004e-07
R_1_15_25_1 Node1_15_25 Node1_15_26 250.00000000000003
R_1_15_25_2 Node1_15_25 Node1_16_25 250.00000000000003
R_1_15_25_3 Node1_15_25 GND 16.0
C_1_15_25 Node1_15_25 GND 3.6093750000000004e-07
R_1_15_26_1 Node1_15_26 Node1_15_27 250.00000000000003
R_1_15_26_2 Node1_15_26 Node1_16_26 250.00000000000003
R_1_15_26_3 Node1_15_26 GND 16.0
C_1_15_26 Node1_15_26 GND 3.6093750000000004e-07
R_1_15_27_1 Node1_15_27 Node1_15_28 250.00000000000003
R_1_15_27_2 Node1_15_27 Node1_16_27 250.00000000000003
R_1_15_27_3 Node1_15_27 GND 16.0
C_1_15_27 Node1_15_27 GND 3.6093750000000004e-07
R_1_15_28_1 Node1_15_28 Node1_15_29 250.00000000000003
R_1_15_28_2 Node1_15_28 Node1_16_28 250.00000000000003
R_1_15_28_3 Node1_15_28 GND 16.0
C_1_15_28 Node1_15_28 GND 3.6093750000000004e-07
R_1_15_29_1 Node1_15_29 Node1_15_30 250.00000000000003
R_1_15_29_2 Node1_15_29 Node1_16_29 250.00000000000003
R_1_15_29_3 Node1_15_29 GND 16.0
C_1_15_29 Node1_15_29 GND 3.6093750000000004e-07
R_1_15_30_1 Node1_15_30 Node1_15_31 250.00000000000003
R_1_15_30_2 Node1_15_30 Node1_16_30 250.00000000000003
R_1_15_30_3 Node1_15_30 GND 16.0
C_1_15_30 Node1_15_30 GND 3.6093750000000004e-07
R_1_15_31_1 Node1_15_31 Node1_15_32 250.00000000000003
R_1_15_31_2 Node1_15_31 Node1_16_31 250.00000000000003
R_1_15_31_3 Node1_15_31 GND 16.0
C_1_15_31 Node1_15_31 GND 3.6093750000000004e-07
R_1_15_32_1 Node1_15_32 Node1_15_33 250.00000000000003
R_1_15_32_2 Node1_15_32 Node1_16_32 250.00000000000003
R_1_15_32_3 Node1_15_32 GND 16.0
C_1_15_32 Node1_15_32 GND 3.6093750000000004e-07
R_1_15_33_1 Node1_15_33 Node1_15_34 250.00000000000003
R_1_15_33_2 Node1_15_33 Node1_16_33 250.00000000000003
R_1_15_33_3 Node1_15_33 GND 16.0
C_1_15_33 Node1_15_33 GND 3.6093750000000004e-07
R_1_15_34_1 Node1_15_34 Node1_15_35 250.00000000000003
R_1_15_34_2 Node1_15_34 Node1_16_34 250.00000000000003
R_1_15_34_3 Node1_15_34 GND 16.0
C_1_15_34 Node1_15_34 GND 3.6093750000000004e-07
R_1_15_35_1 Node1_15_35 Node1_15_36 250.00000000000003
R_1_15_35_2 Node1_15_35 Node1_16_35 250.00000000000003
R_1_15_35_3 Node1_15_35 GND 16.0
C_1_15_35 Node1_15_35 GND 3.6093750000000004e-07
R_1_15_36_1 Node1_15_36 Node1_15_37 250.00000000000003
R_1_15_36_2 Node1_15_36 Node1_16_36 250.00000000000003
R_1_15_36_3 Node1_15_36 GND 16.0
C_1_15_36 Node1_15_36 GND 3.6093750000000004e-07
R_1_15_37_1 Node1_15_37 Node1_15_38 250.00000000000003
R_1_15_37_2 Node1_15_37 Node1_16_37 250.00000000000003
R_1_15_37_3 Node1_15_37 GND 16.0
C_1_15_37 Node1_15_37 GND 3.6093750000000004e-07
R_1_15_38_1 Node1_15_38 Node1_15_39 250.00000000000003
R_1_15_38_2 Node1_15_38 Node1_16_38 250.00000000000003
R_1_15_38_3 Node1_15_38 GND 16.0
C_1_15_38 Node1_15_38 GND 3.6093750000000004e-07
R_1_15_39_2 Node1_15_39 Node1_16_39 250.00000000000003
R_1_15_39_3 Node1_15_39 GND 16.0
C_1_15_39 Node1_15_39 GND 3.6093750000000004e-07
R_1_16_0_1 Node1_16_0 Node1_16_1 250.00000000000003
R_1_16_0_2 Node1_16_0 Node1_17_0 250.00000000000003
R_1_16_0_3 Node1_16_0 GND 16.0
C_1_16_0 Node1_16_0 GND 3.6093750000000004e-07
R_1_16_1_1 Node1_16_1 Node1_16_2 250.00000000000003
R_1_16_1_2 Node1_16_1 Node1_17_1 250.00000000000003
R_1_16_1_3 Node1_16_1 GND 16.0
C_1_16_1 Node1_16_1 GND 3.6093750000000004e-07
R_1_16_2_1 Node1_16_2 Node1_16_3 250.00000000000003
R_1_16_2_2 Node1_16_2 Node1_17_2 250.00000000000003
R_1_16_2_3 Node1_16_2 GND 16.0
C_1_16_2 Node1_16_2 GND 3.6093750000000004e-07
R_1_16_3_1 Node1_16_3 Node1_16_4 250.00000000000003
R_1_16_3_2 Node1_16_3 Node1_17_3 250.00000000000003
R_1_16_3_3 Node1_16_3 GND 16.0
C_1_16_3 Node1_16_3 GND 3.6093750000000004e-07
R_1_16_4_1 Node1_16_4 Node1_16_5 250.00000000000003
R_1_16_4_2 Node1_16_4 Node1_17_4 250.00000000000003
R_1_16_4_3 Node1_16_4 GND 16.0
C_1_16_4 Node1_16_4 GND 3.6093750000000004e-07
R_1_16_5_1 Node1_16_5 Node1_16_6 250.00000000000003
R_1_16_5_2 Node1_16_5 Node1_17_5 250.00000000000003
R_1_16_5_3 Node1_16_5 GND 16.0
C_1_16_5 Node1_16_5 GND 3.6093750000000004e-07
R_1_16_6_1 Node1_16_6 Node1_16_7 250.00000000000003
R_1_16_6_2 Node1_16_6 Node1_17_6 250.00000000000003
R_1_16_6_3 Node1_16_6 GND 16.0
C_1_16_6 Node1_16_6 GND 3.6093750000000004e-07
R_1_16_7_1 Node1_16_7 Node1_16_8 250.00000000000003
R_1_16_7_2 Node1_16_7 Node1_17_7 250.00000000000003
R_1_16_7_3 Node1_16_7 GND 16.0
C_1_16_7 Node1_16_7 GND 3.6093750000000004e-07
R_1_16_8_1 Node1_16_8 Node1_16_9 250.00000000000003
R_1_16_8_2 Node1_16_8 Node1_17_8 250.00000000000003
R_1_16_8_3 Node1_16_8 GND 16.0
C_1_16_8 Node1_16_8 GND 3.6093750000000004e-07
R_1_16_9_1 Node1_16_9 Node1_16_10 250.00000000000003
R_1_16_9_2 Node1_16_9 Node1_17_9 250.00000000000003
R_1_16_9_3 Node1_16_9 GND 16.0
C_1_16_9 Node1_16_9 GND 3.6093750000000004e-07
R_1_16_10_1 Node1_16_10 Node1_16_11 250.00000000000003
R_1_16_10_2 Node1_16_10 Node1_17_10 250.00000000000003
R_1_16_10_3 Node1_16_10 GND 16.0
C_1_16_10 Node1_16_10 GND 3.6093750000000004e-07
R_1_16_11_1 Node1_16_11 Node1_16_12 250.00000000000003
R_1_16_11_2 Node1_16_11 Node1_17_11 250.00000000000003
R_1_16_11_3 Node1_16_11 GND 16.0
C_1_16_11 Node1_16_11 GND 3.6093750000000004e-07
R_1_16_12_1 Node1_16_12 Node1_16_13 250.00000000000003
R_1_16_12_2 Node1_16_12 Node1_17_12 250.00000000000003
R_1_16_12_3 Node1_16_12 GND 16.0
C_1_16_12 Node1_16_12 GND 3.6093750000000004e-07
R_1_16_13_1 Node1_16_13 Node1_16_14 250.00000000000003
R_1_16_13_2 Node1_16_13 Node1_17_13 250.00000000000003
R_1_16_13_3 Node1_16_13 GND 16.0
C_1_16_13 Node1_16_13 GND 3.6093750000000004e-07
R_1_16_14_1 Node1_16_14 Node1_16_15 250.00000000000003
R_1_16_14_2 Node1_16_14 Node1_17_14 250.00000000000003
R_1_16_14_3 Node1_16_14 GND 16.0
C_1_16_14 Node1_16_14 GND 3.6093750000000004e-07
R_1_16_15_1 Node1_16_15 Node1_16_16 250.00000000000003
R_1_16_15_2 Node1_16_15 Node1_17_15 250.00000000000003
R_1_16_15_3 Node1_16_15 GND 16.0
C_1_16_15 Node1_16_15 GND 3.6093750000000004e-07
R_1_16_16_1 Node1_16_16 Node1_16_17 250.00000000000003
R_1_16_16_2 Node1_16_16 Node1_17_16 250.00000000000003
R_1_16_16_3 Node1_16_16 GND 16.0
C_1_16_16 Node1_16_16 GND 3.6093750000000004e-07
R_1_16_17_1 Node1_16_17 Node1_16_18 250.00000000000003
R_1_16_17_2 Node1_16_17 Node1_17_17 250.00000000000003
R_1_16_17_3 Node1_16_17 GND 16.0
C_1_16_17 Node1_16_17 GND 3.6093750000000004e-07
R_1_16_18_1 Node1_16_18 Node1_16_19 250.00000000000003
R_1_16_18_2 Node1_16_18 Node1_17_18 250.00000000000003
R_1_16_18_3 Node1_16_18 GND 16.0
C_1_16_18 Node1_16_18 GND 3.6093750000000004e-07
R_1_16_19_1 Node1_16_19 Node1_16_20 250.00000000000003
R_1_16_19_2 Node1_16_19 Node1_17_19 250.00000000000003
R_1_16_19_3 Node1_16_19 GND 16.0
C_1_16_19 Node1_16_19 GND 3.6093750000000004e-07
R_1_16_20_1 Node1_16_20 Node1_16_21 250.00000000000003
R_1_16_20_2 Node1_16_20 Node1_17_20 250.00000000000003
R_1_16_20_3 Node1_16_20 GND 16.0
C_1_16_20 Node1_16_20 GND 3.6093750000000004e-07
R_1_16_21_1 Node1_16_21 Node1_16_22 250.00000000000003
R_1_16_21_2 Node1_16_21 Node1_17_21 250.00000000000003
R_1_16_21_3 Node1_16_21 GND 16.0
C_1_16_21 Node1_16_21 GND 3.6093750000000004e-07
R_1_16_22_1 Node1_16_22 Node1_16_23 250.00000000000003
R_1_16_22_2 Node1_16_22 Node1_17_22 250.00000000000003
R_1_16_22_3 Node1_16_22 GND 16.0
C_1_16_22 Node1_16_22 GND 3.6093750000000004e-07
R_1_16_23_1 Node1_16_23 Node1_16_24 250.00000000000003
R_1_16_23_2 Node1_16_23 Node1_17_23 250.00000000000003
R_1_16_23_3 Node1_16_23 GND 16.0
C_1_16_23 Node1_16_23 GND 3.6093750000000004e-07
R_1_16_24_1 Node1_16_24 Node1_16_25 250.00000000000003
R_1_16_24_2 Node1_16_24 Node1_17_24 250.00000000000003
R_1_16_24_3 Node1_16_24 GND 16.0
C_1_16_24 Node1_16_24 GND 3.6093750000000004e-07
R_1_16_25_1 Node1_16_25 Node1_16_26 250.00000000000003
R_1_16_25_2 Node1_16_25 Node1_17_25 250.00000000000003
R_1_16_25_3 Node1_16_25 GND 16.0
C_1_16_25 Node1_16_25 GND 3.6093750000000004e-07
R_1_16_26_1 Node1_16_26 Node1_16_27 250.00000000000003
R_1_16_26_2 Node1_16_26 Node1_17_26 250.00000000000003
R_1_16_26_3 Node1_16_26 GND 16.0
C_1_16_26 Node1_16_26 GND 3.6093750000000004e-07
R_1_16_27_1 Node1_16_27 Node1_16_28 250.00000000000003
R_1_16_27_2 Node1_16_27 Node1_17_27 250.00000000000003
R_1_16_27_3 Node1_16_27 GND 16.0
C_1_16_27 Node1_16_27 GND 3.6093750000000004e-07
R_1_16_28_1 Node1_16_28 Node1_16_29 250.00000000000003
R_1_16_28_2 Node1_16_28 Node1_17_28 250.00000000000003
R_1_16_28_3 Node1_16_28 GND 16.0
C_1_16_28 Node1_16_28 GND 3.6093750000000004e-07
R_1_16_29_1 Node1_16_29 Node1_16_30 250.00000000000003
R_1_16_29_2 Node1_16_29 Node1_17_29 250.00000000000003
R_1_16_29_3 Node1_16_29 GND 16.0
C_1_16_29 Node1_16_29 GND 3.6093750000000004e-07
R_1_16_30_1 Node1_16_30 Node1_16_31 250.00000000000003
R_1_16_30_2 Node1_16_30 Node1_17_30 250.00000000000003
R_1_16_30_3 Node1_16_30 GND 16.0
C_1_16_30 Node1_16_30 GND 3.6093750000000004e-07
R_1_16_31_1 Node1_16_31 Node1_16_32 250.00000000000003
R_1_16_31_2 Node1_16_31 Node1_17_31 250.00000000000003
R_1_16_31_3 Node1_16_31 GND 16.0
C_1_16_31 Node1_16_31 GND 3.6093750000000004e-07
R_1_16_32_1 Node1_16_32 Node1_16_33 250.00000000000003
R_1_16_32_2 Node1_16_32 Node1_17_32 250.00000000000003
R_1_16_32_3 Node1_16_32 GND 16.0
C_1_16_32 Node1_16_32 GND 3.6093750000000004e-07
R_1_16_33_1 Node1_16_33 Node1_16_34 250.00000000000003
R_1_16_33_2 Node1_16_33 Node1_17_33 250.00000000000003
R_1_16_33_3 Node1_16_33 GND 16.0
C_1_16_33 Node1_16_33 GND 3.6093750000000004e-07
R_1_16_34_1 Node1_16_34 Node1_16_35 250.00000000000003
R_1_16_34_2 Node1_16_34 Node1_17_34 250.00000000000003
R_1_16_34_3 Node1_16_34 GND 16.0
C_1_16_34 Node1_16_34 GND 3.6093750000000004e-07
R_1_16_35_1 Node1_16_35 Node1_16_36 250.00000000000003
R_1_16_35_2 Node1_16_35 Node1_17_35 250.00000000000003
R_1_16_35_3 Node1_16_35 GND 16.0
C_1_16_35 Node1_16_35 GND 3.6093750000000004e-07
R_1_16_36_1 Node1_16_36 Node1_16_37 250.00000000000003
R_1_16_36_2 Node1_16_36 Node1_17_36 250.00000000000003
R_1_16_36_3 Node1_16_36 GND 16.0
C_1_16_36 Node1_16_36 GND 3.6093750000000004e-07
R_1_16_37_1 Node1_16_37 Node1_16_38 250.00000000000003
R_1_16_37_2 Node1_16_37 Node1_17_37 250.00000000000003
R_1_16_37_3 Node1_16_37 GND 16.0
C_1_16_37 Node1_16_37 GND 3.6093750000000004e-07
R_1_16_38_1 Node1_16_38 Node1_16_39 250.00000000000003
R_1_16_38_2 Node1_16_38 Node1_17_38 250.00000000000003
R_1_16_38_3 Node1_16_38 GND 16.0
C_1_16_38 Node1_16_38 GND 3.6093750000000004e-07
R_1_16_39_2 Node1_16_39 Node1_17_39 250.00000000000003
R_1_16_39_3 Node1_16_39 GND 16.0
C_1_16_39 Node1_16_39 GND 3.6093750000000004e-07
R_1_17_0_1 Node1_17_0 Node1_17_1 250.00000000000003
R_1_17_0_2 Node1_17_0 Node1_18_0 250.00000000000003
R_1_17_0_3 Node1_17_0 GND 16.0
C_1_17_0 Node1_17_0 GND 3.6093750000000004e-07
R_1_17_1_1 Node1_17_1 Node1_17_2 250.00000000000003
R_1_17_1_2 Node1_17_1 Node1_18_1 250.00000000000003
R_1_17_1_3 Node1_17_1 GND 16.0
C_1_17_1 Node1_17_1 GND 3.6093750000000004e-07
R_1_17_2_1 Node1_17_2 Node1_17_3 250.00000000000003
R_1_17_2_2 Node1_17_2 Node1_18_2 250.00000000000003
R_1_17_2_3 Node1_17_2 GND 16.0
C_1_17_2 Node1_17_2 GND 3.6093750000000004e-07
R_1_17_3_1 Node1_17_3 Node1_17_4 250.00000000000003
R_1_17_3_2 Node1_17_3 Node1_18_3 250.00000000000003
R_1_17_3_3 Node1_17_3 GND 16.0
C_1_17_3 Node1_17_3 GND 3.6093750000000004e-07
R_1_17_4_1 Node1_17_4 Node1_17_5 250.00000000000003
R_1_17_4_2 Node1_17_4 Node1_18_4 250.00000000000003
R_1_17_4_3 Node1_17_4 GND 16.0
C_1_17_4 Node1_17_4 GND 3.6093750000000004e-07
R_1_17_5_1 Node1_17_5 Node1_17_6 250.00000000000003
R_1_17_5_2 Node1_17_5 Node1_18_5 250.00000000000003
R_1_17_5_3 Node1_17_5 GND 16.0
C_1_17_5 Node1_17_5 GND 3.6093750000000004e-07
R_1_17_6_1 Node1_17_6 Node1_17_7 250.00000000000003
R_1_17_6_2 Node1_17_6 Node1_18_6 250.00000000000003
R_1_17_6_3 Node1_17_6 GND 16.0
C_1_17_6 Node1_17_6 GND 3.6093750000000004e-07
R_1_17_7_1 Node1_17_7 Node1_17_8 250.00000000000003
R_1_17_7_2 Node1_17_7 Node1_18_7 250.00000000000003
R_1_17_7_3 Node1_17_7 GND 16.0
C_1_17_7 Node1_17_7 GND 3.6093750000000004e-07
R_1_17_8_1 Node1_17_8 Node1_17_9 250.00000000000003
R_1_17_8_2 Node1_17_8 Node1_18_8 250.00000000000003
R_1_17_8_3 Node1_17_8 GND 16.0
C_1_17_8 Node1_17_8 GND 3.6093750000000004e-07
R_1_17_9_1 Node1_17_9 Node1_17_10 250.00000000000003
R_1_17_9_2 Node1_17_9 Node1_18_9 250.00000000000003
R_1_17_9_3 Node1_17_9 GND 16.0
C_1_17_9 Node1_17_9 GND 3.6093750000000004e-07
R_1_17_10_1 Node1_17_10 Node1_17_11 250.00000000000003
R_1_17_10_2 Node1_17_10 Node1_18_10 250.00000000000003
R_1_17_10_3 Node1_17_10 GND 16.0
C_1_17_10 Node1_17_10 GND 3.6093750000000004e-07
R_1_17_11_1 Node1_17_11 Node1_17_12 250.00000000000003
R_1_17_11_2 Node1_17_11 Node1_18_11 250.00000000000003
R_1_17_11_3 Node1_17_11 GND 16.0
C_1_17_11 Node1_17_11 GND 3.6093750000000004e-07
R_1_17_12_1 Node1_17_12 Node1_17_13 250.00000000000003
R_1_17_12_2 Node1_17_12 Node1_18_12 250.00000000000003
R_1_17_12_3 Node1_17_12 GND 16.0
C_1_17_12 Node1_17_12 GND 3.6093750000000004e-07
R_1_17_13_1 Node1_17_13 Node1_17_14 250.00000000000003
R_1_17_13_2 Node1_17_13 Node1_18_13 250.00000000000003
R_1_17_13_3 Node1_17_13 GND 16.0
C_1_17_13 Node1_17_13 GND 3.6093750000000004e-07
R_1_17_14_1 Node1_17_14 Node1_17_15 250.00000000000003
R_1_17_14_2 Node1_17_14 Node1_18_14 250.00000000000003
R_1_17_14_3 Node1_17_14 GND 16.0
C_1_17_14 Node1_17_14 GND 3.6093750000000004e-07
R_1_17_15_1 Node1_17_15 Node1_17_16 250.00000000000003
R_1_17_15_2 Node1_17_15 Node1_18_15 250.00000000000003
R_1_17_15_3 Node1_17_15 GND 16.0
C_1_17_15 Node1_17_15 GND 3.6093750000000004e-07
R_1_17_16_1 Node1_17_16 Node1_17_17 250.00000000000003
R_1_17_16_2 Node1_17_16 Node1_18_16 250.00000000000003
R_1_17_16_3 Node1_17_16 GND 16.0
C_1_17_16 Node1_17_16 GND 3.6093750000000004e-07
R_1_17_17_1 Node1_17_17 Node1_17_18 250.00000000000003
R_1_17_17_2 Node1_17_17 Node1_18_17 250.00000000000003
R_1_17_17_3 Node1_17_17 GND 16.0
C_1_17_17 Node1_17_17 GND 3.6093750000000004e-07
R_1_17_18_1 Node1_17_18 Node1_17_19 250.00000000000003
R_1_17_18_2 Node1_17_18 Node1_18_18 250.00000000000003
R_1_17_18_3 Node1_17_18 GND 16.0
C_1_17_18 Node1_17_18 GND 3.6093750000000004e-07
R_1_17_19_1 Node1_17_19 Node1_17_20 250.00000000000003
R_1_17_19_2 Node1_17_19 Node1_18_19 250.00000000000003
R_1_17_19_3 Node1_17_19 GND 16.0
C_1_17_19 Node1_17_19 GND 3.6093750000000004e-07
R_1_17_20_1 Node1_17_20 Node1_17_21 250.00000000000003
R_1_17_20_2 Node1_17_20 Node1_18_20 250.00000000000003
R_1_17_20_3 Node1_17_20 GND 16.0
C_1_17_20 Node1_17_20 GND 3.6093750000000004e-07
R_1_17_21_1 Node1_17_21 Node1_17_22 250.00000000000003
R_1_17_21_2 Node1_17_21 Node1_18_21 250.00000000000003
R_1_17_21_3 Node1_17_21 GND 16.0
C_1_17_21 Node1_17_21 GND 3.6093750000000004e-07
R_1_17_22_1 Node1_17_22 Node1_17_23 250.00000000000003
R_1_17_22_2 Node1_17_22 Node1_18_22 250.00000000000003
R_1_17_22_3 Node1_17_22 GND 16.0
C_1_17_22 Node1_17_22 GND 3.6093750000000004e-07
R_1_17_23_1 Node1_17_23 Node1_17_24 250.00000000000003
R_1_17_23_2 Node1_17_23 Node1_18_23 250.00000000000003
R_1_17_23_3 Node1_17_23 GND 16.0
C_1_17_23 Node1_17_23 GND 3.6093750000000004e-07
R_1_17_24_1 Node1_17_24 Node1_17_25 250.00000000000003
R_1_17_24_2 Node1_17_24 Node1_18_24 250.00000000000003
R_1_17_24_3 Node1_17_24 GND 16.0
C_1_17_24 Node1_17_24 GND 3.6093750000000004e-07
R_1_17_25_1 Node1_17_25 Node1_17_26 250.00000000000003
R_1_17_25_2 Node1_17_25 Node1_18_25 250.00000000000003
R_1_17_25_3 Node1_17_25 GND 16.0
C_1_17_25 Node1_17_25 GND 3.6093750000000004e-07
R_1_17_26_1 Node1_17_26 Node1_17_27 250.00000000000003
R_1_17_26_2 Node1_17_26 Node1_18_26 250.00000000000003
R_1_17_26_3 Node1_17_26 GND 16.0
C_1_17_26 Node1_17_26 GND 3.6093750000000004e-07
R_1_17_27_1 Node1_17_27 Node1_17_28 250.00000000000003
R_1_17_27_2 Node1_17_27 Node1_18_27 250.00000000000003
R_1_17_27_3 Node1_17_27 GND 16.0
C_1_17_27 Node1_17_27 GND 3.6093750000000004e-07
R_1_17_28_1 Node1_17_28 Node1_17_29 250.00000000000003
R_1_17_28_2 Node1_17_28 Node1_18_28 250.00000000000003
R_1_17_28_3 Node1_17_28 GND 16.0
C_1_17_28 Node1_17_28 GND 3.6093750000000004e-07
R_1_17_29_1 Node1_17_29 Node1_17_30 250.00000000000003
R_1_17_29_2 Node1_17_29 Node1_18_29 250.00000000000003
R_1_17_29_3 Node1_17_29 GND 16.0
C_1_17_29 Node1_17_29 GND 3.6093750000000004e-07
R_1_17_30_1 Node1_17_30 Node1_17_31 250.00000000000003
R_1_17_30_2 Node1_17_30 Node1_18_30 250.00000000000003
R_1_17_30_3 Node1_17_30 GND 16.0
C_1_17_30 Node1_17_30 GND 3.6093750000000004e-07
R_1_17_31_1 Node1_17_31 Node1_17_32 250.00000000000003
R_1_17_31_2 Node1_17_31 Node1_18_31 250.00000000000003
R_1_17_31_3 Node1_17_31 GND 16.0
C_1_17_31 Node1_17_31 GND 3.6093750000000004e-07
R_1_17_32_1 Node1_17_32 Node1_17_33 250.00000000000003
R_1_17_32_2 Node1_17_32 Node1_18_32 250.00000000000003
R_1_17_32_3 Node1_17_32 GND 16.0
C_1_17_32 Node1_17_32 GND 3.6093750000000004e-07
R_1_17_33_1 Node1_17_33 Node1_17_34 250.00000000000003
R_1_17_33_2 Node1_17_33 Node1_18_33 250.00000000000003
R_1_17_33_3 Node1_17_33 GND 16.0
C_1_17_33 Node1_17_33 GND 3.6093750000000004e-07
R_1_17_34_1 Node1_17_34 Node1_17_35 250.00000000000003
R_1_17_34_2 Node1_17_34 Node1_18_34 250.00000000000003
R_1_17_34_3 Node1_17_34 GND 16.0
C_1_17_34 Node1_17_34 GND 3.6093750000000004e-07
R_1_17_35_1 Node1_17_35 Node1_17_36 250.00000000000003
R_1_17_35_2 Node1_17_35 Node1_18_35 250.00000000000003
R_1_17_35_3 Node1_17_35 GND 16.0
C_1_17_35 Node1_17_35 GND 3.6093750000000004e-07
R_1_17_36_1 Node1_17_36 Node1_17_37 250.00000000000003
R_1_17_36_2 Node1_17_36 Node1_18_36 250.00000000000003
R_1_17_36_3 Node1_17_36 GND 16.0
C_1_17_36 Node1_17_36 GND 3.6093750000000004e-07
R_1_17_37_1 Node1_17_37 Node1_17_38 250.00000000000003
R_1_17_37_2 Node1_17_37 Node1_18_37 250.00000000000003
R_1_17_37_3 Node1_17_37 GND 16.0
C_1_17_37 Node1_17_37 GND 3.6093750000000004e-07
R_1_17_38_1 Node1_17_38 Node1_17_39 250.00000000000003
R_1_17_38_2 Node1_17_38 Node1_18_38 250.00000000000003
R_1_17_38_3 Node1_17_38 GND 16.0
C_1_17_38 Node1_17_38 GND 3.6093750000000004e-07
R_1_17_39_2 Node1_17_39 Node1_18_39 250.00000000000003
R_1_17_39_3 Node1_17_39 GND 16.0
C_1_17_39 Node1_17_39 GND 3.6093750000000004e-07
R_1_18_0_1 Node1_18_0 Node1_18_1 250.00000000000003
R_1_18_0_2 Node1_18_0 Node1_19_0 250.00000000000003
R_1_18_0_3 Node1_18_0 GND 16.0
C_1_18_0 Node1_18_0 GND 3.6093750000000004e-07
R_1_18_1_1 Node1_18_1 Node1_18_2 250.00000000000003
R_1_18_1_2 Node1_18_1 Node1_19_1 250.00000000000003
R_1_18_1_3 Node1_18_1 GND 16.0
C_1_18_1 Node1_18_1 GND 3.6093750000000004e-07
R_1_18_2_1 Node1_18_2 Node1_18_3 250.00000000000003
R_1_18_2_2 Node1_18_2 Node1_19_2 250.00000000000003
R_1_18_2_3 Node1_18_2 GND 16.0
C_1_18_2 Node1_18_2 GND 3.6093750000000004e-07
R_1_18_3_1 Node1_18_3 Node1_18_4 250.00000000000003
R_1_18_3_2 Node1_18_3 Node1_19_3 250.00000000000003
R_1_18_3_3 Node1_18_3 GND 16.0
C_1_18_3 Node1_18_3 GND 3.6093750000000004e-07
R_1_18_4_1 Node1_18_4 Node1_18_5 250.00000000000003
R_1_18_4_2 Node1_18_4 Node1_19_4 250.00000000000003
R_1_18_4_3 Node1_18_4 GND 16.0
C_1_18_4 Node1_18_4 GND 3.6093750000000004e-07
R_1_18_5_1 Node1_18_5 Node1_18_6 250.00000000000003
R_1_18_5_2 Node1_18_5 Node1_19_5 250.00000000000003
R_1_18_5_3 Node1_18_5 GND 16.0
C_1_18_5 Node1_18_5 GND 3.6093750000000004e-07
R_1_18_6_1 Node1_18_6 Node1_18_7 250.00000000000003
R_1_18_6_2 Node1_18_6 Node1_19_6 250.00000000000003
R_1_18_6_3 Node1_18_6 GND 16.0
C_1_18_6 Node1_18_6 GND 3.6093750000000004e-07
R_1_18_7_1 Node1_18_7 Node1_18_8 250.00000000000003
R_1_18_7_2 Node1_18_7 Node1_19_7 250.00000000000003
R_1_18_7_3 Node1_18_7 GND 16.0
C_1_18_7 Node1_18_7 GND 3.6093750000000004e-07
R_1_18_8_1 Node1_18_8 Node1_18_9 250.00000000000003
R_1_18_8_2 Node1_18_8 Node1_19_8 250.00000000000003
R_1_18_8_3 Node1_18_8 GND 16.0
C_1_18_8 Node1_18_8 GND 3.6093750000000004e-07
R_1_18_9_1 Node1_18_9 Node1_18_10 250.00000000000003
R_1_18_9_2 Node1_18_9 Node1_19_9 250.00000000000003
R_1_18_9_3 Node1_18_9 GND 16.0
C_1_18_9 Node1_18_9 GND 3.6093750000000004e-07
R_1_18_10_1 Node1_18_10 Node1_18_11 250.00000000000003
R_1_18_10_2 Node1_18_10 Node1_19_10 250.00000000000003
R_1_18_10_3 Node1_18_10 GND 16.0
C_1_18_10 Node1_18_10 GND 3.6093750000000004e-07
R_1_18_11_1 Node1_18_11 Node1_18_12 250.00000000000003
R_1_18_11_2 Node1_18_11 Node1_19_11 250.00000000000003
R_1_18_11_3 Node1_18_11 GND 16.0
C_1_18_11 Node1_18_11 GND 3.6093750000000004e-07
R_1_18_12_1 Node1_18_12 Node1_18_13 250.00000000000003
R_1_18_12_2 Node1_18_12 Node1_19_12 250.00000000000003
R_1_18_12_3 Node1_18_12 GND 16.0
C_1_18_12 Node1_18_12 GND 3.6093750000000004e-07
R_1_18_13_1 Node1_18_13 Node1_18_14 250.00000000000003
R_1_18_13_2 Node1_18_13 Node1_19_13 250.00000000000003
R_1_18_13_3 Node1_18_13 GND 16.0
C_1_18_13 Node1_18_13 GND 3.6093750000000004e-07
R_1_18_14_1 Node1_18_14 Node1_18_15 250.00000000000003
R_1_18_14_2 Node1_18_14 Node1_19_14 250.00000000000003
R_1_18_14_3 Node1_18_14 GND 16.0
C_1_18_14 Node1_18_14 GND 3.6093750000000004e-07
R_1_18_15_1 Node1_18_15 Node1_18_16 250.00000000000003
R_1_18_15_2 Node1_18_15 Node1_19_15 250.00000000000003
R_1_18_15_3 Node1_18_15 GND 16.0
C_1_18_15 Node1_18_15 GND 3.6093750000000004e-07
R_1_18_16_1 Node1_18_16 Node1_18_17 250.00000000000003
R_1_18_16_2 Node1_18_16 Node1_19_16 250.00000000000003
R_1_18_16_3 Node1_18_16 GND 16.0
C_1_18_16 Node1_18_16 GND 3.6093750000000004e-07
R_1_18_17_1 Node1_18_17 Node1_18_18 250.00000000000003
R_1_18_17_2 Node1_18_17 Node1_19_17 250.00000000000003
R_1_18_17_3 Node1_18_17 GND 16.0
C_1_18_17 Node1_18_17 GND 3.6093750000000004e-07
R_1_18_18_1 Node1_18_18 Node1_18_19 250.00000000000003
R_1_18_18_2 Node1_18_18 Node1_19_18 250.00000000000003
R_1_18_18_3 Node1_18_18 GND 16.0
C_1_18_18 Node1_18_18 GND 3.6093750000000004e-07
R_1_18_19_1 Node1_18_19 Node1_18_20 250.00000000000003
R_1_18_19_2 Node1_18_19 Node1_19_19 250.00000000000003
R_1_18_19_3 Node1_18_19 GND 16.0
C_1_18_19 Node1_18_19 GND 3.6093750000000004e-07
R_1_18_20_1 Node1_18_20 Node1_18_21 250.00000000000003
R_1_18_20_2 Node1_18_20 Node1_19_20 250.00000000000003
R_1_18_20_3 Node1_18_20 GND 16.0
C_1_18_20 Node1_18_20 GND 3.6093750000000004e-07
R_1_18_21_1 Node1_18_21 Node1_18_22 250.00000000000003
R_1_18_21_2 Node1_18_21 Node1_19_21 250.00000000000003
R_1_18_21_3 Node1_18_21 GND 16.0
C_1_18_21 Node1_18_21 GND 3.6093750000000004e-07
R_1_18_22_1 Node1_18_22 Node1_18_23 250.00000000000003
R_1_18_22_2 Node1_18_22 Node1_19_22 250.00000000000003
R_1_18_22_3 Node1_18_22 GND 16.0
C_1_18_22 Node1_18_22 GND 3.6093750000000004e-07
R_1_18_23_1 Node1_18_23 Node1_18_24 250.00000000000003
R_1_18_23_2 Node1_18_23 Node1_19_23 250.00000000000003
R_1_18_23_3 Node1_18_23 GND 16.0
C_1_18_23 Node1_18_23 GND 3.6093750000000004e-07
R_1_18_24_1 Node1_18_24 Node1_18_25 250.00000000000003
R_1_18_24_2 Node1_18_24 Node1_19_24 250.00000000000003
R_1_18_24_3 Node1_18_24 GND 16.0
C_1_18_24 Node1_18_24 GND 3.6093750000000004e-07
R_1_18_25_1 Node1_18_25 Node1_18_26 250.00000000000003
R_1_18_25_2 Node1_18_25 Node1_19_25 250.00000000000003
R_1_18_25_3 Node1_18_25 GND 16.0
C_1_18_25 Node1_18_25 GND 3.6093750000000004e-07
R_1_18_26_1 Node1_18_26 Node1_18_27 250.00000000000003
R_1_18_26_2 Node1_18_26 Node1_19_26 250.00000000000003
R_1_18_26_3 Node1_18_26 GND 16.0
C_1_18_26 Node1_18_26 GND 3.6093750000000004e-07
R_1_18_27_1 Node1_18_27 Node1_18_28 250.00000000000003
R_1_18_27_2 Node1_18_27 Node1_19_27 250.00000000000003
R_1_18_27_3 Node1_18_27 GND 16.0
C_1_18_27 Node1_18_27 GND 3.6093750000000004e-07
R_1_18_28_1 Node1_18_28 Node1_18_29 250.00000000000003
R_1_18_28_2 Node1_18_28 Node1_19_28 250.00000000000003
R_1_18_28_3 Node1_18_28 GND 16.0
C_1_18_28 Node1_18_28 GND 3.6093750000000004e-07
R_1_18_29_1 Node1_18_29 Node1_18_30 250.00000000000003
R_1_18_29_2 Node1_18_29 Node1_19_29 250.00000000000003
R_1_18_29_3 Node1_18_29 GND 16.0
C_1_18_29 Node1_18_29 GND 3.6093750000000004e-07
R_1_18_30_1 Node1_18_30 Node1_18_31 250.00000000000003
R_1_18_30_2 Node1_18_30 Node1_19_30 250.00000000000003
R_1_18_30_3 Node1_18_30 GND 16.0
C_1_18_30 Node1_18_30 GND 3.6093750000000004e-07
R_1_18_31_1 Node1_18_31 Node1_18_32 250.00000000000003
R_1_18_31_2 Node1_18_31 Node1_19_31 250.00000000000003
R_1_18_31_3 Node1_18_31 GND 16.0
C_1_18_31 Node1_18_31 GND 3.6093750000000004e-07
R_1_18_32_1 Node1_18_32 Node1_18_33 250.00000000000003
R_1_18_32_2 Node1_18_32 Node1_19_32 250.00000000000003
R_1_18_32_3 Node1_18_32 GND 16.0
C_1_18_32 Node1_18_32 GND 3.6093750000000004e-07
R_1_18_33_1 Node1_18_33 Node1_18_34 250.00000000000003
R_1_18_33_2 Node1_18_33 Node1_19_33 250.00000000000003
R_1_18_33_3 Node1_18_33 GND 16.0
C_1_18_33 Node1_18_33 GND 3.6093750000000004e-07
R_1_18_34_1 Node1_18_34 Node1_18_35 250.00000000000003
R_1_18_34_2 Node1_18_34 Node1_19_34 250.00000000000003
R_1_18_34_3 Node1_18_34 GND 16.0
C_1_18_34 Node1_18_34 GND 3.6093750000000004e-07
R_1_18_35_1 Node1_18_35 Node1_18_36 250.00000000000003
R_1_18_35_2 Node1_18_35 Node1_19_35 250.00000000000003
R_1_18_35_3 Node1_18_35 GND 16.0
C_1_18_35 Node1_18_35 GND 3.6093750000000004e-07
R_1_18_36_1 Node1_18_36 Node1_18_37 250.00000000000003
R_1_18_36_2 Node1_18_36 Node1_19_36 250.00000000000003
R_1_18_36_3 Node1_18_36 GND 16.0
C_1_18_36 Node1_18_36 GND 3.6093750000000004e-07
R_1_18_37_1 Node1_18_37 Node1_18_38 250.00000000000003
R_1_18_37_2 Node1_18_37 Node1_19_37 250.00000000000003
R_1_18_37_3 Node1_18_37 GND 16.0
C_1_18_37 Node1_18_37 GND 3.6093750000000004e-07
R_1_18_38_1 Node1_18_38 Node1_18_39 250.00000000000003
R_1_18_38_2 Node1_18_38 Node1_19_38 250.00000000000003
R_1_18_38_3 Node1_18_38 GND 16.0
C_1_18_38 Node1_18_38 GND 3.6093750000000004e-07
R_1_18_39_2 Node1_18_39 Node1_19_39 250.00000000000003
R_1_18_39_3 Node1_18_39 GND 16.0
C_1_18_39 Node1_18_39 GND 3.6093750000000004e-07
R_1_19_0_1 Node1_19_0 Node1_19_1 250.00000000000003
R_1_19_0_2 Node1_19_0 Node1_20_0 250.00000000000003
R_1_19_0_3 Node1_19_0 GND 16.0
C_1_19_0 Node1_19_0 GND 3.6093750000000004e-07
R_1_19_1_1 Node1_19_1 Node1_19_2 250.00000000000003
R_1_19_1_2 Node1_19_1 Node1_20_1 250.00000000000003
R_1_19_1_3 Node1_19_1 GND 16.0
C_1_19_1 Node1_19_1 GND 3.6093750000000004e-07
R_1_19_2_1 Node1_19_2 Node1_19_3 250.00000000000003
R_1_19_2_2 Node1_19_2 Node1_20_2 250.00000000000003
R_1_19_2_3 Node1_19_2 GND 16.0
C_1_19_2 Node1_19_2 GND 3.6093750000000004e-07
R_1_19_3_1 Node1_19_3 Node1_19_4 250.00000000000003
R_1_19_3_2 Node1_19_3 Node1_20_3 250.00000000000003
R_1_19_3_3 Node1_19_3 GND 16.0
C_1_19_3 Node1_19_3 GND 3.6093750000000004e-07
R_1_19_4_1 Node1_19_4 Node1_19_5 250.00000000000003
R_1_19_4_2 Node1_19_4 Node1_20_4 250.00000000000003
R_1_19_4_3 Node1_19_4 GND 16.0
C_1_19_4 Node1_19_4 GND 3.6093750000000004e-07
R_1_19_5_1 Node1_19_5 Node1_19_6 250.00000000000003
R_1_19_5_2 Node1_19_5 Node1_20_5 250.00000000000003
R_1_19_5_3 Node1_19_5 GND 16.0
C_1_19_5 Node1_19_5 GND 3.6093750000000004e-07
R_1_19_6_1 Node1_19_6 Node1_19_7 250.00000000000003
R_1_19_6_2 Node1_19_6 Node1_20_6 250.00000000000003
R_1_19_6_3 Node1_19_6 GND 16.0
C_1_19_6 Node1_19_6 GND 3.6093750000000004e-07
R_1_19_7_1 Node1_19_7 Node1_19_8 250.00000000000003
R_1_19_7_2 Node1_19_7 Node1_20_7 250.00000000000003
R_1_19_7_3 Node1_19_7 GND 16.0
C_1_19_7 Node1_19_7 GND 3.6093750000000004e-07
R_1_19_8_1 Node1_19_8 Node1_19_9 250.00000000000003
R_1_19_8_2 Node1_19_8 Node1_20_8 250.00000000000003
R_1_19_8_3 Node1_19_8 GND 16.0
C_1_19_8 Node1_19_8 GND 3.6093750000000004e-07
R_1_19_9_1 Node1_19_9 Node1_19_10 250.00000000000003
R_1_19_9_2 Node1_19_9 Node1_20_9 250.00000000000003
R_1_19_9_3 Node1_19_9 GND 16.0
C_1_19_9 Node1_19_9 GND 3.6093750000000004e-07
R_1_19_10_1 Node1_19_10 Node1_19_11 250.00000000000003
R_1_19_10_2 Node1_19_10 Node1_20_10 250.00000000000003
R_1_19_10_3 Node1_19_10 GND 16.0
C_1_19_10 Node1_19_10 GND 3.6093750000000004e-07
R_1_19_11_1 Node1_19_11 Node1_19_12 250.00000000000003
R_1_19_11_2 Node1_19_11 Node1_20_11 250.00000000000003
R_1_19_11_3 Node1_19_11 GND 16.0
C_1_19_11 Node1_19_11 GND 3.6093750000000004e-07
R_1_19_12_1 Node1_19_12 Node1_19_13 250.00000000000003
R_1_19_12_2 Node1_19_12 Node1_20_12 250.00000000000003
R_1_19_12_3 Node1_19_12 GND 16.0
C_1_19_12 Node1_19_12 GND 3.6093750000000004e-07
R_1_19_13_1 Node1_19_13 Node1_19_14 250.00000000000003
R_1_19_13_2 Node1_19_13 Node1_20_13 250.00000000000003
R_1_19_13_3 Node1_19_13 GND 16.0
C_1_19_13 Node1_19_13 GND 3.6093750000000004e-07
R_1_19_14_1 Node1_19_14 Node1_19_15 250.00000000000003
R_1_19_14_2 Node1_19_14 Node1_20_14 250.00000000000003
R_1_19_14_3 Node1_19_14 GND 16.0
C_1_19_14 Node1_19_14 GND 3.6093750000000004e-07
R_1_19_15_1 Node1_19_15 Node1_19_16 250.00000000000003
R_1_19_15_2 Node1_19_15 Node1_20_15 250.00000000000003
R_1_19_15_3 Node1_19_15 GND 16.0
C_1_19_15 Node1_19_15 GND 3.6093750000000004e-07
R_1_19_16_1 Node1_19_16 Node1_19_17 250.00000000000003
R_1_19_16_2 Node1_19_16 Node1_20_16 250.00000000000003
R_1_19_16_3 Node1_19_16 GND 16.0
C_1_19_16 Node1_19_16 GND 3.6093750000000004e-07
R_1_19_17_1 Node1_19_17 Node1_19_18 250.00000000000003
R_1_19_17_2 Node1_19_17 Node1_20_17 250.00000000000003
R_1_19_17_3 Node1_19_17 GND 16.0
C_1_19_17 Node1_19_17 GND 3.6093750000000004e-07
R_1_19_18_1 Node1_19_18 Node1_19_19 250.00000000000003
R_1_19_18_2 Node1_19_18 Node1_20_18 250.00000000000003
R_1_19_18_3 Node1_19_18 GND 16.0
C_1_19_18 Node1_19_18 GND 3.6093750000000004e-07
R_1_19_19_1 Node1_19_19 Node1_19_20 250.00000000000003
R_1_19_19_2 Node1_19_19 Node1_20_19 250.00000000000003
R_1_19_19_3 Node1_19_19 GND 16.0
C_1_19_19 Node1_19_19 GND 3.6093750000000004e-07
R_1_19_20_1 Node1_19_20 Node1_19_21 250.00000000000003
R_1_19_20_2 Node1_19_20 Node1_20_20 250.00000000000003
R_1_19_20_3 Node1_19_20 GND 16.0
C_1_19_20 Node1_19_20 GND 3.6093750000000004e-07
R_1_19_21_1 Node1_19_21 Node1_19_22 250.00000000000003
R_1_19_21_2 Node1_19_21 Node1_20_21 250.00000000000003
R_1_19_21_3 Node1_19_21 GND 16.0
C_1_19_21 Node1_19_21 GND 3.6093750000000004e-07
R_1_19_22_1 Node1_19_22 Node1_19_23 250.00000000000003
R_1_19_22_2 Node1_19_22 Node1_20_22 250.00000000000003
R_1_19_22_3 Node1_19_22 GND 16.0
C_1_19_22 Node1_19_22 GND 3.6093750000000004e-07
R_1_19_23_1 Node1_19_23 Node1_19_24 250.00000000000003
R_1_19_23_2 Node1_19_23 Node1_20_23 250.00000000000003
R_1_19_23_3 Node1_19_23 GND 16.0
C_1_19_23 Node1_19_23 GND 3.6093750000000004e-07
R_1_19_24_1 Node1_19_24 Node1_19_25 250.00000000000003
R_1_19_24_2 Node1_19_24 Node1_20_24 250.00000000000003
R_1_19_24_3 Node1_19_24 GND 16.0
C_1_19_24 Node1_19_24 GND 3.6093750000000004e-07
R_1_19_25_1 Node1_19_25 Node1_19_26 250.00000000000003
R_1_19_25_2 Node1_19_25 Node1_20_25 250.00000000000003
R_1_19_25_3 Node1_19_25 GND 16.0
C_1_19_25 Node1_19_25 GND 3.6093750000000004e-07
R_1_19_26_1 Node1_19_26 Node1_19_27 250.00000000000003
R_1_19_26_2 Node1_19_26 Node1_20_26 250.00000000000003
R_1_19_26_3 Node1_19_26 GND 16.0
C_1_19_26 Node1_19_26 GND 3.6093750000000004e-07
R_1_19_27_1 Node1_19_27 Node1_19_28 250.00000000000003
R_1_19_27_2 Node1_19_27 Node1_20_27 250.00000000000003
R_1_19_27_3 Node1_19_27 GND 16.0
C_1_19_27 Node1_19_27 GND 3.6093750000000004e-07
R_1_19_28_1 Node1_19_28 Node1_19_29 250.00000000000003
R_1_19_28_2 Node1_19_28 Node1_20_28 250.00000000000003
R_1_19_28_3 Node1_19_28 GND 16.0
C_1_19_28 Node1_19_28 GND 3.6093750000000004e-07
R_1_19_29_1 Node1_19_29 Node1_19_30 250.00000000000003
R_1_19_29_2 Node1_19_29 Node1_20_29 250.00000000000003
R_1_19_29_3 Node1_19_29 GND 16.0
C_1_19_29 Node1_19_29 GND 3.6093750000000004e-07
R_1_19_30_1 Node1_19_30 Node1_19_31 250.00000000000003
R_1_19_30_2 Node1_19_30 Node1_20_30 250.00000000000003
R_1_19_30_3 Node1_19_30 GND 16.0
C_1_19_30 Node1_19_30 GND 3.6093750000000004e-07
R_1_19_31_1 Node1_19_31 Node1_19_32 250.00000000000003
R_1_19_31_2 Node1_19_31 Node1_20_31 250.00000000000003
R_1_19_31_3 Node1_19_31 GND 16.0
C_1_19_31 Node1_19_31 GND 3.6093750000000004e-07
R_1_19_32_1 Node1_19_32 Node1_19_33 250.00000000000003
R_1_19_32_2 Node1_19_32 Node1_20_32 250.00000000000003
R_1_19_32_3 Node1_19_32 GND 16.0
C_1_19_32 Node1_19_32 GND 3.6093750000000004e-07
R_1_19_33_1 Node1_19_33 Node1_19_34 250.00000000000003
R_1_19_33_2 Node1_19_33 Node1_20_33 250.00000000000003
R_1_19_33_3 Node1_19_33 GND 16.0
C_1_19_33 Node1_19_33 GND 3.6093750000000004e-07
R_1_19_34_1 Node1_19_34 Node1_19_35 250.00000000000003
R_1_19_34_2 Node1_19_34 Node1_20_34 250.00000000000003
R_1_19_34_3 Node1_19_34 GND 16.0
C_1_19_34 Node1_19_34 GND 3.6093750000000004e-07
R_1_19_35_1 Node1_19_35 Node1_19_36 250.00000000000003
R_1_19_35_2 Node1_19_35 Node1_20_35 250.00000000000003
R_1_19_35_3 Node1_19_35 GND 16.0
C_1_19_35 Node1_19_35 GND 3.6093750000000004e-07
R_1_19_36_1 Node1_19_36 Node1_19_37 250.00000000000003
R_1_19_36_2 Node1_19_36 Node1_20_36 250.00000000000003
R_1_19_36_3 Node1_19_36 GND 16.0
C_1_19_36 Node1_19_36 GND 3.6093750000000004e-07
R_1_19_37_1 Node1_19_37 Node1_19_38 250.00000000000003
R_1_19_37_2 Node1_19_37 Node1_20_37 250.00000000000003
R_1_19_37_3 Node1_19_37 GND 16.0
C_1_19_37 Node1_19_37 GND 3.6093750000000004e-07
R_1_19_38_1 Node1_19_38 Node1_19_39 250.00000000000003
R_1_19_38_2 Node1_19_38 Node1_20_38 250.00000000000003
R_1_19_38_3 Node1_19_38 GND 16.0
C_1_19_38 Node1_19_38 GND 3.6093750000000004e-07
R_1_19_39_2 Node1_19_39 Node1_20_39 250.00000000000003
R_1_19_39_3 Node1_19_39 GND 16.0
C_1_19_39 Node1_19_39 GND 3.6093750000000004e-07
R_1_20_0_1 Node1_20_0 Node1_20_1 250.00000000000003
R_1_20_0_2 Node1_20_0 Node1_21_0 250.00000000000003
R_1_20_0_3 Node1_20_0 GND 16.0
C_1_20_0 Node1_20_0 GND 3.6093750000000004e-07
R_1_20_1_1 Node1_20_1 Node1_20_2 250.00000000000003
R_1_20_1_2 Node1_20_1 Node1_21_1 250.00000000000003
R_1_20_1_3 Node1_20_1 GND 16.0
C_1_20_1 Node1_20_1 GND 3.6093750000000004e-07
R_1_20_2_1 Node1_20_2 Node1_20_3 250.00000000000003
R_1_20_2_2 Node1_20_2 Node1_21_2 250.00000000000003
R_1_20_2_3 Node1_20_2 GND 16.0
C_1_20_2 Node1_20_2 GND 3.6093750000000004e-07
R_1_20_3_1 Node1_20_3 Node1_20_4 250.00000000000003
R_1_20_3_2 Node1_20_3 Node1_21_3 250.00000000000003
R_1_20_3_3 Node1_20_3 GND 16.0
C_1_20_3 Node1_20_3 GND 3.6093750000000004e-07
R_1_20_4_1 Node1_20_4 Node1_20_5 250.00000000000003
R_1_20_4_2 Node1_20_4 Node1_21_4 250.00000000000003
R_1_20_4_3 Node1_20_4 GND 16.0
C_1_20_4 Node1_20_4 GND 3.6093750000000004e-07
R_1_20_5_1 Node1_20_5 Node1_20_6 250.00000000000003
R_1_20_5_2 Node1_20_5 Node1_21_5 250.00000000000003
R_1_20_5_3 Node1_20_5 GND 16.0
C_1_20_5 Node1_20_5 GND 3.6093750000000004e-07
R_1_20_6_1 Node1_20_6 Node1_20_7 250.00000000000003
R_1_20_6_2 Node1_20_6 Node1_21_6 250.00000000000003
R_1_20_6_3 Node1_20_6 GND 16.0
C_1_20_6 Node1_20_6 GND 3.6093750000000004e-07
R_1_20_7_1 Node1_20_7 Node1_20_8 250.00000000000003
R_1_20_7_2 Node1_20_7 Node1_21_7 250.00000000000003
R_1_20_7_3 Node1_20_7 GND 16.0
C_1_20_7 Node1_20_7 GND 3.6093750000000004e-07
R_1_20_8_1 Node1_20_8 Node1_20_9 250.00000000000003
R_1_20_8_2 Node1_20_8 Node1_21_8 250.00000000000003
R_1_20_8_3 Node1_20_8 GND 16.0
C_1_20_8 Node1_20_8 GND 3.6093750000000004e-07
R_1_20_9_1 Node1_20_9 Node1_20_10 250.00000000000003
R_1_20_9_2 Node1_20_9 Node1_21_9 250.00000000000003
R_1_20_9_3 Node1_20_9 GND 16.0
C_1_20_9 Node1_20_9 GND 3.6093750000000004e-07
R_1_20_10_1 Node1_20_10 Node1_20_11 250.00000000000003
R_1_20_10_2 Node1_20_10 Node1_21_10 250.00000000000003
R_1_20_10_3 Node1_20_10 GND 16.0
C_1_20_10 Node1_20_10 GND 3.6093750000000004e-07
R_1_20_11_1 Node1_20_11 Node1_20_12 250.00000000000003
R_1_20_11_2 Node1_20_11 Node1_21_11 250.00000000000003
R_1_20_11_3 Node1_20_11 GND 16.0
C_1_20_11 Node1_20_11 GND 3.6093750000000004e-07
R_1_20_12_1 Node1_20_12 Node1_20_13 250.00000000000003
R_1_20_12_2 Node1_20_12 Node1_21_12 250.00000000000003
R_1_20_12_3 Node1_20_12 GND 16.0
C_1_20_12 Node1_20_12 GND 3.6093750000000004e-07
R_1_20_13_1 Node1_20_13 Node1_20_14 250.00000000000003
R_1_20_13_2 Node1_20_13 Node1_21_13 250.00000000000003
R_1_20_13_3 Node1_20_13 GND 16.0
C_1_20_13 Node1_20_13 GND 3.6093750000000004e-07
R_1_20_14_1 Node1_20_14 Node1_20_15 250.00000000000003
R_1_20_14_2 Node1_20_14 Node1_21_14 250.00000000000003
R_1_20_14_3 Node1_20_14 GND 16.0
C_1_20_14 Node1_20_14 GND 3.6093750000000004e-07
R_1_20_15_1 Node1_20_15 Node1_20_16 250.00000000000003
R_1_20_15_2 Node1_20_15 Node1_21_15 250.00000000000003
R_1_20_15_3 Node1_20_15 GND 16.0
C_1_20_15 Node1_20_15 GND 3.6093750000000004e-07
R_1_20_16_1 Node1_20_16 Node1_20_17 250.00000000000003
R_1_20_16_2 Node1_20_16 Node1_21_16 250.00000000000003
R_1_20_16_3 Node1_20_16 GND 16.0
C_1_20_16 Node1_20_16 GND 3.6093750000000004e-07
R_1_20_17_1 Node1_20_17 Node1_20_18 250.00000000000003
R_1_20_17_2 Node1_20_17 Node1_21_17 250.00000000000003
R_1_20_17_3 Node1_20_17 GND 16.0
C_1_20_17 Node1_20_17 GND 3.6093750000000004e-07
R_1_20_18_1 Node1_20_18 Node1_20_19 250.00000000000003
R_1_20_18_2 Node1_20_18 Node1_21_18 250.00000000000003
R_1_20_18_3 Node1_20_18 GND 16.0
C_1_20_18 Node1_20_18 GND 3.6093750000000004e-07
R_1_20_19_1 Node1_20_19 Node1_20_20 250.00000000000003
R_1_20_19_2 Node1_20_19 Node1_21_19 250.00000000000003
R_1_20_19_3 Node1_20_19 GND 16.0
C_1_20_19 Node1_20_19 GND 3.6093750000000004e-07
R_1_20_20_1 Node1_20_20 Node1_20_21 250.00000000000003
R_1_20_20_2 Node1_20_20 Node1_21_20 250.00000000000003
R_1_20_20_3 Node1_20_20 GND 16.0
C_1_20_20 Node1_20_20 GND 3.6093750000000004e-07
R_1_20_21_1 Node1_20_21 Node1_20_22 250.00000000000003
R_1_20_21_2 Node1_20_21 Node1_21_21 250.00000000000003
R_1_20_21_3 Node1_20_21 GND 16.0
C_1_20_21 Node1_20_21 GND 3.6093750000000004e-07
R_1_20_22_1 Node1_20_22 Node1_20_23 250.00000000000003
R_1_20_22_2 Node1_20_22 Node1_21_22 250.00000000000003
R_1_20_22_3 Node1_20_22 GND 16.0
C_1_20_22 Node1_20_22 GND 3.6093750000000004e-07
R_1_20_23_1 Node1_20_23 Node1_20_24 250.00000000000003
R_1_20_23_2 Node1_20_23 Node1_21_23 250.00000000000003
R_1_20_23_3 Node1_20_23 GND 16.0
C_1_20_23 Node1_20_23 GND 3.6093750000000004e-07
R_1_20_24_1 Node1_20_24 Node1_20_25 250.00000000000003
R_1_20_24_2 Node1_20_24 Node1_21_24 250.00000000000003
R_1_20_24_3 Node1_20_24 GND 16.0
C_1_20_24 Node1_20_24 GND 3.6093750000000004e-07
R_1_20_25_1 Node1_20_25 Node1_20_26 250.00000000000003
R_1_20_25_2 Node1_20_25 Node1_21_25 250.00000000000003
R_1_20_25_3 Node1_20_25 GND 16.0
C_1_20_25 Node1_20_25 GND 3.6093750000000004e-07
R_1_20_26_1 Node1_20_26 Node1_20_27 250.00000000000003
R_1_20_26_2 Node1_20_26 Node1_21_26 250.00000000000003
R_1_20_26_3 Node1_20_26 GND 16.0
C_1_20_26 Node1_20_26 GND 3.6093750000000004e-07
R_1_20_27_1 Node1_20_27 Node1_20_28 250.00000000000003
R_1_20_27_2 Node1_20_27 Node1_21_27 250.00000000000003
R_1_20_27_3 Node1_20_27 GND 16.0
C_1_20_27 Node1_20_27 GND 3.6093750000000004e-07
R_1_20_28_1 Node1_20_28 Node1_20_29 250.00000000000003
R_1_20_28_2 Node1_20_28 Node1_21_28 250.00000000000003
R_1_20_28_3 Node1_20_28 GND 16.0
C_1_20_28 Node1_20_28 GND 3.6093750000000004e-07
R_1_20_29_1 Node1_20_29 Node1_20_30 250.00000000000003
R_1_20_29_2 Node1_20_29 Node1_21_29 250.00000000000003
R_1_20_29_3 Node1_20_29 GND 16.0
C_1_20_29 Node1_20_29 GND 3.6093750000000004e-07
R_1_20_30_1 Node1_20_30 Node1_20_31 250.00000000000003
R_1_20_30_2 Node1_20_30 Node1_21_30 250.00000000000003
R_1_20_30_3 Node1_20_30 GND 16.0
C_1_20_30 Node1_20_30 GND 3.6093750000000004e-07
R_1_20_31_1 Node1_20_31 Node1_20_32 250.00000000000003
R_1_20_31_2 Node1_20_31 Node1_21_31 250.00000000000003
R_1_20_31_3 Node1_20_31 GND 16.0
C_1_20_31 Node1_20_31 GND 3.6093750000000004e-07
R_1_20_32_1 Node1_20_32 Node1_20_33 250.00000000000003
R_1_20_32_2 Node1_20_32 Node1_21_32 250.00000000000003
R_1_20_32_3 Node1_20_32 GND 16.0
C_1_20_32 Node1_20_32 GND 3.6093750000000004e-07
R_1_20_33_1 Node1_20_33 Node1_20_34 250.00000000000003
R_1_20_33_2 Node1_20_33 Node1_21_33 250.00000000000003
R_1_20_33_3 Node1_20_33 GND 16.0
C_1_20_33 Node1_20_33 GND 3.6093750000000004e-07
R_1_20_34_1 Node1_20_34 Node1_20_35 250.00000000000003
R_1_20_34_2 Node1_20_34 Node1_21_34 250.00000000000003
R_1_20_34_3 Node1_20_34 GND 16.0
C_1_20_34 Node1_20_34 GND 3.6093750000000004e-07
R_1_20_35_1 Node1_20_35 Node1_20_36 250.00000000000003
R_1_20_35_2 Node1_20_35 Node1_21_35 250.00000000000003
R_1_20_35_3 Node1_20_35 GND 16.0
C_1_20_35 Node1_20_35 GND 3.6093750000000004e-07
R_1_20_36_1 Node1_20_36 Node1_20_37 250.00000000000003
R_1_20_36_2 Node1_20_36 Node1_21_36 250.00000000000003
R_1_20_36_3 Node1_20_36 GND 16.0
C_1_20_36 Node1_20_36 GND 3.6093750000000004e-07
R_1_20_37_1 Node1_20_37 Node1_20_38 250.00000000000003
R_1_20_37_2 Node1_20_37 Node1_21_37 250.00000000000003
R_1_20_37_3 Node1_20_37 GND 16.0
C_1_20_37 Node1_20_37 GND 3.6093750000000004e-07
R_1_20_38_1 Node1_20_38 Node1_20_39 250.00000000000003
R_1_20_38_2 Node1_20_38 Node1_21_38 250.00000000000003
R_1_20_38_3 Node1_20_38 GND 16.0
C_1_20_38 Node1_20_38 GND 3.6093750000000004e-07
R_1_20_39_2 Node1_20_39 Node1_21_39 250.00000000000003
R_1_20_39_3 Node1_20_39 GND 16.0
C_1_20_39 Node1_20_39 GND 3.6093750000000004e-07
R_1_21_0_1 Node1_21_0 Node1_21_1 250.00000000000003
R_1_21_0_2 Node1_21_0 Node1_22_0 250.00000000000003
R_1_21_0_3 Node1_21_0 GND 16.0
C_1_21_0 Node1_21_0 GND 3.6093750000000004e-07
R_1_21_1_1 Node1_21_1 Node1_21_2 250.00000000000003
R_1_21_1_2 Node1_21_1 Node1_22_1 250.00000000000003
R_1_21_1_3 Node1_21_1 GND 16.0
C_1_21_1 Node1_21_1 GND 3.6093750000000004e-07
R_1_21_2_1 Node1_21_2 Node1_21_3 250.00000000000003
R_1_21_2_2 Node1_21_2 Node1_22_2 250.00000000000003
R_1_21_2_3 Node1_21_2 GND 16.0
C_1_21_2 Node1_21_2 GND 3.6093750000000004e-07
R_1_21_3_1 Node1_21_3 Node1_21_4 250.00000000000003
R_1_21_3_2 Node1_21_3 Node1_22_3 250.00000000000003
R_1_21_3_3 Node1_21_3 GND 16.0
C_1_21_3 Node1_21_3 GND 3.6093750000000004e-07
R_1_21_4_1 Node1_21_4 Node1_21_5 250.00000000000003
R_1_21_4_2 Node1_21_4 Node1_22_4 250.00000000000003
R_1_21_4_3 Node1_21_4 GND 16.0
C_1_21_4 Node1_21_4 GND 3.6093750000000004e-07
R_1_21_5_1 Node1_21_5 Node1_21_6 250.00000000000003
R_1_21_5_2 Node1_21_5 Node1_22_5 250.00000000000003
R_1_21_5_3 Node1_21_5 GND 16.0
C_1_21_5 Node1_21_5 GND 3.6093750000000004e-07
R_1_21_6_1 Node1_21_6 Node1_21_7 250.00000000000003
R_1_21_6_2 Node1_21_6 Node1_22_6 250.00000000000003
R_1_21_6_3 Node1_21_6 GND 16.0
C_1_21_6 Node1_21_6 GND 3.6093750000000004e-07
R_1_21_7_1 Node1_21_7 Node1_21_8 250.00000000000003
R_1_21_7_2 Node1_21_7 Node1_22_7 250.00000000000003
R_1_21_7_3 Node1_21_7 GND 16.0
C_1_21_7 Node1_21_7 GND 3.6093750000000004e-07
R_1_21_8_1 Node1_21_8 Node1_21_9 250.00000000000003
R_1_21_8_2 Node1_21_8 Node1_22_8 250.00000000000003
R_1_21_8_3 Node1_21_8 GND 16.0
C_1_21_8 Node1_21_8 GND 3.6093750000000004e-07
R_1_21_9_1 Node1_21_9 Node1_21_10 250.00000000000003
R_1_21_9_2 Node1_21_9 Node1_22_9 250.00000000000003
R_1_21_9_3 Node1_21_9 GND 16.0
C_1_21_9 Node1_21_9 GND 3.6093750000000004e-07
R_1_21_10_1 Node1_21_10 Node1_21_11 250.00000000000003
R_1_21_10_2 Node1_21_10 Node1_22_10 250.00000000000003
R_1_21_10_3 Node1_21_10 GND 16.0
C_1_21_10 Node1_21_10 GND 3.6093750000000004e-07
R_1_21_11_1 Node1_21_11 Node1_21_12 250.00000000000003
R_1_21_11_2 Node1_21_11 Node1_22_11 250.00000000000003
R_1_21_11_3 Node1_21_11 GND 16.0
C_1_21_11 Node1_21_11 GND 3.6093750000000004e-07
R_1_21_12_1 Node1_21_12 Node1_21_13 250.00000000000003
R_1_21_12_2 Node1_21_12 Node1_22_12 250.00000000000003
R_1_21_12_3 Node1_21_12 GND 16.0
C_1_21_12 Node1_21_12 GND 3.6093750000000004e-07
R_1_21_13_1 Node1_21_13 Node1_21_14 250.00000000000003
R_1_21_13_2 Node1_21_13 Node1_22_13 250.00000000000003
R_1_21_13_3 Node1_21_13 GND 16.0
C_1_21_13 Node1_21_13 GND 3.6093750000000004e-07
R_1_21_14_1 Node1_21_14 Node1_21_15 250.00000000000003
R_1_21_14_2 Node1_21_14 Node1_22_14 250.00000000000003
R_1_21_14_3 Node1_21_14 GND 16.0
C_1_21_14 Node1_21_14 GND 3.6093750000000004e-07
R_1_21_15_1 Node1_21_15 Node1_21_16 250.00000000000003
R_1_21_15_2 Node1_21_15 Node1_22_15 250.00000000000003
R_1_21_15_3 Node1_21_15 GND 16.0
C_1_21_15 Node1_21_15 GND 3.6093750000000004e-07
R_1_21_16_1 Node1_21_16 Node1_21_17 250.00000000000003
R_1_21_16_2 Node1_21_16 Node1_22_16 250.00000000000003
R_1_21_16_3 Node1_21_16 GND 16.0
C_1_21_16 Node1_21_16 GND 3.6093750000000004e-07
R_1_21_17_1 Node1_21_17 Node1_21_18 250.00000000000003
R_1_21_17_2 Node1_21_17 Node1_22_17 250.00000000000003
R_1_21_17_3 Node1_21_17 GND 16.0
C_1_21_17 Node1_21_17 GND 3.6093750000000004e-07
R_1_21_18_1 Node1_21_18 Node1_21_19 250.00000000000003
R_1_21_18_2 Node1_21_18 Node1_22_18 250.00000000000003
R_1_21_18_3 Node1_21_18 GND 16.0
C_1_21_18 Node1_21_18 GND 3.6093750000000004e-07
R_1_21_19_1 Node1_21_19 Node1_21_20 250.00000000000003
R_1_21_19_2 Node1_21_19 Node1_22_19 250.00000000000003
R_1_21_19_3 Node1_21_19 GND 16.0
C_1_21_19 Node1_21_19 GND 3.6093750000000004e-07
R_1_21_20_1 Node1_21_20 Node1_21_21 250.00000000000003
R_1_21_20_2 Node1_21_20 Node1_22_20 250.00000000000003
R_1_21_20_3 Node1_21_20 GND 16.0
C_1_21_20 Node1_21_20 GND 3.6093750000000004e-07
R_1_21_21_1 Node1_21_21 Node1_21_22 250.00000000000003
R_1_21_21_2 Node1_21_21 Node1_22_21 250.00000000000003
R_1_21_21_3 Node1_21_21 GND 16.0
C_1_21_21 Node1_21_21 GND 3.6093750000000004e-07
R_1_21_22_1 Node1_21_22 Node1_21_23 250.00000000000003
R_1_21_22_2 Node1_21_22 Node1_22_22 250.00000000000003
R_1_21_22_3 Node1_21_22 GND 16.0
C_1_21_22 Node1_21_22 GND 3.6093750000000004e-07
R_1_21_23_1 Node1_21_23 Node1_21_24 250.00000000000003
R_1_21_23_2 Node1_21_23 Node1_22_23 250.00000000000003
R_1_21_23_3 Node1_21_23 GND 16.0
C_1_21_23 Node1_21_23 GND 3.6093750000000004e-07
R_1_21_24_1 Node1_21_24 Node1_21_25 250.00000000000003
R_1_21_24_2 Node1_21_24 Node1_22_24 250.00000000000003
R_1_21_24_3 Node1_21_24 GND 16.0
C_1_21_24 Node1_21_24 GND 3.6093750000000004e-07
R_1_21_25_1 Node1_21_25 Node1_21_26 250.00000000000003
R_1_21_25_2 Node1_21_25 Node1_22_25 250.00000000000003
R_1_21_25_3 Node1_21_25 GND 16.0
C_1_21_25 Node1_21_25 GND 3.6093750000000004e-07
R_1_21_26_1 Node1_21_26 Node1_21_27 250.00000000000003
R_1_21_26_2 Node1_21_26 Node1_22_26 250.00000000000003
R_1_21_26_3 Node1_21_26 GND 16.0
C_1_21_26 Node1_21_26 GND 3.6093750000000004e-07
R_1_21_27_1 Node1_21_27 Node1_21_28 250.00000000000003
R_1_21_27_2 Node1_21_27 Node1_22_27 250.00000000000003
R_1_21_27_3 Node1_21_27 GND 16.0
C_1_21_27 Node1_21_27 GND 3.6093750000000004e-07
R_1_21_28_1 Node1_21_28 Node1_21_29 250.00000000000003
R_1_21_28_2 Node1_21_28 Node1_22_28 250.00000000000003
R_1_21_28_3 Node1_21_28 GND 16.0
C_1_21_28 Node1_21_28 GND 3.6093750000000004e-07
R_1_21_29_1 Node1_21_29 Node1_21_30 250.00000000000003
R_1_21_29_2 Node1_21_29 Node1_22_29 250.00000000000003
R_1_21_29_3 Node1_21_29 GND 16.0
C_1_21_29 Node1_21_29 GND 3.6093750000000004e-07
R_1_21_30_1 Node1_21_30 Node1_21_31 250.00000000000003
R_1_21_30_2 Node1_21_30 Node1_22_30 250.00000000000003
R_1_21_30_3 Node1_21_30 GND 16.0
C_1_21_30 Node1_21_30 GND 3.6093750000000004e-07
R_1_21_31_1 Node1_21_31 Node1_21_32 250.00000000000003
R_1_21_31_2 Node1_21_31 Node1_22_31 250.00000000000003
R_1_21_31_3 Node1_21_31 GND 16.0
C_1_21_31 Node1_21_31 GND 3.6093750000000004e-07
R_1_21_32_1 Node1_21_32 Node1_21_33 250.00000000000003
R_1_21_32_2 Node1_21_32 Node1_22_32 250.00000000000003
R_1_21_32_3 Node1_21_32 GND 16.0
C_1_21_32 Node1_21_32 GND 3.6093750000000004e-07
R_1_21_33_1 Node1_21_33 Node1_21_34 250.00000000000003
R_1_21_33_2 Node1_21_33 Node1_22_33 250.00000000000003
R_1_21_33_3 Node1_21_33 GND 16.0
C_1_21_33 Node1_21_33 GND 3.6093750000000004e-07
R_1_21_34_1 Node1_21_34 Node1_21_35 250.00000000000003
R_1_21_34_2 Node1_21_34 Node1_22_34 250.00000000000003
R_1_21_34_3 Node1_21_34 GND 16.0
C_1_21_34 Node1_21_34 GND 3.6093750000000004e-07
R_1_21_35_1 Node1_21_35 Node1_21_36 250.00000000000003
R_1_21_35_2 Node1_21_35 Node1_22_35 250.00000000000003
R_1_21_35_3 Node1_21_35 GND 16.0
C_1_21_35 Node1_21_35 GND 3.6093750000000004e-07
R_1_21_36_1 Node1_21_36 Node1_21_37 250.00000000000003
R_1_21_36_2 Node1_21_36 Node1_22_36 250.00000000000003
R_1_21_36_3 Node1_21_36 GND 16.0
C_1_21_36 Node1_21_36 GND 3.6093750000000004e-07
R_1_21_37_1 Node1_21_37 Node1_21_38 250.00000000000003
R_1_21_37_2 Node1_21_37 Node1_22_37 250.00000000000003
R_1_21_37_3 Node1_21_37 GND 16.0
C_1_21_37 Node1_21_37 GND 3.6093750000000004e-07
R_1_21_38_1 Node1_21_38 Node1_21_39 250.00000000000003
R_1_21_38_2 Node1_21_38 Node1_22_38 250.00000000000003
R_1_21_38_3 Node1_21_38 GND 16.0
C_1_21_38 Node1_21_38 GND 3.6093750000000004e-07
R_1_21_39_2 Node1_21_39 Node1_22_39 250.00000000000003
R_1_21_39_3 Node1_21_39 GND 16.0
C_1_21_39 Node1_21_39 GND 3.6093750000000004e-07
R_1_22_0_1 Node1_22_0 Node1_22_1 250.00000000000003
R_1_22_0_2 Node1_22_0 Node1_23_0 250.00000000000003
R_1_22_0_3 Node1_22_0 GND 16.0
C_1_22_0 Node1_22_0 GND 3.6093750000000004e-07
R_1_22_1_1 Node1_22_1 Node1_22_2 250.00000000000003
R_1_22_1_2 Node1_22_1 Node1_23_1 250.00000000000003
R_1_22_1_3 Node1_22_1 GND 16.0
C_1_22_1 Node1_22_1 GND 3.6093750000000004e-07
R_1_22_2_1 Node1_22_2 Node1_22_3 250.00000000000003
R_1_22_2_2 Node1_22_2 Node1_23_2 250.00000000000003
R_1_22_2_3 Node1_22_2 GND 16.0
C_1_22_2 Node1_22_2 GND 3.6093750000000004e-07
R_1_22_3_1 Node1_22_3 Node1_22_4 250.00000000000003
R_1_22_3_2 Node1_22_3 Node1_23_3 250.00000000000003
R_1_22_3_3 Node1_22_3 GND 16.0
C_1_22_3 Node1_22_3 GND 3.6093750000000004e-07
R_1_22_4_1 Node1_22_4 Node1_22_5 250.00000000000003
R_1_22_4_2 Node1_22_4 Node1_23_4 250.00000000000003
R_1_22_4_3 Node1_22_4 GND 16.0
C_1_22_4 Node1_22_4 GND 3.6093750000000004e-07
R_1_22_5_1 Node1_22_5 Node1_22_6 250.00000000000003
R_1_22_5_2 Node1_22_5 Node1_23_5 250.00000000000003
R_1_22_5_3 Node1_22_5 GND 16.0
C_1_22_5 Node1_22_5 GND 3.6093750000000004e-07
R_1_22_6_1 Node1_22_6 Node1_22_7 250.00000000000003
R_1_22_6_2 Node1_22_6 Node1_23_6 250.00000000000003
R_1_22_6_3 Node1_22_6 GND 16.0
C_1_22_6 Node1_22_6 GND 3.6093750000000004e-07
R_1_22_7_1 Node1_22_7 Node1_22_8 250.00000000000003
R_1_22_7_2 Node1_22_7 Node1_23_7 250.00000000000003
R_1_22_7_3 Node1_22_7 GND 16.0
C_1_22_7 Node1_22_7 GND 3.6093750000000004e-07
R_1_22_8_1 Node1_22_8 Node1_22_9 250.00000000000003
R_1_22_8_2 Node1_22_8 Node1_23_8 250.00000000000003
R_1_22_8_3 Node1_22_8 GND 16.0
C_1_22_8 Node1_22_8 GND 3.6093750000000004e-07
R_1_22_9_1 Node1_22_9 Node1_22_10 250.00000000000003
R_1_22_9_2 Node1_22_9 Node1_23_9 250.00000000000003
R_1_22_9_3 Node1_22_9 GND 16.0
C_1_22_9 Node1_22_9 GND 3.6093750000000004e-07
R_1_22_10_1 Node1_22_10 Node1_22_11 250.00000000000003
R_1_22_10_2 Node1_22_10 Node1_23_10 250.00000000000003
R_1_22_10_3 Node1_22_10 GND 16.0
C_1_22_10 Node1_22_10 GND 3.6093750000000004e-07
R_1_22_11_1 Node1_22_11 Node1_22_12 250.00000000000003
R_1_22_11_2 Node1_22_11 Node1_23_11 250.00000000000003
R_1_22_11_3 Node1_22_11 GND 16.0
C_1_22_11 Node1_22_11 GND 3.6093750000000004e-07
R_1_22_12_1 Node1_22_12 Node1_22_13 250.00000000000003
R_1_22_12_2 Node1_22_12 Node1_23_12 250.00000000000003
R_1_22_12_3 Node1_22_12 GND 16.0
C_1_22_12 Node1_22_12 GND 3.6093750000000004e-07
R_1_22_13_1 Node1_22_13 Node1_22_14 250.00000000000003
R_1_22_13_2 Node1_22_13 Node1_23_13 250.00000000000003
R_1_22_13_3 Node1_22_13 GND 16.0
C_1_22_13 Node1_22_13 GND 3.6093750000000004e-07
R_1_22_14_1 Node1_22_14 Node1_22_15 250.00000000000003
R_1_22_14_2 Node1_22_14 Node1_23_14 250.00000000000003
R_1_22_14_3 Node1_22_14 GND 16.0
C_1_22_14 Node1_22_14 GND 3.6093750000000004e-07
R_1_22_15_1 Node1_22_15 Node1_22_16 250.00000000000003
R_1_22_15_2 Node1_22_15 Node1_23_15 250.00000000000003
R_1_22_15_3 Node1_22_15 GND 16.0
C_1_22_15 Node1_22_15 GND 3.6093750000000004e-07
R_1_22_16_1 Node1_22_16 Node1_22_17 250.00000000000003
R_1_22_16_2 Node1_22_16 Node1_23_16 250.00000000000003
R_1_22_16_3 Node1_22_16 GND 16.0
C_1_22_16 Node1_22_16 GND 3.6093750000000004e-07
R_1_22_17_1 Node1_22_17 Node1_22_18 250.00000000000003
R_1_22_17_2 Node1_22_17 Node1_23_17 250.00000000000003
R_1_22_17_3 Node1_22_17 GND 16.0
C_1_22_17 Node1_22_17 GND 3.6093750000000004e-07
R_1_22_18_1 Node1_22_18 Node1_22_19 250.00000000000003
R_1_22_18_2 Node1_22_18 Node1_23_18 250.00000000000003
R_1_22_18_3 Node1_22_18 GND 16.0
C_1_22_18 Node1_22_18 GND 3.6093750000000004e-07
R_1_22_19_1 Node1_22_19 Node1_22_20 250.00000000000003
R_1_22_19_2 Node1_22_19 Node1_23_19 250.00000000000003
R_1_22_19_3 Node1_22_19 GND 16.0
C_1_22_19 Node1_22_19 GND 3.6093750000000004e-07
R_1_22_20_1 Node1_22_20 Node1_22_21 250.00000000000003
R_1_22_20_2 Node1_22_20 Node1_23_20 250.00000000000003
R_1_22_20_3 Node1_22_20 GND 16.0
C_1_22_20 Node1_22_20 GND 3.6093750000000004e-07
R_1_22_21_1 Node1_22_21 Node1_22_22 250.00000000000003
R_1_22_21_2 Node1_22_21 Node1_23_21 250.00000000000003
R_1_22_21_3 Node1_22_21 GND 16.0
C_1_22_21 Node1_22_21 GND 3.6093750000000004e-07
R_1_22_22_1 Node1_22_22 Node1_22_23 250.00000000000003
R_1_22_22_2 Node1_22_22 Node1_23_22 250.00000000000003
R_1_22_22_3 Node1_22_22 GND 16.0
C_1_22_22 Node1_22_22 GND 3.6093750000000004e-07
R_1_22_23_1 Node1_22_23 Node1_22_24 250.00000000000003
R_1_22_23_2 Node1_22_23 Node1_23_23 250.00000000000003
R_1_22_23_3 Node1_22_23 GND 16.0
C_1_22_23 Node1_22_23 GND 3.6093750000000004e-07
R_1_22_24_1 Node1_22_24 Node1_22_25 250.00000000000003
R_1_22_24_2 Node1_22_24 Node1_23_24 250.00000000000003
R_1_22_24_3 Node1_22_24 GND 16.0
C_1_22_24 Node1_22_24 GND 3.6093750000000004e-07
R_1_22_25_1 Node1_22_25 Node1_22_26 250.00000000000003
R_1_22_25_2 Node1_22_25 Node1_23_25 250.00000000000003
R_1_22_25_3 Node1_22_25 GND 16.0
C_1_22_25 Node1_22_25 GND 3.6093750000000004e-07
R_1_22_26_1 Node1_22_26 Node1_22_27 250.00000000000003
R_1_22_26_2 Node1_22_26 Node1_23_26 250.00000000000003
R_1_22_26_3 Node1_22_26 GND 16.0
C_1_22_26 Node1_22_26 GND 3.6093750000000004e-07
R_1_22_27_1 Node1_22_27 Node1_22_28 250.00000000000003
R_1_22_27_2 Node1_22_27 Node1_23_27 250.00000000000003
R_1_22_27_3 Node1_22_27 GND 16.0
C_1_22_27 Node1_22_27 GND 3.6093750000000004e-07
R_1_22_28_1 Node1_22_28 Node1_22_29 250.00000000000003
R_1_22_28_2 Node1_22_28 Node1_23_28 250.00000000000003
R_1_22_28_3 Node1_22_28 GND 16.0
C_1_22_28 Node1_22_28 GND 3.6093750000000004e-07
R_1_22_29_1 Node1_22_29 Node1_22_30 250.00000000000003
R_1_22_29_2 Node1_22_29 Node1_23_29 250.00000000000003
R_1_22_29_3 Node1_22_29 GND 16.0
C_1_22_29 Node1_22_29 GND 3.6093750000000004e-07
R_1_22_30_1 Node1_22_30 Node1_22_31 250.00000000000003
R_1_22_30_2 Node1_22_30 Node1_23_30 250.00000000000003
R_1_22_30_3 Node1_22_30 GND 16.0
C_1_22_30 Node1_22_30 GND 3.6093750000000004e-07
R_1_22_31_1 Node1_22_31 Node1_22_32 250.00000000000003
R_1_22_31_2 Node1_22_31 Node1_23_31 250.00000000000003
R_1_22_31_3 Node1_22_31 GND 16.0
C_1_22_31 Node1_22_31 GND 3.6093750000000004e-07
R_1_22_32_1 Node1_22_32 Node1_22_33 250.00000000000003
R_1_22_32_2 Node1_22_32 Node1_23_32 250.00000000000003
R_1_22_32_3 Node1_22_32 GND 16.0
C_1_22_32 Node1_22_32 GND 3.6093750000000004e-07
R_1_22_33_1 Node1_22_33 Node1_22_34 250.00000000000003
R_1_22_33_2 Node1_22_33 Node1_23_33 250.00000000000003
R_1_22_33_3 Node1_22_33 GND 16.0
C_1_22_33 Node1_22_33 GND 3.6093750000000004e-07
R_1_22_34_1 Node1_22_34 Node1_22_35 250.00000000000003
R_1_22_34_2 Node1_22_34 Node1_23_34 250.00000000000003
R_1_22_34_3 Node1_22_34 GND 16.0
C_1_22_34 Node1_22_34 GND 3.6093750000000004e-07
R_1_22_35_1 Node1_22_35 Node1_22_36 250.00000000000003
R_1_22_35_2 Node1_22_35 Node1_23_35 250.00000000000003
R_1_22_35_3 Node1_22_35 GND 16.0
C_1_22_35 Node1_22_35 GND 3.6093750000000004e-07
R_1_22_36_1 Node1_22_36 Node1_22_37 250.00000000000003
R_1_22_36_2 Node1_22_36 Node1_23_36 250.00000000000003
R_1_22_36_3 Node1_22_36 GND 16.0
C_1_22_36 Node1_22_36 GND 3.6093750000000004e-07
R_1_22_37_1 Node1_22_37 Node1_22_38 250.00000000000003
R_1_22_37_2 Node1_22_37 Node1_23_37 250.00000000000003
R_1_22_37_3 Node1_22_37 GND 16.0
C_1_22_37 Node1_22_37 GND 3.6093750000000004e-07
R_1_22_38_1 Node1_22_38 Node1_22_39 250.00000000000003
R_1_22_38_2 Node1_22_38 Node1_23_38 250.00000000000003
R_1_22_38_3 Node1_22_38 GND 16.0
C_1_22_38 Node1_22_38 GND 3.6093750000000004e-07
R_1_22_39_2 Node1_22_39 Node1_23_39 250.00000000000003
R_1_22_39_3 Node1_22_39 GND 16.0
C_1_22_39 Node1_22_39 GND 3.6093750000000004e-07
R_1_23_0_1 Node1_23_0 Node1_23_1 250.00000000000003
R_1_23_0_2 Node1_23_0 Node1_24_0 250.00000000000003
R_1_23_0_3 Node1_23_0 GND 16.0
C_1_23_0 Node1_23_0 GND 3.6093750000000004e-07
R_1_23_1_1 Node1_23_1 Node1_23_2 250.00000000000003
R_1_23_1_2 Node1_23_1 Node1_24_1 250.00000000000003
R_1_23_1_3 Node1_23_1 GND 16.0
C_1_23_1 Node1_23_1 GND 3.6093750000000004e-07
R_1_23_2_1 Node1_23_2 Node1_23_3 250.00000000000003
R_1_23_2_2 Node1_23_2 Node1_24_2 250.00000000000003
R_1_23_2_3 Node1_23_2 GND 16.0
C_1_23_2 Node1_23_2 GND 3.6093750000000004e-07
R_1_23_3_1 Node1_23_3 Node1_23_4 250.00000000000003
R_1_23_3_2 Node1_23_3 Node1_24_3 250.00000000000003
R_1_23_3_3 Node1_23_3 GND 16.0
C_1_23_3 Node1_23_3 GND 3.6093750000000004e-07
R_1_23_4_1 Node1_23_4 Node1_23_5 250.00000000000003
R_1_23_4_2 Node1_23_4 Node1_24_4 250.00000000000003
R_1_23_4_3 Node1_23_4 GND 16.0
C_1_23_4 Node1_23_4 GND 3.6093750000000004e-07
R_1_23_5_1 Node1_23_5 Node1_23_6 250.00000000000003
R_1_23_5_2 Node1_23_5 Node1_24_5 250.00000000000003
R_1_23_5_3 Node1_23_5 GND 16.0
C_1_23_5 Node1_23_5 GND 3.6093750000000004e-07
R_1_23_6_1 Node1_23_6 Node1_23_7 250.00000000000003
R_1_23_6_2 Node1_23_6 Node1_24_6 250.00000000000003
R_1_23_6_3 Node1_23_6 GND 16.0
C_1_23_6 Node1_23_6 GND 3.6093750000000004e-07
R_1_23_7_1 Node1_23_7 Node1_23_8 250.00000000000003
R_1_23_7_2 Node1_23_7 Node1_24_7 250.00000000000003
R_1_23_7_3 Node1_23_7 GND 16.0
C_1_23_7 Node1_23_7 GND 3.6093750000000004e-07
R_1_23_8_1 Node1_23_8 Node1_23_9 250.00000000000003
R_1_23_8_2 Node1_23_8 Node1_24_8 250.00000000000003
R_1_23_8_3 Node1_23_8 GND 16.0
C_1_23_8 Node1_23_8 GND 3.6093750000000004e-07
R_1_23_9_1 Node1_23_9 Node1_23_10 250.00000000000003
R_1_23_9_2 Node1_23_9 Node1_24_9 250.00000000000003
R_1_23_9_3 Node1_23_9 GND 16.0
C_1_23_9 Node1_23_9 GND 3.6093750000000004e-07
R_1_23_10_1 Node1_23_10 Node1_23_11 250.00000000000003
R_1_23_10_2 Node1_23_10 Node1_24_10 250.00000000000003
R_1_23_10_3 Node1_23_10 GND 16.0
C_1_23_10 Node1_23_10 GND 3.6093750000000004e-07
R_1_23_11_1 Node1_23_11 Node1_23_12 250.00000000000003
R_1_23_11_2 Node1_23_11 Node1_24_11 250.00000000000003
R_1_23_11_3 Node1_23_11 GND 16.0
C_1_23_11 Node1_23_11 GND 3.6093750000000004e-07
R_1_23_12_1 Node1_23_12 Node1_23_13 250.00000000000003
R_1_23_12_2 Node1_23_12 Node1_24_12 250.00000000000003
R_1_23_12_3 Node1_23_12 GND 16.0
C_1_23_12 Node1_23_12 GND 3.6093750000000004e-07
R_1_23_13_1 Node1_23_13 Node1_23_14 250.00000000000003
R_1_23_13_2 Node1_23_13 Node1_24_13 250.00000000000003
R_1_23_13_3 Node1_23_13 GND 16.0
C_1_23_13 Node1_23_13 GND 3.6093750000000004e-07
R_1_23_14_1 Node1_23_14 Node1_23_15 250.00000000000003
R_1_23_14_2 Node1_23_14 Node1_24_14 250.00000000000003
R_1_23_14_3 Node1_23_14 GND 16.0
C_1_23_14 Node1_23_14 GND 3.6093750000000004e-07
R_1_23_15_1 Node1_23_15 Node1_23_16 250.00000000000003
R_1_23_15_2 Node1_23_15 Node1_24_15 250.00000000000003
R_1_23_15_3 Node1_23_15 GND 16.0
C_1_23_15 Node1_23_15 GND 3.6093750000000004e-07
R_1_23_16_1 Node1_23_16 Node1_23_17 250.00000000000003
R_1_23_16_2 Node1_23_16 Node1_24_16 250.00000000000003
R_1_23_16_3 Node1_23_16 GND 16.0
C_1_23_16 Node1_23_16 GND 3.6093750000000004e-07
R_1_23_17_1 Node1_23_17 Node1_23_18 250.00000000000003
R_1_23_17_2 Node1_23_17 Node1_24_17 250.00000000000003
R_1_23_17_3 Node1_23_17 GND 16.0
C_1_23_17 Node1_23_17 GND 3.6093750000000004e-07
R_1_23_18_1 Node1_23_18 Node1_23_19 250.00000000000003
R_1_23_18_2 Node1_23_18 Node1_24_18 250.00000000000003
R_1_23_18_3 Node1_23_18 GND 16.0
C_1_23_18 Node1_23_18 GND 3.6093750000000004e-07
R_1_23_19_1 Node1_23_19 Node1_23_20 250.00000000000003
R_1_23_19_2 Node1_23_19 Node1_24_19 250.00000000000003
R_1_23_19_3 Node1_23_19 GND 16.0
C_1_23_19 Node1_23_19 GND 3.6093750000000004e-07
R_1_23_20_1 Node1_23_20 Node1_23_21 250.00000000000003
R_1_23_20_2 Node1_23_20 Node1_24_20 250.00000000000003
R_1_23_20_3 Node1_23_20 GND 16.0
C_1_23_20 Node1_23_20 GND 3.6093750000000004e-07
R_1_23_21_1 Node1_23_21 Node1_23_22 250.00000000000003
R_1_23_21_2 Node1_23_21 Node1_24_21 250.00000000000003
R_1_23_21_3 Node1_23_21 GND 16.0
C_1_23_21 Node1_23_21 GND 3.6093750000000004e-07
R_1_23_22_1 Node1_23_22 Node1_23_23 250.00000000000003
R_1_23_22_2 Node1_23_22 Node1_24_22 250.00000000000003
R_1_23_22_3 Node1_23_22 GND 16.0
C_1_23_22 Node1_23_22 GND 3.6093750000000004e-07
R_1_23_23_1 Node1_23_23 Node1_23_24 250.00000000000003
R_1_23_23_2 Node1_23_23 Node1_24_23 250.00000000000003
R_1_23_23_3 Node1_23_23 GND 16.0
C_1_23_23 Node1_23_23 GND 3.6093750000000004e-07
R_1_23_24_1 Node1_23_24 Node1_23_25 250.00000000000003
R_1_23_24_2 Node1_23_24 Node1_24_24 250.00000000000003
R_1_23_24_3 Node1_23_24 GND 16.0
C_1_23_24 Node1_23_24 GND 3.6093750000000004e-07
R_1_23_25_1 Node1_23_25 Node1_23_26 250.00000000000003
R_1_23_25_2 Node1_23_25 Node1_24_25 250.00000000000003
R_1_23_25_3 Node1_23_25 GND 16.0
C_1_23_25 Node1_23_25 GND 3.6093750000000004e-07
R_1_23_26_1 Node1_23_26 Node1_23_27 250.00000000000003
R_1_23_26_2 Node1_23_26 Node1_24_26 250.00000000000003
R_1_23_26_3 Node1_23_26 GND 16.0
C_1_23_26 Node1_23_26 GND 3.6093750000000004e-07
R_1_23_27_1 Node1_23_27 Node1_23_28 250.00000000000003
R_1_23_27_2 Node1_23_27 Node1_24_27 250.00000000000003
R_1_23_27_3 Node1_23_27 GND 16.0
C_1_23_27 Node1_23_27 GND 3.6093750000000004e-07
R_1_23_28_1 Node1_23_28 Node1_23_29 250.00000000000003
R_1_23_28_2 Node1_23_28 Node1_24_28 250.00000000000003
R_1_23_28_3 Node1_23_28 GND 16.0
C_1_23_28 Node1_23_28 GND 3.6093750000000004e-07
R_1_23_29_1 Node1_23_29 Node1_23_30 250.00000000000003
R_1_23_29_2 Node1_23_29 Node1_24_29 250.00000000000003
R_1_23_29_3 Node1_23_29 GND 16.0
C_1_23_29 Node1_23_29 GND 3.6093750000000004e-07
R_1_23_30_1 Node1_23_30 Node1_23_31 250.00000000000003
R_1_23_30_2 Node1_23_30 Node1_24_30 250.00000000000003
R_1_23_30_3 Node1_23_30 GND 16.0
C_1_23_30 Node1_23_30 GND 3.6093750000000004e-07
R_1_23_31_1 Node1_23_31 Node1_23_32 250.00000000000003
R_1_23_31_2 Node1_23_31 Node1_24_31 250.00000000000003
R_1_23_31_3 Node1_23_31 GND 16.0
C_1_23_31 Node1_23_31 GND 3.6093750000000004e-07
R_1_23_32_1 Node1_23_32 Node1_23_33 250.00000000000003
R_1_23_32_2 Node1_23_32 Node1_24_32 250.00000000000003
R_1_23_32_3 Node1_23_32 GND 16.0
C_1_23_32 Node1_23_32 GND 3.6093750000000004e-07
R_1_23_33_1 Node1_23_33 Node1_23_34 250.00000000000003
R_1_23_33_2 Node1_23_33 Node1_24_33 250.00000000000003
R_1_23_33_3 Node1_23_33 GND 16.0
C_1_23_33 Node1_23_33 GND 3.6093750000000004e-07
R_1_23_34_1 Node1_23_34 Node1_23_35 250.00000000000003
R_1_23_34_2 Node1_23_34 Node1_24_34 250.00000000000003
R_1_23_34_3 Node1_23_34 GND 16.0
C_1_23_34 Node1_23_34 GND 3.6093750000000004e-07
R_1_23_35_1 Node1_23_35 Node1_23_36 250.00000000000003
R_1_23_35_2 Node1_23_35 Node1_24_35 250.00000000000003
R_1_23_35_3 Node1_23_35 GND 16.0
C_1_23_35 Node1_23_35 GND 3.6093750000000004e-07
R_1_23_36_1 Node1_23_36 Node1_23_37 250.00000000000003
R_1_23_36_2 Node1_23_36 Node1_24_36 250.00000000000003
R_1_23_36_3 Node1_23_36 GND 16.0
C_1_23_36 Node1_23_36 GND 3.6093750000000004e-07
R_1_23_37_1 Node1_23_37 Node1_23_38 250.00000000000003
R_1_23_37_2 Node1_23_37 Node1_24_37 250.00000000000003
R_1_23_37_3 Node1_23_37 GND 16.0
C_1_23_37 Node1_23_37 GND 3.6093750000000004e-07
R_1_23_38_1 Node1_23_38 Node1_23_39 250.00000000000003
R_1_23_38_2 Node1_23_38 Node1_24_38 250.00000000000003
R_1_23_38_3 Node1_23_38 GND 16.0
C_1_23_38 Node1_23_38 GND 3.6093750000000004e-07
R_1_23_39_2 Node1_23_39 Node1_24_39 250.00000000000003
R_1_23_39_3 Node1_23_39 GND 16.0
C_1_23_39 Node1_23_39 GND 3.6093750000000004e-07
R_1_24_0_1 Node1_24_0 Node1_24_1 250.00000000000003
R_1_24_0_2 Node1_24_0 Node1_25_0 250.00000000000003
R_1_24_0_3 Node1_24_0 GND 16.0
C_1_24_0 Node1_24_0 GND 3.6093750000000004e-07
R_1_24_1_1 Node1_24_1 Node1_24_2 250.00000000000003
R_1_24_1_2 Node1_24_1 Node1_25_1 250.00000000000003
R_1_24_1_3 Node1_24_1 GND 16.0
C_1_24_1 Node1_24_1 GND 3.6093750000000004e-07
R_1_24_2_1 Node1_24_2 Node1_24_3 250.00000000000003
R_1_24_2_2 Node1_24_2 Node1_25_2 250.00000000000003
R_1_24_2_3 Node1_24_2 GND 16.0
C_1_24_2 Node1_24_2 GND 3.6093750000000004e-07
R_1_24_3_1 Node1_24_3 Node1_24_4 250.00000000000003
R_1_24_3_2 Node1_24_3 Node1_25_3 250.00000000000003
R_1_24_3_3 Node1_24_3 GND 16.0
C_1_24_3 Node1_24_3 GND 3.6093750000000004e-07
R_1_24_4_1 Node1_24_4 Node1_24_5 250.00000000000003
R_1_24_4_2 Node1_24_4 Node1_25_4 250.00000000000003
R_1_24_4_3 Node1_24_4 GND 16.0
C_1_24_4 Node1_24_4 GND 3.6093750000000004e-07
R_1_24_5_1 Node1_24_5 Node1_24_6 250.00000000000003
R_1_24_5_2 Node1_24_5 Node1_25_5 250.00000000000003
R_1_24_5_3 Node1_24_5 GND 16.0
C_1_24_5 Node1_24_5 GND 3.6093750000000004e-07
R_1_24_6_1 Node1_24_6 Node1_24_7 250.00000000000003
R_1_24_6_2 Node1_24_6 Node1_25_6 250.00000000000003
R_1_24_6_3 Node1_24_6 GND 16.0
C_1_24_6 Node1_24_6 GND 3.6093750000000004e-07
R_1_24_7_1 Node1_24_7 Node1_24_8 250.00000000000003
R_1_24_7_2 Node1_24_7 Node1_25_7 250.00000000000003
R_1_24_7_3 Node1_24_7 GND 16.0
C_1_24_7 Node1_24_7 GND 3.6093750000000004e-07
R_1_24_8_1 Node1_24_8 Node1_24_9 250.00000000000003
R_1_24_8_2 Node1_24_8 Node1_25_8 250.00000000000003
R_1_24_8_3 Node1_24_8 GND 16.0
C_1_24_8 Node1_24_8 GND 3.6093750000000004e-07
R_1_24_9_1 Node1_24_9 Node1_24_10 250.00000000000003
R_1_24_9_2 Node1_24_9 Node1_25_9 250.00000000000003
R_1_24_9_3 Node1_24_9 GND 16.0
C_1_24_9 Node1_24_9 GND 3.6093750000000004e-07
R_1_24_10_1 Node1_24_10 Node1_24_11 250.00000000000003
R_1_24_10_2 Node1_24_10 Node1_25_10 250.00000000000003
R_1_24_10_3 Node1_24_10 GND 16.0
C_1_24_10 Node1_24_10 GND 3.6093750000000004e-07
R_1_24_11_1 Node1_24_11 Node1_24_12 250.00000000000003
R_1_24_11_2 Node1_24_11 Node1_25_11 250.00000000000003
R_1_24_11_3 Node1_24_11 GND 16.0
C_1_24_11 Node1_24_11 GND 3.6093750000000004e-07
R_1_24_12_1 Node1_24_12 Node1_24_13 250.00000000000003
R_1_24_12_2 Node1_24_12 Node1_25_12 250.00000000000003
R_1_24_12_3 Node1_24_12 GND 16.0
C_1_24_12 Node1_24_12 GND 3.6093750000000004e-07
R_1_24_13_1 Node1_24_13 Node1_24_14 250.00000000000003
R_1_24_13_2 Node1_24_13 Node1_25_13 250.00000000000003
R_1_24_13_3 Node1_24_13 GND 16.0
C_1_24_13 Node1_24_13 GND 3.6093750000000004e-07
R_1_24_14_1 Node1_24_14 Node1_24_15 250.00000000000003
R_1_24_14_2 Node1_24_14 Node1_25_14 250.00000000000003
R_1_24_14_3 Node1_24_14 GND 16.0
C_1_24_14 Node1_24_14 GND 3.6093750000000004e-07
R_1_24_15_1 Node1_24_15 Node1_24_16 250.00000000000003
R_1_24_15_2 Node1_24_15 Node1_25_15 250.00000000000003
R_1_24_15_3 Node1_24_15 GND 16.0
C_1_24_15 Node1_24_15 GND 3.6093750000000004e-07
R_1_24_16_1 Node1_24_16 Node1_24_17 250.00000000000003
R_1_24_16_2 Node1_24_16 Node1_25_16 250.00000000000003
R_1_24_16_3 Node1_24_16 GND 16.0
C_1_24_16 Node1_24_16 GND 3.6093750000000004e-07
R_1_24_17_1 Node1_24_17 Node1_24_18 250.00000000000003
R_1_24_17_2 Node1_24_17 Node1_25_17 250.00000000000003
R_1_24_17_3 Node1_24_17 GND 16.0
C_1_24_17 Node1_24_17 GND 3.6093750000000004e-07
R_1_24_18_1 Node1_24_18 Node1_24_19 250.00000000000003
R_1_24_18_2 Node1_24_18 Node1_25_18 250.00000000000003
R_1_24_18_3 Node1_24_18 GND 16.0
C_1_24_18 Node1_24_18 GND 3.6093750000000004e-07
R_1_24_19_1 Node1_24_19 Node1_24_20 250.00000000000003
R_1_24_19_2 Node1_24_19 Node1_25_19 250.00000000000003
R_1_24_19_3 Node1_24_19 GND 16.0
C_1_24_19 Node1_24_19 GND 3.6093750000000004e-07
R_1_24_20_1 Node1_24_20 Node1_24_21 250.00000000000003
R_1_24_20_2 Node1_24_20 Node1_25_20 250.00000000000003
R_1_24_20_3 Node1_24_20 GND 16.0
C_1_24_20 Node1_24_20 GND 3.6093750000000004e-07
R_1_24_21_1 Node1_24_21 Node1_24_22 250.00000000000003
R_1_24_21_2 Node1_24_21 Node1_25_21 250.00000000000003
R_1_24_21_3 Node1_24_21 GND 16.0
C_1_24_21 Node1_24_21 GND 3.6093750000000004e-07
R_1_24_22_1 Node1_24_22 Node1_24_23 250.00000000000003
R_1_24_22_2 Node1_24_22 Node1_25_22 250.00000000000003
R_1_24_22_3 Node1_24_22 GND 16.0
C_1_24_22 Node1_24_22 GND 3.6093750000000004e-07
R_1_24_23_1 Node1_24_23 Node1_24_24 250.00000000000003
R_1_24_23_2 Node1_24_23 Node1_25_23 250.00000000000003
R_1_24_23_3 Node1_24_23 GND 16.0
C_1_24_23 Node1_24_23 GND 3.6093750000000004e-07
R_1_24_24_1 Node1_24_24 Node1_24_25 250.00000000000003
R_1_24_24_2 Node1_24_24 Node1_25_24 250.00000000000003
R_1_24_24_3 Node1_24_24 GND 16.0
C_1_24_24 Node1_24_24 GND 3.6093750000000004e-07
R_1_24_25_1 Node1_24_25 Node1_24_26 250.00000000000003
R_1_24_25_2 Node1_24_25 Node1_25_25 250.00000000000003
R_1_24_25_3 Node1_24_25 GND 16.0
C_1_24_25 Node1_24_25 GND 3.6093750000000004e-07
R_1_24_26_1 Node1_24_26 Node1_24_27 250.00000000000003
R_1_24_26_2 Node1_24_26 Node1_25_26 250.00000000000003
R_1_24_26_3 Node1_24_26 GND 16.0
C_1_24_26 Node1_24_26 GND 3.6093750000000004e-07
R_1_24_27_1 Node1_24_27 Node1_24_28 250.00000000000003
R_1_24_27_2 Node1_24_27 Node1_25_27 250.00000000000003
R_1_24_27_3 Node1_24_27 GND 16.0
C_1_24_27 Node1_24_27 GND 3.6093750000000004e-07
R_1_24_28_1 Node1_24_28 Node1_24_29 250.00000000000003
R_1_24_28_2 Node1_24_28 Node1_25_28 250.00000000000003
R_1_24_28_3 Node1_24_28 GND 16.0
C_1_24_28 Node1_24_28 GND 3.6093750000000004e-07
R_1_24_29_1 Node1_24_29 Node1_24_30 250.00000000000003
R_1_24_29_2 Node1_24_29 Node1_25_29 250.00000000000003
R_1_24_29_3 Node1_24_29 GND 16.0
C_1_24_29 Node1_24_29 GND 3.6093750000000004e-07
R_1_24_30_1 Node1_24_30 Node1_24_31 250.00000000000003
R_1_24_30_2 Node1_24_30 Node1_25_30 250.00000000000003
R_1_24_30_3 Node1_24_30 GND 16.0
C_1_24_30 Node1_24_30 GND 3.6093750000000004e-07
R_1_24_31_1 Node1_24_31 Node1_24_32 250.00000000000003
R_1_24_31_2 Node1_24_31 Node1_25_31 250.00000000000003
R_1_24_31_3 Node1_24_31 GND 16.0
C_1_24_31 Node1_24_31 GND 3.6093750000000004e-07
R_1_24_32_1 Node1_24_32 Node1_24_33 250.00000000000003
R_1_24_32_2 Node1_24_32 Node1_25_32 250.00000000000003
R_1_24_32_3 Node1_24_32 GND 16.0
C_1_24_32 Node1_24_32 GND 3.6093750000000004e-07
R_1_24_33_1 Node1_24_33 Node1_24_34 250.00000000000003
R_1_24_33_2 Node1_24_33 Node1_25_33 250.00000000000003
R_1_24_33_3 Node1_24_33 GND 16.0
C_1_24_33 Node1_24_33 GND 3.6093750000000004e-07
R_1_24_34_1 Node1_24_34 Node1_24_35 250.00000000000003
R_1_24_34_2 Node1_24_34 Node1_25_34 250.00000000000003
R_1_24_34_3 Node1_24_34 GND 16.0
C_1_24_34 Node1_24_34 GND 3.6093750000000004e-07
R_1_24_35_1 Node1_24_35 Node1_24_36 250.00000000000003
R_1_24_35_2 Node1_24_35 Node1_25_35 250.00000000000003
R_1_24_35_3 Node1_24_35 GND 16.0
C_1_24_35 Node1_24_35 GND 3.6093750000000004e-07
R_1_24_36_1 Node1_24_36 Node1_24_37 250.00000000000003
R_1_24_36_2 Node1_24_36 Node1_25_36 250.00000000000003
R_1_24_36_3 Node1_24_36 GND 16.0
C_1_24_36 Node1_24_36 GND 3.6093750000000004e-07
R_1_24_37_1 Node1_24_37 Node1_24_38 250.00000000000003
R_1_24_37_2 Node1_24_37 Node1_25_37 250.00000000000003
R_1_24_37_3 Node1_24_37 GND 16.0
C_1_24_37 Node1_24_37 GND 3.6093750000000004e-07
R_1_24_38_1 Node1_24_38 Node1_24_39 250.00000000000003
R_1_24_38_2 Node1_24_38 Node1_25_38 250.00000000000003
R_1_24_38_3 Node1_24_38 GND 16.0
C_1_24_38 Node1_24_38 GND 3.6093750000000004e-07
R_1_24_39_2 Node1_24_39 Node1_25_39 250.00000000000003
R_1_24_39_3 Node1_24_39 GND 16.0
C_1_24_39 Node1_24_39 GND 3.6093750000000004e-07
R_1_25_0_1 Node1_25_0 Node1_25_1 250.00000000000003
R_1_25_0_2 Node1_25_0 Node1_26_0 250.00000000000003
R_1_25_0_3 Node1_25_0 GND 16.0
C_1_25_0 Node1_25_0 GND 3.6093750000000004e-07
R_1_25_1_1 Node1_25_1 Node1_25_2 250.00000000000003
R_1_25_1_2 Node1_25_1 Node1_26_1 250.00000000000003
R_1_25_1_3 Node1_25_1 GND 16.0
C_1_25_1 Node1_25_1 GND 3.6093750000000004e-07
R_1_25_2_1 Node1_25_2 Node1_25_3 250.00000000000003
R_1_25_2_2 Node1_25_2 Node1_26_2 250.00000000000003
R_1_25_2_3 Node1_25_2 GND 16.0
C_1_25_2 Node1_25_2 GND 3.6093750000000004e-07
R_1_25_3_1 Node1_25_3 Node1_25_4 250.00000000000003
R_1_25_3_2 Node1_25_3 Node1_26_3 250.00000000000003
R_1_25_3_3 Node1_25_3 GND 16.0
C_1_25_3 Node1_25_3 GND 3.6093750000000004e-07
R_1_25_4_1 Node1_25_4 Node1_25_5 250.00000000000003
R_1_25_4_2 Node1_25_4 Node1_26_4 250.00000000000003
R_1_25_4_3 Node1_25_4 GND 16.0
C_1_25_4 Node1_25_4 GND 3.6093750000000004e-07
R_1_25_5_1 Node1_25_5 Node1_25_6 250.00000000000003
R_1_25_5_2 Node1_25_5 Node1_26_5 250.00000000000003
R_1_25_5_3 Node1_25_5 GND 16.0
C_1_25_5 Node1_25_5 GND 3.6093750000000004e-07
R_1_25_6_1 Node1_25_6 Node1_25_7 250.00000000000003
R_1_25_6_2 Node1_25_6 Node1_26_6 250.00000000000003
R_1_25_6_3 Node1_25_6 GND 16.0
C_1_25_6 Node1_25_6 GND 3.6093750000000004e-07
R_1_25_7_1 Node1_25_7 Node1_25_8 250.00000000000003
R_1_25_7_2 Node1_25_7 Node1_26_7 250.00000000000003
R_1_25_7_3 Node1_25_7 GND 16.0
C_1_25_7 Node1_25_7 GND 3.6093750000000004e-07
R_1_25_8_1 Node1_25_8 Node1_25_9 250.00000000000003
R_1_25_8_2 Node1_25_8 Node1_26_8 250.00000000000003
R_1_25_8_3 Node1_25_8 GND 16.0
C_1_25_8 Node1_25_8 GND 3.6093750000000004e-07
R_1_25_9_1 Node1_25_9 Node1_25_10 250.00000000000003
R_1_25_9_2 Node1_25_9 Node1_26_9 250.00000000000003
R_1_25_9_3 Node1_25_9 GND 16.0
C_1_25_9 Node1_25_9 GND 3.6093750000000004e-07
R_1_25_10_1 Node1_25_10 Node1_25_11 250.00000000000003
R_1_25_10_2 Node1_25_10 Node1_26_10 250.00000000000003
R_1_25_10_3 Node1_25_10 GND 16.0
C_1_25_10 Node1_25_10 GND 3.6093750000000004e-07
R_1_25_11_1 Node1_25_11 Node1_25_12 250.00000000000003
R_1_25_11_2 Node1_25_11 Node1_26_11 250.00000000000003
R_1_25_11_3 Node1_25_11 GND 16.0
C_1_25_11 Node1_25_11 GND 3.6093750000000004e-07
R_1_25_12_1 Node1_25_12 Node1_25_13 250.00000000000003
R_1_25_12_2 Node1_25_12 Node1_26_12 250.00000000000003
R_1_25_12_3 Node1_25_12 GND 16.0
C_1_25_12 Node1_25_12 GND 3.6093750000000004e-07
R_1_25_13_1 Node1_25_13 Node1_25_14 250.00000000000003
R_1_25_13_2 Node1_25_13 Node1_26_13 250.00000000000003
R_1_25_13_3 Node1_25_13 GND 16.0
C_1_25_13 Node1_25_13 GND 3.6093750000000004e-07
R_1_25_14_1 Node1_25_14 Node1_25_15 250.00000000000003
R_1_25_14_2 Node1_25_14 Node1_26_14 250.00000000000003
R_1_25_14_3 Node1_25_14 GND 16.0
C_1_25_14 Node1_25_14 GND 3.6093750000000004e-07
R_1_25_15_1 Node1_25_15 Node1_25_16 250.00000000000003
R_1_25_15_2 Node1_25_15 Node1_26_15 250.00000000000003
R_1_25_15_3 Node1_25_15 GND 16.0
C_1_25_15 Node1_25_15 GND 3.6093750000000004e-07
R_1_25_16_1 Node1_25_16 Node1_25_17 250.00000000000003
R_1_25_16_2 Node1_25_16 Node1_26_16 250.00000000000003
R_1_25_16_3 Node1_25_16 GND 16.0
C_1_25_16 Node1_25_16 GND 3.6093750000000004e-07
R_1_25_17_1 Node1_25_17 Node1_25_18 250.00000000000003
R_1_25_17_2 Node1_25_17 Node1_26_17 250.00000000000003
R_1_25_17_3 Node1_25_17 GND 16.0
C_1_25_17 Node1_25_17 GND 3.6093750000000004e-07
R_1_25_18_1 Node1_25_18 Node1_25_19 250.00000000000003
R_1_25_18_2 Node1_25_18 Node1_26_18 250.00000000000003
R_1_25_18_3 Node1_25_18 GND 16.0
C_1_25_18 Node1_25_18 GND 3.6093750000000004e-07
R_1_25_19_1 Node1_25_19 Node1_25_20 250.00000000000003
R_1_25_19_2 Node1_25_19 Node1_26_19 250.00000000000003
R_1_25_19_3 Node1_25_19 GND 16.0
C_1_25_19 Node1_25_19 GND 3.6093750000000004e-07
R_1_25_20_1 Node1_25_20 Node1_25_21 250.00000000000003
R_1_25_20_2 Node1_25_20 Node1_26_20 250.00000000000003
R_1_25_20_3 Node1_25_20 GND 16.0
C_1_25_20 Node1_25_20 GND 3.6093750000000004e-07
R_1_25_21_1 Node1_25_21 Node1_25_22 250.00000000000003
R_1_25_21_2 Node1_25_21 Node1_26_21 250.00000000000003
R_1_25_21_3 Node1_25_21 GND 16.0
C_1_25_21 Node1_25_21 GND 3.6093750000000004e-07
R_1_25_22_1 Node1_25_22 Node1_25_23 250.00000000000003
R_1_25_22_2 Node1_25_22 Node1_26_22 250.00000000000003
R_1_25_22_3 Node1_25_22 GND 16.0
C_1_25_22 Node1_25_22 GND 3.6093750000000004e-07
R_1_25_23_1 Node1_25_23 Node1_25_24 250.00000000000003
R_1_25_23_2 Node1_25_23 Node1_26_23 250.00000000000003
R_1_25_23_3 Node1_25_23 GND 16.0
C_1_25_23 Node1_25_23 GND 3.6093750000000004e-07
R_1_25_24_1 Node1_25_24 Node1_25_25 250.00000000000003
R_1_25_24_2 Node1_25_24 Node1_26_24 250.00000000000003
R_1_25_24_3 Node1_25_24 GND 16.0
C_1_25_24 Node1_25_24 GND 3.6093750000000004e-07
R_1_25_25_1 Node1_25_25 Node1_25_26 250.00000000000003
R_1_25_25_2 Node1_25_25 Node1_26_25 250.00000000000003
R_1_25_25_3 Node1_25_25 GND 16.0
C_1_25_25 Node1_25_25 GND 3.6093750000000004e-07
R_1_25_26_1 Node1_25_26 Node1_25_27 250.00000000000003
R_1_25_26_2 Node1_25_26 Node1_26_26 250.00000000000003
R_1_25_26_3 Node1_25_26 GND 16.0
C_1_25_26 Node1_25_26 GND 3.6093750000000004e-07
R_1_25_27_1 Node1_25_27 Node1_25_28 250.00000000000003
R_1_25_27_2 Node1_25_27 Node1_26_27 250.00000000000003
R_1_25_27_3 Node1_25_27 GND 16.0
C_1_25_27 Node1_25_27 GND 3.6093750000000004e-07
R_1_25_28_1 Node1_25_28 Node1_25_29 250.00000000000003
R_1_25_28_2 Node1_25_28 Node1_26_28 250.00000000000003
R_1_25_28_3 Node1_25_28 GND 16.0
C_1_25_28 Node1_25_28 GND 3.6093750000000004e-07
R_1_25_29_1 Node1_25_29 Node1_25_30 250.00000000000003
R_1_25_29_2 Node1_25_29 Node1_26_29 250.00000000000003
R_1_25_29_3 Node1_25_29 GND 16.0
C_1_25_29 Node1_25_29 GND 3.6093750000000004e-07
R_1_25_30_1 Node1_25_30 Node1_25_31 250.00000000000003
R_1_25_30_2 Node1_25_30 Node1_26_30 250.00000000000003
R_1_25_30_3 Node1_25_30 GND 16.0
C_1_25_30 Node1_25_30 GND 3.6093750000000004e-07
R_1_25_31_1 Node1_25_31 Node1_25_32 250.00000000000003
R_1_25_31_2 Node1_25_31 Node1_26_31 250.00000000000003
R_1_25_31_3 Node1_25_31 GND 16.0
C_1_25_31 Node1_25_31 GND 3.6093750000000004e-07
R_1_25_32_1 Node1_25_32 Node1_25_33 250.00000000000003
R_1_25_32_2 Node1_25_32 Node1_26_32 250.00000000000003
R_1_25_32_3 Node1_25_32 GND 16.0
C_1_25_32 Node1_25_32 GND 3.6093750000000004e-07
R_1_25_33_1 Node1_25_33 Node1_25_34 250.00000000000003
R_1_25_33_2 Node1_25_33 Node1_26_33 250.00000000000003
R_1_25_33_3 Node1_25_33 GND 16.0
C_1_25_33 Node1_25_33 GND 3.6093750000000004e-07
R_1_25_34_1 Node1_25_34 Node1_25_35 250.00000000000003
R_1_25_34_2 Node1_25_34 Node1_26_34 250.00000000000003
R_1_25_34_3 Node1_25_34 GND 16.0
C_1_25_34 Node1_25_34 GND 3.6093750000000004e-07
R_1_25_35_1 Node1_25_35 Node1_25_36 250.00000000000003
R_1_25_35_2 Node1_25_35 Node1_26_35 250.00000000000003
R_1_25_35_3 Node1_25_35 GND 16.0
C_1_25_35 Node1_25_35 GND 3.6093750000000004e-07
R_1_25_36_1 Node1_25_36 Node1_25_37 250.00000000000003
R_1_25_36_2 Node1_25_36 Node1_26_36 250.00000000000003
R_1_25_36_3 Node1_25_36 GND 16.0
C_1_25_36 Node1_25_36 GND 3.6093750000000004e-07
R_1_25_37_1 Node1_25_37 Node1_25_38 250.00000000000003
R_1_25_37_2 Node1_25_37 Node1_26_37 250.00000000000003
R_1_25_37_3 Node1_25_37 GND 16.0
C_1_25_37 Node1_25_37 GND 3.6093750000000004e-07
R_1_25_38_1 Node1_25_38 Node1_25_39 250.00000000000003
R_1_25_38_2 Node1_25_38 Node1_26_38 250.00000000000003
R_1_25_38_3 Node1_25_38 GND 16.0
C_1_25_38 Node1_25_38 GND 3.6093750000000004e-07
R_1_25_39_2 Node1_25_39 Node1_26_39 250.00000000000003
R_1_25_39_3 Node1_25_39 GND 16.0
C_1_25_39 Node1_25_39 GND 3.6093750000000004e-07
R_1_26_0_1 Node1_26_0 Node1_26_1 250.00000000000003
R_1_26_0_2 Node1_26_0 Node1_27_0 250.00000000000003
R_1_26_0_3 Node1_26_0 GND 16.0
C_1_26_0 Node1_26_0 GND 3.6093750000000004e-07
R_1_26_1_1 Node1_26_1 Node1_26_2 250.00000000000003
R_1_26_1_2 Node1_26_1 Node1_27_1 250.00000000000003
R_1_26_1_3 Node1_26_1 GND 16.0
C_1_26_1 Node1_26_1 GND 3.6093750000000004e-07
R_1_26_2_1 Node1_26_2 Node1_26_3 250.00000000000003
R_1_26_2_2 Node1_26_2 Node1_27_2 250.00000000000003
R_1_26_2_3 Node1_26_2 GND 16.0
C_1_26_2 Node1_26_2 GND 3.6093750000000004e-07
R_1_26_3_1 Node1_26_3 Node1_26_4 250.00000000000003
R_1_26_3_2 Node1_26_3 Node1_27_3 250.00000000000003
R_1_26_3_3 Node1_26_3 GND 16.0
C_1_26_3 Node1_26_3 GND 3.6093750000000004e-07
R_1_26_4_1 Node1_26_4 Node1_26_5 250.00000000000003
R_1_26_4_2 Node1_26_4 Node1_27_4 250.00000000000003
R_1_26_4_3 Node1_26_4 GND 16.0
C_1_26_4 Node1_26_4 GND 3.6093750000000004e-07
R_1_26_5_1 Node1_26_5 Node1_26_6 250.00000000000003
R_1_26_5_2 Node1_26_5 Node1_27_5 250.00000000000003
R_1_26_5_3 Node1_26_5 GND 16.0
C_1_26_5 Node1_26_5 GND 3.6093750000000004e-07
R_1_26_6_1 Node1_26_6 Node1_26_7 250.00000000000003
R_1_26_6_2 Node1_26_6 Node1_27_6 250.00000000000003
R_1_26_6_3 Node1_26_6 GND 16.0
C_1_26_6 Node1_26_6 GND 3.6093750000000004e-07
R_1_26_7_1 Node1_26_7 Node1_26_8 250.00000000000003
R_1_26_7_2 Node1_26_7 Node1_27_7 250.00000000000003
R_1_26_7_3 Node1_26_7 GND 16.0
C_1_26_7 Node1_26_7 GND 3.6093750000000004e-07
R_1_26_8_1 Node1_26_8 Node1_26_9 250.00000000000003
R_1_26_8_2 Node1_26_8 Node1_27_8 250.00000000000003
R_1_26_8_3 Node1_26_8 GND 16.0
C_1_26_8 Node1_26_8 GND 3.6093750000000004e-07
R_1_26_9_1 Node1_26_9 Node1_26_10 250.00000000000003
R_1_26_9_2 Node1_26_9 Node1_27_9 250.00000000000003
R_1_26_9_3 Node1_26_9 GND 16.0
C_1_26_9 Node1_26_9 GND 3.6093750000000004e-07
R_1_26_10_1 Node1_26_10 Node1_26_11 250.00000000000003
R_1_26_10_2 Node1_26_10 Node1_27_10 250.00000000000003
R_1_26_10_3 Node1_26_10 GND 16.0
C_1_26_10 Node1_26_10 GND 3.6093750000000004e-07
R_1_26_11_1 Node1_26_11 Node1_26_12 250.00000000000003
R_1_26_11_2 Node1_26_11 Node1_27_11 250.00000000000003
R_1_26_11_3 Node1_26_11 GND 16.0
C_1_26_11 Node1_26_11 GND 3.6093750000000004e-07
R_1_26_12_1 Node1_26_12 Node1_26_13 250.00000000000003
R_1_26_12_2 Node1_26_12 Node1_27_12 250.00000000000003
R_1_26_12_3 Node1_26_12 GND 16.0
C_1_26_12 Node1_26_12 GND 3.6093750000000004e-07
R_1_26_13_1 Node1_26_13 Node1_26_14 250.00000000000003
R_1_26_13_2 Node1_26_13 Node1_27_13 250.00000000000003
R_1_26_13_3 Node1_26_13 GND 16.0
C_1_26_13 Node1_26_13 GND 3.6093750000000004e-07
R_1_26_14_1 Node1_26_14 Node1_26_15 250.00000000000003
R_1_26_14_2 Node1_26_14 Node1_27_14 250.00000000000003
R_1_26_14_3 Node1_26_14 GND 16.0
C_1_26_14 Node1_26_14 GND 3.6093750000000004e-07
R_1_26_15_1 Node1_26_15 Node1_26_16 250.00000000000003
R_1_26_15_2 Node1_26_15 Node1_27_15 250.00000000000003
R_1_26_15_3 Node1_26_15 GND 16.0
C_1_26_15 Node1_26_15 GND 3.6093750000000004e-07
R_1_26_16_1 Node1_26_16 Node1_26_17 250.00000000000003
R_1_26_16_2 Node1_26_16 Node1_27_16 250.00000000000003
R_1_26_16_3 Node1_26_16 GND 16.0
C_1_26_16 Node1_26_16 GND 3.6093750000000004e-07
R_1_26_17_1 Node1_26_17 Node1_26_18 250.00000000000003
R_1_26_17_2 Node1_26_17 Node1_27_17 250.00000000000003
R_1_26_17_3 Node1_26_17 GND 16.0
C_1_26_17 Node1_26_17 GND 3.6093750000000004e-07
R_1_26_18_1 Node1_26_18 Node1_26_19 250.00000000000003
R_1_26_18_2 Node1_26_18 Node1_27_18 250.00000000000003
R_1_26_18_3 Node1_26_18 GND 16.0
C_1_26_18 Node1_26_18 GND 3.6093750000000004e-07
R_1_26_19_1 Node1_26_19 Node1_26_20 250.00000000000003
R_1_26_19_2 Node1_26_19 Node1_27_19 250.00000000000003
R_1_26_19_3 Node1_26_19 GND 16.0
C_1_26_19 Node1_26_19 GND 3.6093750000000004e-07
R_1_26_20_1 Node1_26_20 Node1_26_21 250.00000000000003
R_1_26_20_2 Node1_26_20 Node1_27_20 250.00000000000003
R_1_26_20_3 Node1_26_20 GND 16.0
C_1_26_20 Node1_26_20 GND 3.6093750000000004e-07
R_1_26_21_1 Node1_26_21 Node1_26_22 250.00000000000003
R_1_26_21_2 Node1_26_21 Node1_27_21 250.00000000000003
R_1_26_21_3 Node1_26_21 GND 16.0
C_1_26_21 Node1_26_21 GND 3.6093750000000004e-07
R_1_26_22_1 Node1_26_22 Node1_26_23 250.00000000000003
R_1_26_22_2 Node1_26_22 Node1_27_22 250.00000000000003
R_1_26_22_3 Node1_26_22 GND 16.0
C_1_26_22 Node1_26_22 GND 3.6093750000000004e-07
R_1_26_23_1 Node1_26_23 Node1_26_24 250.00000000000003
R_1_26_23_2 Node1_26_23 Node1_27_23 250.00000000000003
R_1_26_23_3 Node1_26_23 GND 16.0
C_1_26_23 Node1_26_23 GND 3.6093750000000004e-07
R_1_26_24_1 Node1_26_24 Node1_26_25 250.00000000000003
R_1_26_24_2 Node1_26_24 Node1_27_24 250.00000000000003
R_1_26_24_3 Node1_26_24 GND 16.0
C_1_26_24 Node1_26_24 GND 3.6093750000000004e-07
R_1_26_25_1 Node1_26_25 Node1_26_26 250.00000000000003
R_1_26_25_2 Node1_26_25 Node1_27_25 250.00000000000003
R_1_26_25_3 Node1_26_25 GND 16.0
C_1_26_25 Node1_26_25 GND 3.6093750000000004e-07
R_1_26_26_1 Node1_26_26 Node1_26_27 250.00000000000003
R_1_26_26_2 Node1_26_26 Node1_27_26 250.00000000000003
R_1_26_26_3 Node1_26_26 GND 16.0
C_1_26_26 Node1_26_26 GND 3.6093750000000004e-07
R_1_26_27_1 Node1_26_27 Node1_26_28 250.00000000000003
R_1_26_27_2 Node1_26_27 Node1_27_27 250.00000000000003
R_1_26_27_3 Node1_26_27 GND 16.0
C_1_26_27 Node1_26_27 GND 3.6093750000000004e-07
R_1_26_28_1 Node1_26_28 Node1_26_29 250.00000000000003
R_1_26_28_2 Node1_26_28 Node1_27_28 250.00000000000003
R_1_26_28_3 Node1_26_28 GND 16.0
C_1_26_28 Node1_26_28 GND 3.6093750000000004e-07
R_1_26_29_1 Node1_26_29 Node1_26_30 250.00000000000003
R_1_26_29_2 Node1_26_29 Node1_27_29 250.00000000000003
R_1_26_29_3 Node1_26_29 GND 16.0
C_1_26_29 Node1_26_29 GND 3.6093750000000004e-07
R_1_26_30_1 Node1_26_30 Node1_26_31 250.00000000000003
R_1_26_30_2 Node1_26_30 Node1_27_30 250.00000000000003
R_1_26_30_3 Node1_26_30 GND 16.0
C_1_26_30 Node1_26_30 GND 3.6093750000000004e-07
R_1_26_31_1 Node1_26_31 Node1_26_32 250.00000000000003
R_1_26_31_2 Node1_26_31 Node1_27_31 250.00000000000003
R_1_26_31_3 Node1_26_31 GND 16.0
C_1_26_31 Node1_26_31 GND 3.6093750000000004e-07
R_1_26_32_1 Node1_26_32 Node1_26_33 250.00000000000003
R_1_26_32_2 Node1_26_32 Node1_27_32 250.00000000000003
R_1_26_32_3 Node1_26_32 GND 16.0
C_1_26_32 Node1_26_32 GND 3.6093750000000004e-07
R_1_26_33_1 Node1_26_33 Node1_26_34 250.00000000000003
R_1_26_33_2 Node1_26_33 Node1_27_33 250.00000000000003
R_1_26_33_3 Node1_26_33 GND 16.0
C_1_26_33 Node1_26_33 GND 3.6093750000000004e-07
R_1_26_34_1 Node1_26_34 Node1_26_35 250.00000000000003
R_1_26_34_2 Node1_26_34 Node1_27_34 250.00000000000003
R_1_26_34_3 Node1_26_34 GND 16.0
C_1_26_34 Node1_26_34 GND 3.6093750000000004e-07
R_1_26_35_1 Node1_26_35 Node1_26_36 250.00000000000003
R_1_26_35_2 Node1_26_35 Node1_27_35 250.00000000000003
R_1_26_35_3 Node1_26_35 GND 16.0
C_1_26_35 Node1_26_35 GND 3.6093750000000004e-07
R_1_26_36_1 Node1_26_36 Node1_26_37 250.00000000000003
R_1_26_36_2 Node1_26_36 Node1_27_36 250.00000000000003
R_1_26_36_3 Node1_26_36 GND 16.0
C_1_26_36 Node1_26_36 GND 3.6093750000000004e-07
R_1_26_37_1 Node1_26_37 Node1_26_38 250.00000000000003
R_1_26_37_2 Node1_26_37 Node1_27_37 250.00000000000003
R_1_26_37_3 Node1_26_37 GND 16.0
C_1_26_37 Node1_26_37 GND 3.6093750000000004e-07
R_1_26_38_1 Node1_26_38 Node1_26_39 250.00000000000003
R_1_26_38_2 Node1_26_38 Node1_27_38 250.00000000000003
R_1_26_38_3 Node1_26_38 GND 16.0
C_1_26_38 Node1_26_38 GND 3.6093750000000004e-07
R_1_26_39_2 Node1_26_39 Node1_27_39 250.00000000000003
R_1_26_39_3 Node1_26_39 GND 16.0
C_1_26_39 Node1_26_39 GND 3.6093750000000004e-07
R_1_27_0_1 Node1_27_0 Node1_27_1 250.00000000000003
R_1_27_0_2 Node1_27_0 Node1_28_0 250.00000000000003
R_1_27_0_3 Node1_27_0 GND 16.0
C_1_27_0 Node1_27_0 GND 3.6093750000000004e-07
R_1_27_1_1 Node1_27_1 Node1_27_2 250.00000000000003
R_1_27_1_2 Node1_27_1 Node1_28_1 250.00000000000003
R_1_27_1_3 Node1_27_1 GND 16.0
C_1_27_1 Node1_27_1 GND 3.6093750000000004e-07
R_1_27_2_1 Node1_27_2 Node1_27_3 250.00000000000003
R_1_27_2_2 Node1_27_2 Node1_28_2 250.00000000000003
R_1_27_2_3 Node1_27_2 GND 16.0
C_1_27_2 Node1_27_2 GND 3.6093750000000004e-07
R_1_27_3_1 Node1_27_3 Node1_27_4 250.00000000000003
R_1_27_3_2 Node1_27_3 Node1_28_3 250.00000000000003
R_1_27_3_3 Node1_27_3 GND 16.0
C_1_27_3 Node1_27_3 GND 3.6093750000000004e-07
R_1_27_4_1 Node1_27_4 Node1_27_5 250.00000000000003
R_1_27_4_2 Node1_27_4 Node1_28_4 250.00000000000003
R_1_27_4_3 Node1_27_4 GND 16.0
C_1_27_4 Node1_27_4 GND 3.6093750000000004e-07
R_1_27_5_1 Node1_27_5 Node1_27_6 250.00000000000003
R_1_27_5_2 Node1_27_5 Node1_28_5 250.00000000000003
R_1_27_5_3 Node1_27_5 GND 16.0
C_1_27_5 Node1_27_5 GND 3.6093750000000004e-07
R_1_27_6_1 Node1_27_6 Node1_27_7 250.00000000000003
R_1_27_6_2 Node1_27_6 Node1_28_6 250.00000000000003
R_1_27_6_3 Node1_27_6 GND 16.0
C_1_27_6 Node1_27_6 GND 3.6093750000000004e-07
R_1_27_7_1 Node1_27_7 Node1_27_8 250.00000000000003
R_1_27_7_2 Node1_27_7 Node1_28_7 250.00000000000003
R_1_27_7_3 Node1_27_7 GND 16.0
C_1_27_7 Node1_27_7 GND 3.6093750000000004e-07
R_1_27_8_1 Node1_27_8 Node1_27_9 250.00000000000003
R_1_27_8_2 Node1_27_8 Node1_28_8 250.00000000000003
R_1_27_8_3 Node1_27_8 GND 16.0
C_1_27_8 Node1_27_8 GND 3.6093750000000004e-07
R_1_27_9_1 Node1_27_9 Node1_27_10 250.00000000000003
R_1_27_9_2 Node1_27_9 Node1_28_9 250.00000000000003
R_1_27_9_3 Node1_27_9 GND 16.0
C_1_27_9 Node1_27_9 GND 3.6093750000000004e-07
R_1_27_10_1 Node1_27_10 Node1_27_11 250.00000000000003
R_1_27_10_2 Node1_27_10 Node1_28_10 250.00000000000003
R_1_27_10_3 Node1_27_10 GND 16.0
C_1_27_10 Node1_27_10 GND 3.6093750000000004e-07
R_1_27_11_1 Node1_27_11 Node1_27_12 250.00000000000003
R_1_27_11_2 Node1_27_11 Node1_28_11 250.00000000000003
R_1_27_11_3 Node1_27_11 GND 16.0
C_1_27_11 Node1_27_11 GND 3.6093750000000004e-07
R_1_27_12_1 Node1_27_12 Node1_27_13 250.00000000000003
R_1_27_12_2 Node1_27_12 Node1_28_12 250.00000000000003
R_1_27_12_3 Node1_27_12 GND 16.0
C_1_27_12 Node1_27_12 GND 3.6093750000000004e-07
R_1_27_13_1 Node1_27_13 Node1_27_14 250.00000000000003
R_1_27_13_2 Node1_27_13 Node1_28_13 250.00000000000003
R_1_27_13_3 Node1_27_13 GND 16.0
C_1_27_13 Node1_27_13 GND 3.6093750000000004e-07
R_1_27_14_1 Node1_27_14 Node1_27_15 250.00000000000003
R_1_27_14_2 Node1_27_14 Node1_28_14 250.00000000000003
R_1_27_14_3 Node1_27_14 GND 16.0
C_1_27_14 Node1_27_14 GND 3.6093750000000004e-07
R_1_27_15_1 Node1_27_15 Node1_27_16 250.00000000000003
R_1_27_15_2 Node1_27_15 Node1_28_15 250.00000000000003
R_1_27_15_3 Node1_27_15 GND 16.0
C_1_27_15 Node1_27_15 GND 3.6093750000000004e-07
R_1_27_16_1 Node1_27_16 Node1_27_17 250.00000000000003
R_1_27_16_2 Node1_27_16 Node1_28_16 250.00000000000003
R_1_27_16_3 Node1_27_16 GND 16.0
C_1_27_16 Node1_27_16 GND 3.6093750000000004e-07
R_1_27_17_1 Node1_27_17 Node1_27_18 250.00000000000003
R_1_27_17_2 Node1_27_17 Node1_28_17 250.00000000000003
R_1_27_17_3 Node1_27_17 GND 16.0
C_1_27_17 Node1_27_17 GND 3.6093750000000004e-07
R_1_27_18_1 Node1_27_18 Node1_27_19 250.00000000000003
R_1_27_18_2 Node1_27_18 Node1_28_18 250.00000000000003
R_1_27_18_3 Node1_27_18 GND 16.0
C_1_27_18 Node1_27_18 GND 3.6093750000000004e-07
R_1_27_19_1 Node1_27_19 Node1_27_20 250.00000000000003
R_1_27_19_2 Node1_27_19 Node1_28_19 250.00000000000003
R_1_27_19_3 Node1_27_19 GND 16.0
C_1_27_19 Node1_27_19 GND 3.6093750000000004e-07
R_1_27_20_1 Node1_27_20 Node1_27_21 250.00000000000003
R_1_27_20_2 Node1_27_20 Node1_28_20 250.00000000000003
R_1_27_20_3 Node1_27_20 GND 16.0
C_1_27_20 Node1_27_20 GND 3.6093750000000004e-07
R_1_27_21_1 Node1_27_21 Node1_27_22 250.00000000000003
R_1_27_21_2 Node1_27_21 Node1_28_21 250.00000000000003
R_1_27_21_3 Node1_27_21 GND 16.0
C_1_27_21 Node1_27_21 GND 3.6093750000000004e-07
R_1_27_22_1 Node1_27_22 Node1_27_23 250.00000000000003
R_1_27_22_2 Node1_27_22 Node1_28_22 250.00000000000003
R_1_27_22_3 Node1_27_22 GND 16.0
C_1_27_22 Node1_27_22 GND 3.6093750000000004e-07
R_1_27_23_1 Node1_27_23 Node1_27_24 250.00000000000003
R_1_27_23_2 Node1_27_23 Node1_28_23 250.00000000000003
R_1_27_23_3 Node1_27_23 GND 16.0
C_1_27_23 Node1_27_23 GND 3.6093750000000004e-07
R_1_27_24_1 Node1_27_24 Node1_27_25 250.00000000000003
R_1_27_24_2 Node1_27_24 Node1_28_24 250.00000000000003
R_1_27_24_3 Node1_27_24 GND 16.0
C_1_27_24 Node1_27_24 GND 3.6093750000000004e-07
R_1_27_25_1 Node1_27_25 Node1_27_26 250.00000000000003
R_1_27_25_2 Node1_27_25 Node1_28_25 250.00000000000003
R_1_27_25_3 Node1_27_25 GND 16.0
C_1_27_25 Node1_27_25 GND 3.6093750000000004e-07
R_1_27_26_1 Node1_27_26 Node1_27_27 250.00000000000003
R_1_27_26_2 Node1_27_26 Node1_28_26 250.00000000000003
R_1_27_26_3 Node1_27_26 GND 16.0
C_1_27_26 Node1_27_26 GND 3.6093750000000004e-07
R_1_27_27_1 Node1_27_27 Node1_27_28 250.00000000000003
R_1_27_27_2 Node1_27_27 Node1_28_27 250.00000000000003
R_1_27_27_3 Node1_27_27 GND 16.0
C_1_27_27 Node1_27_27 GND 3.6093750000000004e-07
R_1_27_28_1 Node1_27_28 Node1_27_29 250.00000000000003
R_1_27_28_2 Node1_27_28 Node1_28_28 250.00000000000003
R_1_27_28_3 Node1_27_28 GND 16.0
C_1_27_28 Node1_27_28 GND 3.6093750000000004e-07
R_1_27_29_1 Node1_27_29 Node1_27_30 250.00000000000003
R_1_27_29_2 Node1_27_29 Node1_28_29 250.00000000000003
R_1_27_29_3 Node1_27_29 GND 16.0
C_1_27_29 Node1_27_29 GND 3.6093750000000004e-07
R_1_27_30_1 Node1_27_30 Node1_27_31 250.00000000000003
R_1_27_30_2 Node1_27_30 Node1_28_30 250.00000000000003
R_1_27_30_3 Node1_27_30 GND 16.0
C_1_27_30 Node1_27_30 GND 3.6093750000000004e-07
R_1_27_31_1 Node1_27_31 Node1_27_32 250.00000000000003
R_1_27_31_2 Node1_27_31 Node1_28_31 250.00000000000003
R_1_27_31_3 Node1_27_31 GND 16.0
C_1_27_31 Node1_27_31 GND 3.6093750000000004e-07
R_1_27_32_1 Node1_27_32 Node1_27_33 250.00000000000003
R_1_27_32_2 Node1_27_32 Node1_28_32 250.00000000000003
R_1_27_32_3 Node1_27_32 GND 16.0
C_1_27_32 Node1_27_32 GND 3.6093750000000004e-07
R_1_27_33_1 Node1_27_33 Node1_27_34 250.00000000000003
R_1_27_33_2 Node1_27_33 Node1_28_33 250.00000000000003
R_1_27_33_3 Node1_27_33 GND 16.0
C_1_27_33 Node1_27_33 GND 3.6093750000000004e-07
R_1_27_34_1 Node1_27_34 Node1_27_35 250.00000000000003
R_1_27_34_2 Node1_27_34 Node1_28_34 250.00000000000003
R_1_27_34_3 Node1_27_34 GND 16.0
C_1_27_34 Node1_27_34 GND 3.6093750000000004e-07
R_1_27_35_1 Node1_27_35 Node1_27_36 250.00000000000003
R_1_27_35_2 Node1_27_35 Node1_28_35 250.00000000000003
R_1_27_35_3 Node1_27_35 GND 16.0
C_1_27_35 Node1_27_35 GND 3.6093750000000004e-07
R_1_27_36_1 Node1_27_36 Node1_27_37 250.00000000000003
R_1_27_36_2 Node1_27_36 Node1_28_36 250.00000000000003
R_1_27_36_3 Node1_27_36 GND 16.0
C_1_27_36 Node1_27_36 GND 3.6093750000000004e-07
R_1_27_37_1 Node1_27_37 Node1_27_38 250.00000000000003
R_1_27_37_2 Node1_27_37 Node1_28_37 250.00000000000003
R_1_27_37_3 Node1_27_37 GND 16.0
C_1_27_37 Node1_27_37 GND 3.6093750000000004e-07
R_1_27_38_1 Node1_27_38 Node1_27_39 250.00000000000003
R_1_27_38_2 Node1_27_38 Node1_28_38 250.00000000000003
R_1_27_38_3 Node1_27_38 GND 16.0
C_1_27_38 Node1_27_38 GND 3.6093750000000004e-07
R_1_27_39_2 Node1_27_39 Node1_28_39 250.00000000000003
R_1_27_39_3 Node1_27_39 GND 16.0
C_1_27_39 Node1_27_39 GND 3.6093750000000004e-07
R_1_28_0_1 Node1_28_0 Node1_28_1 250.00000000000003
R_1_28_0_2 Node1_28_0 Node1_29_0 250.00000000000003
R_1_28_0_3 Node1_28_0 GND 16.0
C_1_28_0 Node1_28_0 GND 3.6093750000000004e-07
R_1_28_1_1 Node1_28_1 Node1_28_2 250.00000000000003
R_1_28_1_2 Node1_28_1 Node1_29_1 250.00000000000003
R_1_28_1_3 Node1_28_1 GND 16.0
C_1_28_1 Node1_28_1 GND 3.6093750000000004e-07
R_1_28_2_1 Node1_28_2 Node1_28_3 250.00000000000003
R_1_28_2_2 Node1_28_2 Node1_29_2 250.00000000000003
R_1_28_2_3 Node1_28_2 GND 16.0
C_1_28_2 Node1_28_2 GND 3.6093750000000004e-07
R_1_28_3_1 Node1_28_3 Node1_28_4 250.00000000000003
R_1_28_3_2 Node1_28_3 Node1_29_3 250.00000000000003
R_1_28_3_3 Node1_28_3 GND 16.0
C_1_28_3 Node1_28_3 GND 3.6093750000000004e-07
R_1_28_4_1 Node1_28_4 Node1_28_5 250.00000000000003
R_1_28_4_2 Node1_28_4 Node1_29_4 250.00000000000003
R_1_28_4_3 Node1_28_4 GND 16.0
C_1_28_4 Node1_28_4 GND 3.6093750000000004e-07
R_1_28_5_1 Node1_28_5 Node1_28_6 250.00000000000003
R_1_28_5_2 Node1_28_5 Node1_29_5 250.00000000000003
R_1_28_5_3 Node1_28_5 GND 16.0
C_1_28_5 Node1_28_5 GND 3.6093750000000004e-07
R_1_28_6_1 Node1_28_6 Node1_28_7 250.00000000000003
R_1_28_6_2 Node1_28_6 Node1_29_6 250.00000000000003
R_1_28_6_3 Node1_28_6 GND 16.0
C_1_28_6 Node1_28_6 GND 3.6093750000000004e-07
R_1_28_7_1 Node1_28_7 Node1_28_8 250.00000000000003
R_1_28_7_2 Node1_28_7 Node1_29_7 250.00000000000003
R_1_28_7_3 Node1_28_7 GND 16.0
C_1_28_7 Node1_28_7 GND 3.6093750000000004e-07
R_1_28_8_1 Node1_28_8 Node1_28_9 250.00000000000003
R_1_28_8_2 Node1_28_8 Node1_29_8 250.00000000000003
R_1_28_8_3 Node1_28_8 GND 16.0
C_1_28_8 Node1_28_8 GND 3.6093750000000004e-07
R_1_28_9_1 Node1_28_9 Node1_28_10 250.00000000000003
R_1_28_9_2 Node1_28_9 Node1_29_9 250.00000000000003
R_1_28_9_3 Node1_28_9 GND 16.0
C_1_28_9 Node1_28_9 GND 3.6093750000000004e-07
R_1_28_10_1 Node1_28_10 Node1_28_11 250.00000000000003
R_1_28_10_2 Node1_28_10 Node1_29_10 250.00000000000003
R_1_28_10_3 Node1_28_10 GND 16.0
C_1_28_10 Node1_28_10 GND 3.6093750000000004e-07
R_1_28_11_1 Node1_28_11 Node1_28_12 250.00000000000003
R_1_28_11_2 Node1_28_11 Node1_29_11 250.00000000000003
R_1_28_11_3 Node1_28_11 GND 16.0
C_1_28_11 Node1_28_11 GND 3.6093750000000004e-07
R_1_28_12_1 Node1_28_12 Node1_28_13 250.00000000000003
R_1_28_12_2 Node1_28_12 Node1_29_12 250.00000000000003
R_1_28_12_3 Node1_28_12 GND 16.0
C_1_28_12 Node1_28_12 GND 3.6093750000000004e-07
R_1_28_13_1 Node1_28_13 Node1_28_14 250.00000000000003
R_1_28_13_2 Node1_28_13 Node1_29_13 250.00000000000003
R_1_28_13_3 Node1_28_13 GND 16.0
C_1_28_13 Node1_28_13 GND 3.6093750000000004e-07
R_1_28_14_1 Node1_28_14 Node1_28_15 250.00000000000003
R_1_28_14_2 Node1_28_14 Node1_29_14 250.00000000000003
R_1_28_14_3 Node1_28_14 GND 16.0
C_1_28_14 Node1_28_14 GND 3.6093750000000004e-07
R_1_28_15_1 Node1_28_15 Node1_28_16 250.00000000000003
R_1_28_15_2 Node1_28_15 Node1_29_15 250.00000000000003
R_1_28_15_3 Node1_28_15 GND 16.0
C_1_28_15 Node1_28_15 GND 3.6093750000000004e-07
R_1_28_16_1 Node1_28_16 Node1_28_17 250.00000000000003
R_1_28_16_2 Node1_28_16 Node1_29_16 250.00000000000003
R_1_28_16_3 Node1_28_16 GND 16.0
C_1_28_16 Node1_28_16 GND 3.6093750000000004e-07
R_1_28_17_1 Node1_28_17 Node1_28_18 250.00000000000003
R_1_28_17_2 Node1_28_17 Node1_29_17 250.00000000000003
R_1_28_17_3 Node1_28_17 GND 16.0
C_1_28_17 Node1_28_17 GND 3.6093750000000004e-07
R_1_28_18_1 Node1_28_18 Node1_28_19 250.00000000000003
R_1_28_18_2 Node1_28_18 Node1_29_18 250.00000000000003
R_1_28_18_3 Node1_28_18 GND 16.0
C_1_28_18 Node1_28_18 GND 3.6093750000000004e-07
R_1_28_19_1 Node1_28_19 Node1_28_20 250.00000000000003
R_1_28_19_2 Node1_28_19 Node1_29_19 250.00000000000003
R_1_28_19_3 Node1_28_19 GND 16.0
C_1_28_19 Node1_28_19 GND 3.6093750000000004e-07
R_1_28_20_1 Node1_28_20 Node1_28_21 250.00000000000003
R_1_28_20_2 Node1_28_20 Node1_29_20 250.00000000000003
R_1_28_20_3 Node1_28_20 GND 16.0
C_1_28_20 Node1_28_20 GND 3.6093750000000004e-07
R_1_28_21_1 Node1_28_21 Node1_28_22 250.00000000000003
R_1_28_21_2 Node1_28_21 Node1_29_21 250.00000000000003
R_1_28_21_3 Node1_28_21 GND 16.0
C_1_28_21 Node1_28_21 GND 3.6093750000000004e-07
R_1_28_22_1 Node1_28_22 Node1_28_23 250.00000000000003
R_1_28_22_2 Node1_28_22 Node1_29_22 250.00000000000003
R_1_28_22_3 Node1_28_22 GND 16.0
C_1_28_22 Node1_28_22 GND 3.6093750000000004e-07
R_1_28_23_1 Node1_28_23 Node1_28_24 250.00000000000003
R_1_28_23_2 Node1_28_23 Node1_29_23 250.00000000000003
R_1_28_23_3 Node1_28_23 GND 16.0
C_1_28_23 Node1_28_23 GND 3.6093750000000004e-07
R_1_28_24_1 Node1_28_24 Node1_28_25 250.00000000000003
R_1_28_24_2 Node1_28_24 Node1_29_24 250.00000000000003
R_1_28_24_3 Node1_28_24 GND 16.0
C_1_28_24 Node1_28_24 GND 3.6093750000000004e-07
R_1_28_25_1 Node1_28_25 Node1_28_26 250.00000000000003
R_1_28_25_2 Node1_28_25 Node1_29_25 250.00000000000003
R_1_28_25_3 Node1_28_25 GND 16.0
C_1_28_25 Node1_28_25 GND 3.6093750000000004e-07
R_1_28_26_1 Node1_28_26 Node1_28_27 250.00000000000003
R_1_28_26_2 Node1_28_26 Node1_29_26 250.00000000000003
R_1_28_26_3 Node1_28_26 GND 16.0
C_1_28_26 Node1_28_26 GND 3.6093750000000004e-07
R_1_28_27_1 Node1_28_27 Node1_28_28 250.00000000000003
R_1_28_27_2 Node1_28_27 Node1_29_27 250.00000000000003
R_1_28_27_3 Node1_28_27 GND 16.0
C_1_28_27 Node1_28_27 GND 3.6093750000000004e-07
R_1_28_28_1 Node1_28_28 Node1_28_29 250.00000000000003
R_1_28_28_2 Node1_28_28 Node1_29_28 250.00000000000003
R_1_28_28_3 Node1_28_28 GND 16.0
C_1_28_28 Node1_28_28 GND 3.6093750000000004e-07
R_1_28_29_1 Node1_28_29 Node1_28_30 250.00000000000003
R_1_28_29_2 Node1_28_29 Node1_29_29 250.00000000000003
R_1_28_29_3 Node1_28_29 GND 16.0
C_1_28_29 Node1_28_29 GND 3.6093750000000004e-07
R_1_28_30_1 Node1_28_30 Node1_28_31 250.00000000000003
R_1_28_30_2 Node1_28_30 Node1_29_30 250.00000000000003
R_1_28_30_3 Node1_28_30 GND 16.0
C_1_28_30 Node1_28_30 GND 3.6093750000000004e-07
R_1_28_31_1 Node1_28_31 Node1_28_32 250.00000000000003
R_1_28_31_2 Node1_28_31 Node1_29_31 250.00000000000003
R_1_28_31_3 Node1_28_31 GND 16.0
C_1_28_31 Node1_28_31 GND 3.6093750000000004e-07
R_1_28_32_1 Node1_28_32 Node1_28_33 250.00000000000003
R_1_28_32_2 Node1_28_32 Node1_29_32 250.00000000000003
R_1_28_32_3 Node1_28_32 GND 16.0
C_1_28_32 Node1_28_32 GND 3.6093750000000004e-07
R_1_28_33_1 Node1_28_33 Node1_28_34 250.00000000000003
R_1_28_33_2 Node1_28_33 Node1_29_33 250.00000000000003
R_1_28_33_3 Node1_28_33 GND 16.0
C_1_28_33 Node1_28_33 GND 3.6093750000000004e-07
R_1_28_34_1 Node1_28_34 Node1_28_35 250.00000000000003
R_1_28_34_2 Node1_28_34 Node1_29_34 250.00000000000003
R_1_28_34_3 Node1_28_34 GND 16.0
C_1_28_34 Node1_28_34 GND 3.6093750000000004e-07
R_1_28_35_1 Node1_28_35 Node1_28_36 250.00000000000003
R_1_28_35_2 Node1_28_35 Node1_29_35 250.00000000000003
R_1_28_35_3 Node1_28_35 GND 16.0
C_1_28_35 Node1_28_35 GND 3.6093750000000004e-07
R_1_28_36_1 Node1_28_36 Node1_28_37 250.00000000000003
R_1_28_36_2 Node1_28_36 Node1_29_36 250.00000000000003
R_1_28_36_3 Node1_28_36 GND 16.0
C_1_28_36 Node1_28_36 GND 3.6093750000000004e-07
R_1_28_37_1 Node1_28_37 Node1_28_38 250.00000000000003
R_1_28_37_2 Node1_28_37 Node1_29_37 250.00000000000003
R_1_28_37_3 Node1_28_37 GND 16.0
C_1_28_37 Node1_28_37 GND 3.6093750000000004e-07
R_1_28_38_1 Node1_28_38 Node1_28_39 250.00000000000003
R_1_28_38_2 Node1_28_38 Node1_29_38 250.00000000000003
R_1_28_38_3 Node1_28_38 GND 16.0
C_1_28_38 Node1_28_38 GND 3.6093750000000004e-07
R_1_28_39_2 Node1_28_39 Node1_29_39 250.00000000000003
R_1_28_39_3 Node1_28_39 GND 16.0
C_1_28_39 Node1_28_39 GND 3.6093750000000004e-07
R_1_29_0_1 Node1_29_0 Node1_29_1 250.00000000000003
R_1_29_0_2 Node1_29_0 Node1_30_0 250.00000000000003
R_1_29_0_3 Node1_29_0 GND 16.0
C_1_29_0 Node1_29_0 GND 3.6093750000000004e-07
R_1_29_1_1 Node1_29_1 Node1_29_2 250.00000000000003
R_1_29_1_2 Node1_29_1 Node1_30_1 250.00000000000003
R_1_29_1_3 Node1_29_1 GND 16.0
C_1_29_1 Node1_29_1 GND 3.6093750000000004e-07
R_1_29_2_1 Node1_29_2 Node1_29_3 250.00000000000003
R_1_29_2_2 Node1_29_2 Node1_30_2 250.00000000000003
R_1_29_2_3 Node1_29_2 GND 16.0
C_1_29_2 Node1_29_2 GND 3.6093750000000004e-07
R_1_29_3_1 Node1_29_3 Node1_29_4 250.00000000000003
R_1_29_3_2 Node1_29_3 Node1_30_3 250.00000000000003
R_1_29_3_3 Node1_29_3 GND 16.0
C_1_29_3 Node1_29_3 GND 3.6093750000000004e-07
R_1_29_4_1 Node1_29_4 Node1_29_5 250.00000000000003
R_1_29_4_2 Node1_29_4 Node1_30_4 250.00000000000003
R_1_29_4_3 Node1_29_4 GND 16.0
C_1_29_4 Node1_29_4 GND 3.6093750000000004e-07
R_1_29_5_1 Node1_29_5 Node1_29_6 250.00000000000003
R_1_29_5_2 Node1_29_5 Node1_30_5 250.00000000000003
R_1_29_5_3 Node1_29_5 GND 16.0
C_1_29_5 Node1_29_5 GND 3.6093750000000004e-07
R_1_29_6_1 Node1_29_6 Node1_29_7 250.00000000000003
R_1_29_6_2 Node1_29_6 Node1_30_6 250.00000000000003
R_1_29_6_3 Node1_29_6 GND 16.0
C_1_29_6 Node1_29_6 GND 3.6093750000000004e-07
R_1_29_7_1 Node1_29_7 Node1_29_8 250.00000000000003
R_1_29_7_2 Node1_29_7 Node1_30_7 250.00000000000003
R_1_29_7_3 Node1_29_7 GND 16.0
C_1_29_7 Node1_29_7 GND 3.6093750000000004e-07
R_1_29_8_1 Node1_29_8 Node1_29_9 250.00000000000003
R_1_29_8_2 Node1_29_8 Node1_30_8 250.00000000000003
R_1_29_8_3 Node1_29_8 GND 16.0
C_1_29_8 Node1_29_8 GND 3.6093750000000004e-07
R_1_29_9_1 Node1_29_9 Node1_29_10 250.00000000000003
R_1_29_9_2 Node1_29_9 Node1_30_9 250.00000000000003
R_1_29_9_3 Node1_29_9 GND 16.0
C_1_29_9 Node1_29_9 GND 3.6093750000000004e-07
R_1_29_10_1 Node1_29_10 Node1_29_11 250.00000000000003
R_1_29_10_2 Node1_29_10 Node1_30_10 250.00000000000003
R_1_29_10_3 Node1_29_10 GND 16.0
C_1_29_10 Node1_29_10 GND 3.6093750000000004e-07
R_1_29_11_1 Node1_29_11 Node1_29_12 250.00000000000003
R_1_29_11_2 Node1_29_11 Node1_30_11 250.00000000000003
R_1_29_11_3 Node1_29_11 GND 16.0
C_1_29_11 Node1_29_11 GND 3.6093750000000004e-07
R_1_29_12_1 Node1_29_12 Node1_29_13 250.00000000000003
R_1_29_12_2 Node1_29_12 Node1_30_12 250.00000000000003
R_1_29_12_3 Node1_29_12 GND 16.0
C_1_29_12 Node1_29_12 GND 3.6093750000000004e-07
R_1_29_13_1 Node1_29_13 Node1_29_14 250.00000000000003
R_1_29_13_2 Node1_29_13 Node1_30_13 250.00000000000003
R_1_29_13_3 Node1_29_13 GND 16.0
C_1_29_13 Node1_29_13 GND 3.6093750000000004e-07
R_1_29_14_1 Node1_29_14 Node1_29_15 250.00000000000003
R_1_29_14_2 Node1_29_14 Node1_30_14 250.00000000000003
R_1_29_14_3 Node1_29_14 GND 16.0
C_1_29_14 Node1_29_14 GND 3.6093750000000004e-07
R_1_29_15_1 Node1_29_15 Node1_29_16 250.00000000000003
R_1_29_15_2 Node1_29_15 Node1_30_15 250.00000000000003
R_1_29_15_3 Node1_29_15 GND 16.0
C_1_29_15 Node1_29_15 GND 3.6093750000000004e-07
R_1_29_16_1 Node1_29_16 Node1_29_17 250.00000000000003
R_1_29_16_2 Node1_29_16 Node1_30_16 250.00000000000003
R_1_29_16_3 Node1_29_16 GND 16.0
C_1_29_16 Node1_29_16 GND 3.6093750000000004e-07
R_1_29_17_1 Node1_29_17 Node1_29_18 250.00000000000003
R_1_29_17_2 Node1_29_17 Node1_30_17 250.00000000000003
R_1_29_17_3 Node1_29_17 GND 16.0
C_1_29_17 Node1_29_17 GND 3.6093750000000004e-07
R_1_29_18_1 Node1_29_18 Node1_29_19 250.00000000000003
R_1_29_18_2 Node1_29_18 Node1_30_18 250.00000000000003
R_1_29_18_3 Node1_29_18 GND 16.0
C_1_29_18 Node1_29_18 GND 3.6093750000000004e-07
R_1_29_19_1 Node1_29_19 Node1_29_20 250.00000000000003
R_1_29_19_2 Node1_29_19 Node1_30_19 250.00000000000003
R_1_29_19_3 Node1_29_19 GND 16.0
C_1_29_19 Node1_29_19 GND 3.6093750000000004e-07
R_1_29_20_1 Node1_29_20 Node1_29_21 250.00000000000003
R_1_29_20_2 Node1_29_20 Node1_30_20 250.00000000000003
R_1_29_20_3 Node1_29_20 GND 16.0
C_1_29_20 Node1_29_20 GND 3.6093750000000004e-07
R_1_29_21_1 Node1_29_21 Node1_29_22 250.00000000000003
R_1_29_21_2 Node1_29_21 Node1_30_21 250.00000000000003
R_1_29_21_3 Node1_29_21 GND 16.0
C_1_29_21 Node1_29_21 GND 3.6093750000000004e-07
R_1_29_22_1 Node1_29_22 Node1_29_23 250.00000000000003
R_1_29_22_2 Node1_29_22 Node1_30_22 250.00000000000003
R_1_29_22_3 Node1_29_22 GND 16.0
C_1_29_22 Node1_29_22 GND 3.6093750000000004e-07
R_1_29_23_1 Node1_29_23 Node1_29_24 250.00000000000003
R_1_29_23_2 Node1_29_23 Node1_30_23 250.00000000000003
R_1_29_23_3 Node1_29_23 GND 16.0
C_1_29_23 Node1_29_23 GND 3.6093750000000004e-07
R_1_29_24_1 Node1_29_24 Node1_29_25 250.00000000000003
R_1_29_24_2 Node1_29_24 Node1_30_24 250.00000000000003
R_1_29_24_3 Node1_29_24 GND 16.0
C_1_29_24 Node1_29_24 GND 3.6093750000000004e-07
R_1_29_25_1 Node1_29_25 Node1_29_26 250.00000000000003
R_1_29_25_2 Node1_29_25 Node1_30_25 250.00000000000003
R_1_29_25_3 Node1_29_25 GND 16.0
C_1_29_25 Node1_29_25 GND 3.6093750000000004e-07
R_1_29_26_1 Node1_29_26 Node1_29_27 250.00000000000003
R_1_29_26_2 Node1_29_26 Node1_30_26 250.00000000000003
R_1_29_26_3 Node1_29_26 GND 16.0
C_1_29_26 Node1_29_26 GND 3.6093750000000004e-07
R_1_29_27_1 Node1_29_27 Node1_29_28 250.00000000000003
R_1_29_27_2 Node1_29_27 Node1_30_27 250.00000000000003
R_1_29_27_3 Node1_29_27 GND 16.0
C_1_29_27 Node1_29_27 GND 3.6093750000000004e-07
R_1_29_28_1 Node1_29_28 Node1_29_29 250.00000000000003
R_1_29_28_2 Node1_29_28 Node1_30_28 250.00000000000003
R_1_29_28_3 Node1_29_28 GND 16.0
C_1_29_28 Node1_29_28 GND 3.6093750000000004e-07
R_1_29_29_1 Node1_29_29 Node1_29_30 250.00000000000003
R_1_29_29_2 Node1_29_29 Node1_30_29 250.00000000000003
R_1_29_29_3 Node1_29_29 GND 16.0
C_1_29_29 Node1_29_29 GND 3.6093750000000004e-07
R_1_29_30_1 Node1_29_30 Node1_29_31 250.00000000000003
R_1_29_30_2 Node1_29_30 Node1_30_30 250.00000000000003
R_1_29_30_3 Node1_29_30 GND 16.0
C_1_29_30 Node1_29_30 GND 3.6093750000000004e-07
R_1_29_31_1 Node1_29_31 Node1_29_32 250.00000000000003
R_1_29_31_2 Node1_29_31 Node1_30_31 250.00000000000003
R_1_29_31_3 Node1_29_31 GND 16.0
C_1_29_31 Node1_29_31 GND 3.6093750000000004e-07
R_1_29_32_1 Node1_29_32 Node1_29_33 250.00000000000003
R_1_29_32_2 Node1_29_32 Node1_30_32 250.00000000000003
R_1_29_32_3 Node1_29_32 GND 16.0
C_1_29_32 Node1_29_32 GND 3.6093750000000004e-07
R_1_29_33_1 Node1_29_33 Node1_29_34 250.00000000000003
R_1_29_33_2 Node1_29_33 Node1_30_33 250.00000000000003
R_1_29_33_3 Node1_29_33 GND 16.0
C_1_29_33 Node1_29_33 GND 3.6093750000000004e-07
R_1_29_34_1 Node1_29_34 Node1_29_35 250.00000000000003
R_1_29_34_2 Node1_29_34 Node1_30_34 250.00000000000003
R_1_29_34_3 Node1_29_34 GND 16.0
C_1_29_34 Node1_29_34 GND 3.6093750000000004e-07
R_1_29_35_1 Node1_29_35 Node1_29_36 250.00000000000003
R_1_29_35_2 Node1_29_35 Node1_30_35 250.00000000000003
R_1_29_35_3 Node1_29_35 GND 16.0
C_1_29_35 Node1_29_35 GND 3.6093750000000004e-07
R_1_29_36_1 Node1_29_36 Node1_29_37 250.00000000000003
R_1_29_36_2 Node1_29_36 Node1_30_36 250.00000000000003
R_1_29_36_3 Node1_29_36 GND 16.0
C_1_29_36 Node1_29_36 GND 3.6093750000000004e-07
R_1_29_37_1 Node1_29_37 Node1_29_38 250.00000000000003
R_1_29_37_2 Node1_29_37 Node1_30_37 250.00000000000003
R_1_29_37_3 Node1_29_37 GND 16.0
C_1_29_37 Node1_29_37 GND 3.6093750000000004e-07
R_1_29_38_1 Node1_29_38 Node1_29_39 250.00000000000003
R_1_29_38_2 Node1_29_38 Node1_30_38 250.00000000000003
R_1_29_38_3 Node1_29_38 GND 16.0
C_1_29_38 Node1_29_38 GND 3.6093750000000004e-07
R_1_29_39_2 Node1_29_39 Node1_30_39 250.00000000000003
R_1_29_39_3 Node1_29_39 GND 16.0
C_1_29_39 Node1_29_39 GND 3.6093750000000004e-07
R_1_30_0_1 Node1_30_0 Node1_30_1 250.00000000000003
R_1_30_0_2 Node1_30_0 Node1_31_0 250.00000000000003
R_1_30_0_3 Node1_30_0 GND 16.0
C_1_30_0 Node1_30_0 GND 3.6093750000000004e-07
R_1_30_1_1 Node1_30_1 Node1_30_2 250.00000000000003
R_1_30_1_2 Node1_30_1 Node1_31_1 250.00000000000003
R_1_30_1_3 Node1_30_1 GND 16.0
C_1_30_1 Node1_30_1 GND 3.6093750000000004e-07
R_1_30_2_1 Node1_30_2 Node1_30_3 250.00000000000003
R_1_30_2_2 Node1_30_2 Node1_31_2 250.00000000000003
R_1_30_2_3 Node1_30_2 GND 16.0
C_1_30_2 Node1_30_2 GND 3.6093750000000004e-07
R_1_30_3_1 Node1_30_3 Node1_30_4 250.00000000000003
R_1_30_3_2 Node1_30_3 Node1_31_3 250.00000000000003
R_1_30_3_3 Node1_30_3 GND 16.0
C_1_30_3 Node1_30_3 GND 3.6093750000000004e-07
R_1_30_4_1 Node1_30_4 Node1_30_5 250.00000000000003
R_1_30_4_2 Node1_30_4 Node1_31_4 250.00000000000003
R_1_30_4_3 Node1_30_4 GND 16.0
C_1_30_4 Node1_30_4 GND 3.6093750000000004e-07
R_1_30_5_1 Node1_30_5 Node1_30_6 250.00000000000003
R_1_30_5_2 Node1_30_5 Node1_31_5 250.00000000000003
R_1_30_5_3 Node1_30_5 GND 16.0
C_1_30_5 Node1_30_5 GND 3.6093750000000004e-07
R_1_30_6_1 Node1_30_6 Node1_30_7 250.00000000000003
R_1_30_6_2 Node1_30_6 Node1_31_6 250.00000000000003
R_1_30_6_3 Node1_30_6 GND 16.0
C_1_30_6 Node1_30_6 GND 3.6093750000000004e-07
R_1_30_7_1 Node1_30_7 Node1_30_8 250.00000000000003
R_1_30_7_2 Node1_30_7 Node1_31_7 250.00000000000003
R_1_30_7_3 Node1_30_7 GND 16.0
C_1_30_7 Node1_30_7 GND 3.6093750000000004e-07
R_1_30_8_1 Node1_30_8 Node1_30_9 250.00000000000003
R_1_30_8_2 Node1_30_8 Node1_31_8 250.00000000000003
R_1_30_8_3 Node1_30_8 GND 16.0
C_1_30_8 Node1_30_8 GND 3.6093750000000004e-07
R_1_30_9_1 Node1_30_9 Node1_30_10 250.00000000000003
R_1_30_9_2 Node1_30_9 Node1_31_9 250.00000000000003
R_1_30_9_3 Node1_30_9 GND 16.0
C_1_30_9 Node1_30_9 GND 3.6093750000000004e-07
R_1_30_10_1 Node1_30_10 Node1_30_11 250.00000000000003
R_1_30_10_2 Node1_30_10 Node1_31_10 250.00000000000003
R_1_30_10_3 Node1_30_10 GND 16.0
C_1_30_10 Node1_30_10 GND 3.6093750000000004e-07
R_1_30_11_1 Node1_30_11 Node1_30_12 250.00000000000003
R_1_30_11_2 Node1_30_11 Node1_31_11 250.00000000000003
R_1_30_11_3 Node1_30_11 GND 16.0
C_1_30_11 Node1_30_11 GND 3.6093750000000004e-07
R_1_30_12_1 Node1_30_12 Node1_30_13 250.00000000000003
R_1_30_12_2 Node1_30_12 Node1_31_12 250.00000000000003
R_1_30_12_3 Node1_30_12 GND 16.0
C_1_30_12 Node1_30_12 GND 3.6093750000000004e-07
R_1_30_13_1 Node1_30_13 Node1_30_14 250.00000000000003
R_1_30_13_2 Node1_30_13 Node1_31_13 250.00000000000003
R_1_30_13_3 Node1_30_13 GND 16.0
C_1_30_13 Node1_30_13 GND 3.6093750000000004e-07
R_1_30_14_1 Node1_30_14 Node1_30_15 250.00000000000003
R_1_30_14_2 Node1_30_14 Node1_31_14 250.00000000000003
R_1_30_14_3 Node1_30_14 GND 16.0
C_1_30_14 Node1_30_14 GND 3.6093750000000004e-07
R_1_30_15_1 Node1_30_15 Node1_30_16 250.00000000000003
R_1_30_15_2 Node1_30_15 Node1_31_15 250.00000000000003
R_1_30_15_3 Node1_30_15 GND 16.0
C_1_30_15 Node1_30_15 GND 3.6093750000000004e-07
R_1_30_16_1 Node1_30_16 Node1_30_17 250.00000000000003
R_1_30_16_2 Node1_30_16 Node1_31_16 250.00000000000003
R_1_30_16_3 Node1_30_16 GND 16.0
C_1_30_16 Node1_30_16 GND 3.6093750000000004e-07
R_1_30_17_1 Node1_30_17 Node1_30_18 250.00000000000003
R_1_30_17_2 Node1_30_17 Node1_31_17 250.00000000000003
R_1_30_17_3 Node1_30_17 GND 16.0
C_1_30_17 Node1_30_17 GND 3.6093750000000004e-07
R_1_30_18_1 Node1_30_18 Node1_30_19 250.00000000000003
R_1_30_18_2 Node1_30_18 Node1_31_18 250.00000000000003
R_1_30_18_3 Node1_30_18 GND 16.0
C_1_30_18 Node1_30_18 GND 3.6093750000000004e-07
R_1_30_19_1 Node1_30_19 Node1_30_20 250.00000000000003
R_1_30_19_2 Node1_30_19 Node1_31_19 250.00000000000003
R_1_30_19_3 Node1_30_19 GND 16.0
C_1_30_19 Node1_30_19 GND 3.6093750000000004e-07
R_1_30_20_1 Node1_30_20 Node1_30_21 250.00000000000003
R_1_30_20_2 Node1_30_20 Node1_31_20 250.00000000000003
R_1_30_20_3 Node1_30_20 GND 16.0
C_1_30_20 Node1_30_20 GND 3.6093750000000004e-07
R_1_30_21_1 Node1_30_21 Node1_30_22 250.00000000000003
R_1_30_21_2 Node1_30_21 Node1_31_21 250.00000000000003
R_1_30_21_3 Node1_30_21 GND 16.0
C_1_30_21 Node1_30_21 GND 3.6093750000000004e-07
R_1_30_22_1 Node1_30_22 Node1_30_23 250.00000000000003
R_1_30_22_2 Node1_30_22 Node1_31_22 250.00000000000003
R_1_30_22_3 Node1_30_22 GND 16.0
C_1_30_22 Node1_30_22 GND 3.6093750000000004e-07
R_1_30_23_1 Node1_30_23 Node1_30_24 250.00000000000003
R_1_30_23_2 Node1_30_23 Node1_31_23 250.00000000000003
R_1_30_23_3 Node1_30_23 GND 16.0
C_1_30_23 Node1_30_23 GND 3.6093750000000004e-07
R_1_30_24_1 Node1_30_24 Node1_30_25 250.00000000000003
R_1_30_24_2 Node1_30_24 Node1_31_24 250.00000000000003
R_1_30_24_3 Node1_30_24 GND 16.0
C_1_30_24 Node1_30_24 GND 3.6093750000000004e-07
R_1_30_25_1 Node1_30_25 Node1_30_26 250.00000000000003
R_1_30_25_2 Node1_30_25 Node1_31_25 250.00000000000003
R_1_30_25_3 Node1_30_25 GND 16.0
C_1_30_25 Node1_30_25 GND 3.6093750000000004e-07
R_1_30_26_1 Node1_30_26 Node1_30_27 250.00000000000003
R_1_30_26_2 Node1_30_26 Node1_31_26 250.00000000000003
R_1_30_26_3 Node1_30_26 GND 16.0
C_1_30_26 Node1_30_26 GND 3.6093750000000004e-07
R_1_30_27_1 Node1_30_27 Node1_30_28 250.00000000000003
R_1_30_27_2 Node1_30_27 Node1_31_27 250.00000000000003
R_1_30_27_3 Node1_30_27 GND 16.0
C_1_30_27 Node1_30_27 GND 3.6093750000000004e-07
R_1_30_28_1 Node1_30_28 Node1_30_29 250.00000000000003
R_1_30_28_2 Node1_30_28 Node1_31_28 250.00000000000003
R_1_30_28_3 Node1_30_28 GND 16.0
C_1_30_28 Node1_30_28 GND 3.6093750000000004e-07
R_1_30_29_1 Node1_30_29 Node1_30_30 250.00000000000003
R_1_30_29_2 Node1_30_29 Node1_31_29 250.00000000000003
R_1_30_29_3 Node1_30_29 GND 16.0
C_1_30_29 Node1_30_29 GND 3.6093750000000004e-07
R_1_30_30_1 Node1_30_30 Node1_30_31 250.00000000000003
R_1_30_30_2 Node1_30_30 Node1_31_30 250.00000000000003
R_1_30_30_3 Node1_30_30 GND 16.0
C_1_30_30 Node1_30_30 GND 3.6093750000000004e-07
R_1_30_31_1 Node1_30_31 Node1_30_32 250.00000000000003
R_1_30_31_2 Node1_30_31 Node1_31_31 250.00000000000003
R_1_30_31_3 Node1_30_31 GND 16.0
C_1_30_31 Node1_30_31 GND 3.6093750000000004e-07
R_1_30_32_1 Node1_30_32 Node1_30_33 250.00000000000003
R_1_30_32_2 Node1_30_32 Node1_31_32 250.00000000000003
R_1_30_32_3 Node1_30_32 GND 16.0
C_1_30_32 Node1_30_32 GND 3.6093750000000004e-07
R_1_30_33_1 Node1_30_33 Node1_30_34 250.00000000000003
R_1_30_33_2 Node1_30_33 Node1_31_33 250.00000000000003
R_1_30_33_3 Node1_30_33 GND 16.0
C_1_30_33 Node1_30_33 GND 3.6093750000000004e-07
R_1_30_34_1 Node1_30_34 Node1_30_35 250.00000000000003
R_1_30_34_2 Node1_30_34 Node1_31_34 250.00000000000003
R_1_30_34_3 Node1_30_34 GND 16.0
C_1_30_34 Node1_30_34 GND 3.6093750000000004e-07
R_1_30_35_1 Node1_30_35 Node1_30_36 250.00000000000003
R_1_30_35_2 Node1_30_35 Node1_31_35 250.00000000000003
R_1_30_35_3 Node1_30_35 GND 16.0
C_1_30_35 Node1_30_35 GND 3.6093750000000004e-07
R_1_30_36_1 Node1_30_36 Node1_30_37 250.00000000000003
R_1_30_36_2 Node1_30_36 Node1_31_36 250.00000000000003
R_1_30_36_3 Node1_30_36 GND 16.0
C_1_30_36 Node1_30_36 GND 3.6093750000000004e-07
R_1_30_37_1 Node1_30_37 Node1_30_38 250.00000000000003
R_1_30_37_2 Node1_30_37 Node1_31_37 250.00000000000003
R_1_30_37_3 Node1_30_37 GND 16.0
C_1_30_37 Node1_30_37 GND 3.6093750000000004e-07
R_1_30_38_1 Node1_30_38 Node1_30_39 250.00000000000003
R_1_30_38_2 Node1_30_38 Node1_31_38 250.00000000000003
R_1_30_38_3 Node1_30_38 GND 16.0
C_1_30_38 Node1_30_38 GND 3.6093750000000004e-07
R_1_30_39_2 Node1_30_39 Node1_31_39 250.00000000000003
R_1_30_39_3 Node1_30_39 GND 16.0
C_1_30_39 Node1_30_39 GND 3.6093750000000004e-07
R_1_31_0_1 Node1_31_0 Node1_31_1 250.00000000000003
R_1_31_0_2 Node1_31_0 Node1_32_0 250.00000000000003
R_1_31_0_3 Node1_31_0 GND 16.0
C_1_31_0 Node1_31_0 GND 3.6093750000000004e-07
R_1_31_1_1 Node1_31_1 Node1_31_2 250.00000000000003
R_1_31_1_2 Node1_31_1 Node1_32_1 250.00000000000003
R_1_31_1_3 Node1_31_1 GND 16.0
C_1_31_1 Node1_31_1 GND 3.6093750000000004e-07
R_1_31_2_1 Node1_31_2 Node1_31_3 250.00000000000003
R_1_31_2_2 Node1_31_2 Node1_32_2 250.00000000000003
R_1_31_2_3 Node1_31_2 GND 16.0
C_1_31_2 Node1_31_2 GND 3.6093750000000004e-07
R_1_31_3_1 Node1_31_3 Node1_31_4 250.00000000000003
R_1_31_3_2 Node1_31_3 Node1_32_3 250.00000000000003
R_1_31_3_3 Node1_31_3 GND 16.0
C_1_31_3 Node1_31_3 GND 3.6093750000000004e-07
R_1_31_4_1 Node1_31_4 Node1_31_5 250.00000000000003
R_1_31_4_2 Node1_31_4 Node1_32_4 250.00000000000003
R_1_31_4_3 Node1_31_4 GND 16.0
C_1_31_4 Node1_31_4 GND 3.6093750000000004e-07
R_1_31_5_1 Node1_31_5 Node1_31_6 250.00000000000003
R_1_31_5_2 Node1_31_5 Node1_32_5 250.00000000000003
R_1_31_5_3 Node1_31_5 GND 16.0
C_1_31_5 Node1_31_5 GND 3.6093750000000004e-07
R_1_31_6_1 Node1_31_6 Node1_31_7 250.00000000000003
R_1_31_6_2 Node1_31_6 Node1_32_6 250.00000000000003
R_1_31_6_3 Node1_31_6 GND 16.0
C_1_31_6 Node1_31_6 GND 3.6093750000000004e-07
R_1_31_7_1 Node1_31_7 Node1_31_8 250.00000000000003
R_1_31_7_2 Node1_31_7 Node1_32_7 250.00000000000003
R_1_31_7_3 Node1_31_7 GND 16.0
C_1_31_7 Node1_31_7 GND 3.6093750000000004e-07
R_1_31_8_1 Node1_31_8 Node1_31_9 250.00000000000003
R_1_31_8_2 Node1_31_8 Node1_32_8 250.00000000000003
R_1_31_8_3 Node1_31_8 GND 16.0
C_1_31_8 Node1_31_8 GND 3.6093750000000004e-07
R_1_31_9_1 Node1_31_9 Node1_31_10 250.00000000000003
R_1_31_9_2 Node1_31_9 Node1_32_9 250.00000000000003
R_1_31_9_3 Node1_31_9 GND 16.0
C_1_31_9 Node1_31_9 GND 3.6093750000000004e-07
R_1_31_10_1 Node1_31_10 Node1_31_11 250.00000000000003
R_1_31_10_2 Node1_31_10 Node1_32_10 250.00000000000003
R_1_31_10_3 Node1_31_10 GND 16.0
C_1_31_10 Node1_31_10 GND 3.6093750000000004e-07
R_1_31_11_1 Node1_31_11 Node1_31_12 250.00000000000003
R_1_31_11_2 Node1_31_11 Node1_32_11 250.00000000000003
R_1_31_11_3 Node1_31_11 GND 16.0
C_1_31_11 Node1_31_11 GND 3.6093750000000004e-07
R_1_31_12_1 Node1_31_12 Node1_31_13 250.00000000000003
R_1_31_12_2 Node1_31_12 Node1_32_12 250.00000000000003
R_1_31_12_3 Node1_31_12 GND 16.0
C_1_31_12 Node1_31_12 GND 3.6093750000000004e-07
R_1_31_13_1 Node1_31_13 Node1_31_14 250.00000000000003
R_1_31_13_2 Node1_31_13 Node1_32_13 250.00000000000003
R_1_31_13_3 Node1_31_13 GND 16.0
C_1_31_13 Node1_31_13 GND 3.6093750000000004e-07
R_1_31_14_1 Node1_31_14 Node1_31_15 250.00000000000003
R_1_31_14_2 Node1_31_14 Node1_32_14 250.00000000000003
R_1_31_14_3 Node1_31_14 GND 16.0
C_1_31_14 Node1_31_14 GND 3.6093750000000004e-07
R_1_31_15_1 Node1_31_15 Node1_31_16 250.00000000000003
R_1_31_15_2 Node1_31_15 Node1_32_15 250.00000000000003
R_1_31_15_3 Node1_31_15 GND 16.0
C_1_31_15 Node1_31_15 GND 3.6093750000000004e-07
R_1_31_16_1 Node1_31_16 Node1_31_17 250.00000000000003
R_1_31_16_2 Node1_31_16 Node1_32_16 250.00000000000003
R_1_31_16_3 Node1_31_16 GND 16.0
C_1_31_16 Node1_31_16 GND 3.6093750000000004e-07
R_1_31_17_1 Node1_31_17 Node1_31_18 250.00000000000003
R_1_31_17_2 Node1_31_17 Node1_32_17 250.00000000000003
R_1_31_17_3 Node1_31_17 GND 16.0
C_1_31_17 Node1_31_17 GND 3.6093750000000004e-07
R_1_31_18_1 Node1_31_18 Node1_31_19 250.00000000000003
R_1_31_18_2 Node1_31_18 Node1_32_18 250.00000000000003
R_1_31_18_3 Node1_31_18 GND 16.0
C_1_31_18 Node1_31_18 GND 3.6093750000000004e-07
R_1_31_19_1 Node1_31_19 Node1_31_20 250.00000000000003
R_1_31_19_2 Node1_31_19 Node1_32_19 250.00000000000003
R_1_31_19_3 Node1_31_19 GND 16.0
C_1_31_19 Node1_31_19 GND 3.6093750000000004e-07
R_1_31_20_1 Node1_31_20 Node1_31_21 250.00000000000003
R_1_31_20_2 Node1_31_20 Node1_32_20 250.00000000000003
R_1_31_20_3 Node1_31_20 GND 16.0
C_1_31_20 Node1_31_20 GND 3.6093750000000004e-07
R_1_31_21_1 Node1_31_21 Node1_31_22 250.00000000000003
R_1_31_21_2 Node1_31_21 Node1_32_21 250.00000000000003
R_1_31_21_3 Node1_31_21 GND 16.0
C_1_31_21 Node1_31_21 GND 3.6093750000000004e-07
R_1_31_22_1 Node1_31_22 Node1_31_23 250.00000000000003
R_1_31_22_2 Node1_31_22 Node1_32_22 250.00000000000003
R_1_31_22_3 Node1_31_22 GND 16.0
C_1_31_22 Node1_31_22 GND 3.6093750000000004e-07
R_1_31_23_1 Node1_31_23 Node1_31_24 250.00000000000003
R_1_31_23_2 Node1_31_23 Node1_32_23 250.00000000000003
R_1_31_23_3 Node1_31_23 GND 16.0
C_1_31_23 Node1_31_23 GND 3.6093750000000004e-07
R_1_31_24_1 Node1_31_24 Node1_31_25 250.00000000000003
R_1_31_24_2 Node1_31_24 Node1_32_24 250.00000000000003
R_1_31_24_3 Node1_31_24 GND 16.0
C_1_31_24 Node1_31_24 GND 3.6093750000000004e-07
R_1_31_25_1 Node1_31_25 Node1_31_26 250.00000000000003
R_1_31_25_2 Node1_31_25 Node1_32_25 250.00000000000003
R_1_31_25_3 Node1_31_25 GND 16.0
C_1_31_25 Node1_31_25 GND 3.6093750000000004e-07
R_1_31_26_1 Node1_31_26 Node1_31_27 250.00000000000003
R_1_31_26_2 Node1_31_26 Node1_32_26 250.00000000000003
R_1_31_26_3 Node1_31_26 GND 16.0
C_1_31_26 Node1_31_26 GND 3.6093750000000004e-07
R_1_31_27_1 Node1_31_27 Node1_31_28 250.00000000000003
R_1_31_27_2 Node1_31_27 Node1_32_27 250.00000000000003
R_1_31_27_3 Node1_31_27 GND 16.0
C_1_31_27 Node1_31_27 GND 3.6093750000000004e-07
R_1_31_28_1 Node1_31_28 Node1_31_29 250.00000000000003
R_1_31_28_2 Node1_31_28 Node1_32_28 250.00000000000003
R_1_31_28_3 Node1_31_28 GND 16.0
C_1_31_28 Node1_31_28 GND 3.6093750000000004e-07
R_1_31_29_1 Node1_31_29 Node1_31_30 250.00000000000003
R_1_31_29_2 Node1_31_29 Node1_32_29 250.00000000000003
R_1_31_29_3 Node1_31_29 GND 16.0
C_1_31_29 Node1_31_29 GND 3.6093750000000004e-07
R_1_31_30_1 Node1_31_30 Node1_31_31 250.00000000000003
R_1_31_30_2 Node1_31_30 Node1_32_30 250.00000000000003
R_1_31_30_3 Node1_31_30 GND 16.0
C_1_31_30 Node1_31_30 GND 3.6093750000000004e-07
R_1_31_31_1 Node1_31_31 Node1_31_32 250.00000000000003
R_1_31_31_2 Node1_31_31 Node1_32_31 250.00000000000003
R_1_31_31_3 Node1_31_31 GND 16.0
C_1_31_31 Node1_31_31 GND 3.6093750000000004e-07
R_1_31_32_1 Node1_31_32 Node1_31_33 250.00000000000003
R_1_31_32_2 Node1_31_32 Node1_32_32 250.00000000000003
R_1_31_32_3 Node1_31_32 GND 16.0
C_1_31_32 Node1_31_32 GND 3.6093750000000004e-07
R_1_31_33_1 Node1_31_33 Node1_31_34 250.00000000000003
R_1_31_33_2 Node1_31_33 Node1_32_33 250.00000000000003
R_1_31_33_3 Node1_31_33 GND 16.0
C_1_31_33 Node1_31_33 GND 3.6093750000000004e-07
R_1_31_34_1 Node1_31_34 Node1_31_35 250.00000000000003
R_1_31_34_2 Node1_31_34 Node1_32_34 250.00000000000003
R_1_31_34_3 Node1_31_34 GND 16.0
C_1_31_34 Node1_31_34 GND 3.6093750000000004e-07
R_1_31_35_1 Node1_31_35 Node1_31_36 250.00000000000003
R_1_31_35_2 Node1_31_35 Node1_32_35 250.00000000000003
R_1_31_35_3 Node1_31_35 GND 16.0
C_1_31_35 Node1_31_35 GND 3.6093750000000004e-07
R_1_31_36_1 Node1_31_36 Node1_31_37 250.00000000000003
R_1_31_36_2 Node1_31_36 Node1_32_36 250.00000000000003
R_1_31_36_3 Node1_31_36 GND 16.0
C_1_31_36 Node1_31_36 GND 3.6093750000000004e-07
R_1_31_37_1 Node1_31_37 Node1_31_38 250.00000000000003
R_1_31_37_2 Node1_31_37 Node1_32_37 250.00000000000003
R_1_31_37_3 Node1_31_37 GND 16.0
C_1_31_37 Node1_31_37 GND 3.6093750000000004e-07
R_1_31_38_1 Node1_31_38 Node1_31_39 250.00000000000003
R_1_31_38_2 Node1_31_38 Node1_32_38 250.00000000000003
R_1_31_38_3 Node1_31_38 GND 16.0
C_1_31_38 Node1_31_38 GND 3.6093750000000004e-07
R_1_31_39_2 Node1_31_39 Node1_32_39 250.00000000000003
R_1_31_39_3 Node1_31_39 GND 16.0
C_1_31_39 Node1_31_39 GND 3.6093750000000004e-07
R_1_32_0_1 Node1_32_0 Node1_32_1 250.00000000000003
R_1_32_0_2 Node1_32_0 Node1_33_0 250.00000000000003
R_1_32_0_3 Node1_32_0 GND 16.0
C_1_32_0 Node1_32_0 GND 3.6093750000000004e-07
R_1_32_1_1 Node1_32_1 Node1_32_2 250.00000000000003
R_1_32_1_2 Node1_32_1 Node1_33_1 250.00000000000003
R_1_32_1_3 Node1_32_1 GND 16.0
C_1_32_1 Node1_32_1 GND 3.6093750000000004e-07
R_1_32_2_1 Node1_32_2 Node1_32_3 250.00000000000003
R_1_32_2_2 Node1_32_2 Node1_33_2 250.00000000000003
R_1_32_2_3 Node1_32_2 GND 16.0
C_1_32_2 Node1_32_2 GND 3.6093750000000004e-07
R_1_32_3_1 Node1_32_3 Node1_32_4 250.00000000000003
R_1_32_3_2 Node1_32_3 Node1_33_3 250.00000000000003
R_1_32_3_3 Node1_32_3 GND 16.0
C_1_32_3 Node1_32_3 GND 3.6093750000000004e-07
R_1_32_4_1 Node1_32_4 Node1_32_5 250.00000000000003
R_1_32_4_2 Node1_32_4 Node1_33_4 250.00000000000003
R_1_32_4_3 Node1_32_4 GND 16.0
C_1_32_4 Node1_32_4 GND 3.6093750000000004e-07
R_1_32_5_1 Node1_32_5 Node1_32_6 250.00000000000003
R_1_32_5_2 Node1_32_5 Node1_33_5 250.00000000000003
R_1_32_5_3 Node1_32_5 GND 16.0
C_1_32_5 Node1_32_5 GND 3.6093750000000004e-07
R_1_32_6_1 Node1_32_6 Node1_32_7 250.00000000000003
R_1_32_6_2 Node1_32_6 Node1_33_6 250.00000000000003
R_1_32_6_3 Node1_32_6 GND 16.0
C_1_32_6 Node1_32_6 GND 3.6093750000000004e-07
R_1_32_7_1 Node1_32_7 Node1_32_8 250.00000000000003
R_1_32_7_2 Node1_32_7 Node1_33_7 250.00000000000003
R_1_32_7_3 Node1_32_7 GND 16.0
C_1_32_7 Node1_32_7 GND 3.6093750000000004e-07
R_1_32_8_1 Node1_32_8 Node1_32_9 250.00000000000003
R_1_32_8_2 Node1_32_8 Node1_33_8 250.00000000000003
R_1_32_8_3 Node1_32_8 GND 16.0
C_1_32_8 Node1_32_8 GND 3.6093750000000004e-07
R_1_32_9_1 Node1_32_9 Node1_32_10 250.00000000000003
R_1_32_9_2 Node1_32_9 Node1_33_9 250.00000000000003
R_1_32_9_3 Node1_32_9 GND 16.0
C_1_32_9 Node1_32_9 GND 3.6093750000000004e-07
R_1_32_10_1 Node1_32_10 Node1_32_11 250.00000000000003
R_1_32_10_2 Node1_32_10 Node1_33_10 250.00000000000003
R_1_32_10_3 Node1_32_10 GND 16.0
C_1_32_10 Node1_32_10 GND 3.6093750000000004e-07
R_1_32_11_1 Node1_32_11 Node1_32_12 250.00000000000003
R_1_32_11_2 Node1_32_11 Node1_33_11 250.00000000000003
R_1_32_11_3 Node1_32_11 GND 16.0
C_1_32_11 Node1_32_11 GND 3.6093750000000004e-07
R_1_32_12_1 Node1_32_12 Node1_32_13 250.00000000000003
R_1_32_12_2 Node1_32_12 Node1_33_12 250.00000000000003
R_1_32_12_3 Node1_32_12 GND 16.0
C_1_32_12 Node1_32_12 GND 3.6093750000000004e-07
R_1_32_13_1 Node1_32_13 Node1_32_14 250.00000000000003
R_1_32_13_2 Node1_32_13 Node1_33_13 250.00000000000003
R_1_32_13_3 Node1_32_13 GND 16.0
C_1_32_13 Node1_32_13 GND 3.6093750000000004e-07
R_1_32_14_1 Node1_32_14 Node1_32_15 250.00000000000003
R_1_32_14_2 Node1_32_14 Node1_33_14 250.00000000000003
R_1_32_14_3 Node1_32_14 GND 16.0
C_1_32_14 Node1_32_14 GND 3.6093750000000004e-07
R_1_32_15_1 Node1_32_15 Node1_32_16 250.00000000000003
R_1_32_15_2 Node1_32_15 Node1_33_15 250.00000000000003
R_1_32_15_3 Node1_32_15 GND 16.0
C_1_32_15 Node1_32_15 GND 3.6093750000000004e-07
R_1_32_16_1 Node1_32_16 Node1_32_17 250.00000000000003
R_1_32_16_2 Node1_32_16 Node1_33_16 250.00000000000003
R_1_32_16_3 Node1_32_16 GND 16.0
C_1_32_16 Node1_32_16 GND 3.6093750000000004e-07
R_1_32_17_1 Node1_32_17 Node1_32_18 250.00000000000003
R_1_32_17_2 Node1_32_17 Node1_33_17 250.00000000000003
R_1_32_17_3 Node1_32_17 GND 16.0
C_1_32_17 Node1_32_17 GND 3.6093750000000004e-07
R_1_32_18_1 Node1_32_18 Node1_32_19 250.00000000000003
R_1_32_18_2 Node1_32_18 Node1_33_18 250.00000000000003
R_1_32_18_3 Node1_32_18 GND 16.0
C_1_32_18 Node1_32_18 GND 3.6093750000000004e-07
R_1_32_19_1 Node1_32_19 Node1_32_20 250.00000000000003
R_1_32_19_2 Node1_32_19 Node1_33_19 250.00000000000003
R_1_32_19_3 Node1_32_19 GND 16.0
C_1_32_19 Node1_32_19 GND 3.6093750000000004e-07
R_1_32_20_1 Node1_32_20 Node1_32_21 250.00000000000003
R_1_32_20_2 Node1_32_20 Node1_33_20 250.00000000000003
R_1_32_20_3 Node1_32_20 GND 16.0
C_1_32_20 Node1_32_20 GND 3.6093750000000004e-07
R_1_32_21_1 Node1_32_21 Node1_32_22 250.00000000000003
R_1_32_21_2 Node1_32_21 Node1_33_21 250.00000000000003
R_1_32_21_3 Node1_32_21 GND 16.0
C_1_32_21 Node1_32_21 GND 3.6093750000000004e-07
R_1_32_22_1 Node1_32_22 Node1_32_23 250.00000000000003
R_1_32_22_2 Node1_32_22 Node1_33_22 250.00000000000003
R_1_32_22_3 Node1_32_22 GND 16.0
C_1_32_22 Node1_32_22 GND 3.6093750000000004e-07
R_1_32_23_1 Node1_32_23 Node1_32_24 250.00000000000003
R_1_32_23_2 Node1_32_23 Node1_33_23 250.00000000000003
R_1_32_23_3 Node1_32_23 GND 16.0
C_1_32_23 Node1_32_23 GND 3.6093750000000004e-07
R_1_32_24_1 Node1_32_24 Node1_32_25 250.00000000000003
R_1_32_24_2 Node1_32_24 Node1_33_24 250.00000000000003
R_1_32_24_3 Node1_32_24 GND 16.0
C_1_32_24 Node1_32_24 GND 3.6093750000000004e-07
R_1_32_25_1 Node1_32_25 Node1_32_26 250.00000000000003
R_1_32_25_2 Node1_32_25 Node1_33_25 250.00000000000003
R_1_32_25_3 Node1_32_25 GND 16.0
C_1_32_25 Node1_32_25 GND 3.6093750000000004e-07
R_1_32_26_1 Node1_32_26 Node1_32_27 250.00000000000003
R_1_32_26_2 Node1_32_26 Node1_33_26 250.00000000000003
R_1_32_26_3 Node1_32_26 GND 16.0
C_1_32_26 Node1_32_26 GND 3.6093750000000004e-07
R_1_32_27_1 Node1_32_27 Node1_32_28 250.00000000000003
R_1_32_27_2 Node1_32_27 Node1_33_27 250.00000000000003
R_1_32_27_3 Node1_32_27 GND 16.0
C_1_32_27 Node1_32_27 GND 3.6093750000000004e-07
R_1_32_28_1 Node1_32_28 Node1_32_29 250.00000000000003
R_1_32_28_2 Node1_32_28 Node1_33_28 250.00000000000003
R_1_32_28_3 Node1_32_28 GND 16.0
C_1_32_28 Node1_32_28 GND 3.6093750000000004e-07
R_1_32_29_1 Node1_32_29 Node1_32_30 250.00000000000003
R_1_32_29_2 Node1_32_29 Node1_33_29 250.00000000000003
R_1_32_29_3 Node1_32_29 GND 16.0
C_1_32_29 Node1_32_29 GND 3.6093750000000004e-07
R_1_32_30_1 Node1_32_30 Node1_32_31 250.00000000000003
R_1_32_30_2 Node1_32_30 Node1_33_30 250.00000000000003
R_1_32_30_3 Node1_32_30 GND 16.0
C_1_32_30 Node1_32_30 GND 3.6093750000000004e-07
R_1_32_31_1 Node1_32_31 Node1_32_32 250.00000000000003
R_1_32_31_2 Node1_32_31 Node1_33_31 250.00000000000003
R_1_32_31_3 Node1_32_31 GND 16.0
C_1_32_31 Node1_32_31 GND 3.6093750000000004e-07
R_1_32_32_1 Node1_32_32 Node1_32_33 250.00000000000003
R_1_32_32_2 Node1_32_32 Node1_33_32 250.00000000000003
R_1_32_32_3 Node1_32_32 GND 16.0
C_1_32_32 Node1_32_32 GND 3.6093750000000004e-07
R_1_32_33_1 Node1_32_33 Node1_32_34 250.00000000000003
R_1_32_33_2 Node1_32_33 Node1_33_33 250.00000000000003
R_1_32_33_3 Node1_32_33 GND 16.0
C_1_32_33 Node1_32_33 GND 3.6093750000000004e-07
R_1_32_34_1 Node1_32_34 Node1_32_35 250.00000000000003
R_1_32_34_2 Node1_32_34 Node1_33_34 250.00000000000003
R_1_32_34_3 Node1_32_34 GND 16.0
C_1_32_34 Node1_32_34 GND 3.6093750000000004e-07
R_1_32_35_1 Node1_32_35 Node1_32_36 250.00000000000003
R_1_32_35_2 Node1_32_35 Node1_33_35 250.00000000000003
R_1_32_35_3 Node1_32_35 GND 16.0
C_1_32_35 Node1_32_35 GND 3.6093750000000004e-07
R_1_32_36_1 Node1_32_36 Node1_32_37 250.00000000000003
R_1_32_36_2 Node1_32_36 Node1_33_36 250.00000000000003
R_1_32_36_3 Node1_32_36 GND 16.0
C_1_32_36 Node1_32_36 GND 3.6093750000000004e-07
R_1_32_37_1 Node1_32_37 Node1_32_38 250.00000000000003
R_1_32_37_2 Node1_32_37 Node1_33_37 250.00000000000003
R_1_32_37_3 Node1_32_37 GND 16.0
C_1_32_37 Node1_32_37 GND 3.6093750000000004e-07
R_1_32_38_1 Node1_32_38 Node1_32_39 250.00000000000003
R_1_32_38_2 Node1_32_38 Node1_33_38 250.00000000000003
R_1_32_38_3 Node1_32_38 GND 16.0
C_1_32_38 Node1_32_38 GND 3.6093750000000004e-07
R_1_32_39_2 Node1_32_39 Node1_33_39 250.00000000000003
R_1_32_39_3 Node1_32_39 GND 16.0
C_1_32_39 Node1_32_39 GND 3.6093750000000004e-07
R_1_33_0_1 Node1_33_0 Node1_33_1 250.00000000000003
R_1_33_0_2 Node1_33_0 Node1_34_0 250.00000000000003
R_1_33_0_3 Node1_33_0 GND 16.0
C_1_33_0 Node1_33_0 GND 3.6093750000000004e-07
R_1_33_1_1 Node1_33_1 Node1_33_2 250.00000000000003
R_1_33_1_2 Node1_33_1 Node1_34_1 250.00000000000003
R_1_33_1_3 Node1_33_1 GND 16.0
C_1_33_1 Node1_33_1 GND 3.6093750000000004e-07
R_1_33_2_1 Node1_33_2 Node1_33_3 250.00000000000003
R_1_33_2_2 Node1_33_2 Node1_34_2 250.00000000000003
R_1_33_2_3 Node1_33_2 GND 16.0
C_1_33_2 Node1_33_2 GND 3.6093750000000004e-07
R_1_33_3_1 Node1_33_3 Node1_33_4 250.00000000000003
R_1_33_3_2 Node1_33_3 Node1_34_3 250.00000000000003
R_1_33_3_3 Node1_33_3 GND 16.0
C_1_33_3 Node1_33_3 GND 3.6093750000000004e-07
R_1_33_4_1 Node1_33_4 Node1_33_5 250.00000000000003
R_1_33_4_2 Node1_33_4 Node1_34_4 250.00000000000003
R_1_33_4_3 Node1_33_4 GND 16.0
C_1_33_4 Node1_33_4 GND 3.6093750000000004e-07
R_1_33_5_1 Node1_33_5 Node1_33_6 250.00000000000003
R_1_33_5_2 Node1_33_5 Node1_34_5 250.00000000000003
R_1_33_5_3 Node1_33_5 GND 16.0
C_1_33_5 Node1_33_5 GND 3.6093750000000004e-07
R_1_33_6_1 Node1_33_6 Node1_33_7 250.00000000000003
R_1_33_6_2 Node1_33_6 Node1_34_6 250.00000000000003
R_1_33_6_3 Node1_33_6 GND 16.0
C_1_33_6 Node1_33_6 GND 3.6093750000000004e-07
R_1_33_7_1 Node1_33_7 Node1_33_8 250.00000000000003
R_1_33_7_2 Node1_33_7 Node1_34_7 250.00000000000003
R_1_33_7_3 Node1_33_7 GND 16.0
C_1_33_7 Node1_33_7 GND 3.6093750000000004e-07
R_1_33_8_1 Node1_33_8 Node1_33_9 250.00000000000003
R_1_33_8_2 Node1_33_8 Node1_34_8 250.00000000000003
R_1_33_8_3 Node1_33_8 GND 16.0
C_1_33_8 Node1_33_8 GND 3.6093750000000004e-07
R_1_33_9_1 Node1_33_9 Node1_33_10 250.00000000000003
R_1_33_9_2 Node1_33_9 Node1_34_9 250.00000000000003
R_1_33_9_3 Node1_33_9 GND 16.0
C_1_33_9 Node1_33_9 GND 3.6093750000000004e-07
R_1_33_10_1 Node1_33_10 Node1_33_11 250.00000000000003
R_1_33_10_2 Node1_33_10 Node1_34_10 250.00000000000003
R_1_33_10_3 Node1_33_10 GND 16.0
C_1_33_10 Node1_33_10 GND 3.6093750000000004e-07
R_1_33_11_1 Node1_33_11 Node1_33_12 250.00000000000003
R_1_33_11_2 Node1_33_11 Node1_34_11 250.00000000000003
R_1_33_11_3 Node1_33_11 GND 16.0
C_1_33_11 Node1_33_11 GND 3.6093750000000004e-07
R_1_33_12_1 Node1_33_12 Node1_33_13 250.00000000000003
R_1_33_12_2 Node1_33_12 Node1_34_12 250.00000000000003
R_1_33_12_3 Node1_33_12 GND 16.0
C_1_33_12 Node1_33_12 GND 3.6093750000000004e-07
R_1_33_13_1 Node1_33_13 Node1_33_14 250.00000000000003
R_1_33_13_2 Node1_33_13 Node1_34_13 250.00000000000003
R_1_33_13_3 Node1_33_13 GND 16.0
C_1_33_13 Node1_33_13 GND 3.6093750000000004e-07
R_1_33_14_1 Node1_33_14 Node1_33_15 250.00000000000003
R_1_33_14_2 Node1_33_14 Node1_34_14 250.00000000000003
R_1_33_14_3 Node1_33_14 GND 16.0
C_1_33_14 Node1_33_14 GND 3.6093750000000004e-07
R_1_33_15_1 Node1_33_15 Node1_33_16 250.00000000000003
R_1_33_15_2 Node1_33_15 Node1_34_15 250.00000000000003
R_1_33_15_3 Node1_33_15 GND 16.0
C_1_33_15 Node1_33_15 GND 3.6093750000000004e-07
R_1_33_16_1 Node1_33_16 Node1_33_17 250.00000000000003
R_1_33_16_2 Node1_33_16 Node1_34_16 250.00000000000003
R_1_33_16_3 Node1_33_16 GND 16.0
C_1_33_16 Node1_33_16 GND 3.6093750000000004e-07
R_1_33_17_1 Node1_33_17 Node1_33_18 250.00000000000003
R_1_33_17_2 Node1_33_17 Node1_34_17 250.00000000000003
R_1_33_17_3 Node1_33_17 GND 16.0
C_1_33_17 Node1_33_17 GND 3.6093750000000004e-07
R_1_33_18_1 Node1_33_18 Node1_33_19 250.00000000000003
R_1_33_18_2 Node1_33_18 Node1_34_18 250.00000000000003
R_1_33_18_3 Node1_33_18 GND 16.0
C_1_33_18 Node1_33_18 GND 3.6093750000000004e-07
R_1_33_19_1 Node1_33_19 Node1_33_20 250.00000000000003
R_1_33_19_2 Node1_33_19 Node1_34_19 250.00000000000003
R_1_33_19_3 Node1_33_19 GND 16.0
C_1_33_19 Node1_33_19 GND 3.6093750000000004e-07
R_1_33_20_1 Node1_33_20 Node1_33_21 250.00000000000003
R_1_33_20_2 Node1_33_20 Node1_34_20 250.00000000000003
R_1_33_20_3 Node1_33_20 GND 16.0
C_1_33_20 Node1_33_20 GND 3.6093750000000004e-07
R_1_33_21_1 Node1_33_21 Node1_33_22 250.00000000000003
R_1_33_21_2 Node1_33_21 Node1_34_21 250.00000000000003
R_1_33_21_3 Node1_33_21 GND 16.0
C_1_33_21 Node1_33_21 GND 3.6093750000000004e-07
R_1_33_22_1 Node1_33_22 Node1_33_23 250.00000000000003
R_1_33_22_2 Node1_33_22 Node1_34_22 250.00000000000003
R_1_33_22_3 Node1_33_22 GND 16.0
C_1_33_22 Node1_33_22 GND 3.6093750000000004e-07
R_1_33_23_1 Node1_33_23 Node1_33_24 250.00000000000003
R_1_33_23_2 Node1_33_23 Node1_34_23 250.00000000000003
R_1_33_23_3 Node1_33_23 GND 16.0
C_1_33_23 Node1_33_23 GND 3.6093750000000004e-07
R_1_33_24_1 Node1_33_24 Node1_33_25 250.00000000000003
R_1_33_24_2 Node1_33_24 Node1_34_24 250.00000000000003
R_1_33_24_3 Node1_33_24 GND 16.0
C_1_33_24 Node1_33_24 GND 3.6093750000000004e-07
R_1_33_25_1 Node1_33_25 Node1_33_26 250.00000000000003
R_1_33_25_2 Node1_33_25 Node1_34_25 250.00000000000003
R_1_33_25_3 Node1_33_25 GND 16.0
C_1_33_25 Node1_33_25 GND 3.6093750000000004e-07
R_1_33_26_1 Node1_33_26 Node1_33_27 250.00000000000003
R_1_33_26_2 Node1_33_26 Node1_34_26 250.00000000000003
R_1_33_26_3 Node1_33_26 GND 16.0
C_1_33_26 Node1_33_26 GND 3.6093750000000004e-07
R_1_33_27_1 Node1_33_27 Node1_33_28 250.00000000000003
R_1_33_27_2 Node1_33_27 Node1_34_27 250.00000000000003
R_1_33_27_3 Node1_33_27 GND 16.0
C_1_33_27 Node1_33_27 GND 3.6093750000000004e-07
R_1_33_28_1 Node1_33_28 Node1_33_29 250.00000000000003
R_1_33_28_2 Node1_33_28 Node1_34_28 250.00000000000003
R_1_33_28_3 Node1_33_28 GND 16.0
C_1_33_28 Node1_33_28 GND 3.6093750000000004e-07
R_1_33_29_1 Node1_33_29 Node1_33_30 250.00000000000003
R_1_33_29_2 Node1_33_29 Node1_34_29 250.00000000000003
R_1_33_29_3 Node1_33_29 GND 16.0
C_1_33_29 Node1_33_29 GND 3.6093750000000004e-07
R_1_33_30_1 Node1_33_30 Node1_33_31 250.00000000000003
R_1_33_30_2 Node1_33_30 Node1_34_30 250.00000000000003
R_1_33_30_3 Node1_33_30 GND 16.0
C_1_33_30 Node1_33_30 GND 3.6093750000000004e-07
R_1_33_31_1 Node1_33_31 Node1_33_32 250.00000000000003
R_1_33_31_2 Node1_33_31 Node1_34_31 250.00000000000003
R_1_33_31_3 Node1_33_31 GND 16.0
C_1_33_31 Node1_33_31 GND 3.6093750000000004e-07
R_1_33_32_1 Node1_33_32 Node1_33_33 250.00000000000003
R_1_33_32_2 Node1_33_32 Node1_34_32 250.00000000000003
R_1_33_32_3 Node1_33_32 GND 16.0
C_1_33_32 Node1_33_32 GND 3.6093750000000004e-07
R_1_33_33_1 Node1_33_33 Node1_33_34 250.00000000000003
R_1_33_33_2 Node1_33_33 Node1_34_33 250.00000000000003
R_1_33_33_3 Node1_33_33 GND 16.0
C_1_33_33 Node1_33_33 GND 3.6093750000000004e-07
R_1_33_34_1 Node1_33_34 Node1_33_35 250.00000000000003
R_1_33_34_2 Node1_33_34 Node1_34_34 250.00000000000003
R_1_33_34_3 Node1_33_34 GND 16.0
C_1_33_34 Node1_33_34 GND 3.6093750000000004e-07
R_1_33_35_1 Node1_33_35 Node1_33_36 250.00000000000003
R_1_33_35_2 Node1_33_35 Node1_34_35 250.00000000000003
R_1_33_35_3 Node1_33_35 GND 16.0
C_1_33_35 Node1_33_35 GND 3.6093750000000004e-07
R_1_33_36_1 Node1_33_36 Node1_33_37 250.00000000000003
R_1_33_36_2 Node1_33_36 Node1_34_36 250.00000000000003
R_1_33_36_3 Node1_33_36 GND 16.0
C_1_33_36 Node1_33_36 GND 3.6093750000000004e-07
R_1_33_37_1 Node1_33_37 Node1_33_38 250.00000000000003
R_1_33_37_2 Node1_33_37 Node1_34_37 250.00000000000003
R_1_33_37_3 Node1_33_37 GND 16.0
C_1_33_37 Node1_33_37 GND 3.6093750000000004e-07
R_1_33_38_1 Node1_33_38 Node1_33_39 250.00000000000003
R_1_33_38_2 Node1_33_38 Node1_34_38 250.00000000000003
R_1_33_38_3 Node1_33_38 GND 16.0
C_1_33_38 Node1_33_38 GND 3.6093750000000004e-07
R_1_33_39_2 Node1_33_39 Node1_34_39 250.00000000000003
R_1_33_39_3 Node1_33_39 GND 16.0
C_1_33_39 Node1_33_39 GND 3.6093750000000004e-07
R_1_34_0_1 Node1_34_0 Node1_34_1 250.00000000000003
R_1_34_0_2 Node1_34_0 Node1_35_0 250.00000000000003
R_1_34_0_3 Node1_34_0 GND 16.0
C_1_34_0 Node1_34_0 GND 3.6093750000000004e-07
R_1_34_1_1 Node1_34_1 Node1_34_2 250.00000000000003
R_1_34_1_2 Node1_34_1 Node1_35_1 250.00000000000003
R_1_34_1_3 Node1_34_1 GND 16.0
C_1_34_1 Node1_34_1 GND 3.6093750000000004e-07
R_1_34_2_1 Node1_34_2 Node1_34_3 250.00000000000003
R_1_34_2_2 Node1_34_2 Node1_35_2 250.00000000000003
R_1_34_2_3 Node1_34_2 GND 16.0
C_1_34_2 Node1_34_2 GND 3.6093750000000004e-07
R_1_34_3_1 Node1_34_3 Node1_34_4 250.00000000000003
R_1_34_3_2 Node1_34_3 Node1_35_3 250.00000000000003
R_1_34_3_3 Node1_34_3 GND 16.0
C_1_34_3 Node1_34_3 GND 3.6093750000000004e-07
R_1_34_4_1 Node1_34_4 Node1_34_5 250.00000000000003
R_1_34_4_2 Node1_34_4 Node1_35_4 250.00000000000003
R_1_34_4_3 Node1_34_4 GND 16.0
C_1_34_4 Node1_34_4 GND 3.6093750000000004e-07
R_1_34_5_1 Node1_34_5 Node1_34_6 250.00000000000003
R_1_34_5_2 Node1_34_5 Node1_35_5 250.00000000000003
R_1_34_5_3 Node1_34_5 GND 16.0
C_1_34_5 Node1_34_5 GND 3.6093750000000004e-07
R_1_34_6_1 Node1_34_6 Node1_34_7 250.00000000000003
R_1_34_6_2 Node1_34_6 Node1_35_6 250.00000000000003
R_1_34_6_3 Node1_34_6 GND 16.0
C_1_34_6 Node1_34_6 GND 3.6093750000000004e-07
R_1_34_7_1 Node1_34_7 Node1_34_8 250.00000000000003
R_1_34_7_2 Node1_34_7 Node1_35_7 250.00000000000003
R_1_34_7_3 Node1_34_7 GND 16.0
C_1_34_7 Node1_34_7 GND 3.6093750000000004e-07
R_1_34_8_1 Node1_34_8 Node1_34_9 250.00000000000003
R_1_34_8_2 Node1_34_8 Node1_35_8 250.00000000000003
R_1_34_8_3 Node1_34_8 GND 16.0
C_1_34_8 Node1_34_8 GND 3.6093750000000004e-07
R_1_34_9_1 Node1_34_9 Node1_34_10 250.00000000000003
R_1_34_9_2 Node1_34_9 Node1_35_9 250.00000000000003
R_1_34_9_3 Node1_34_9 GND 16.0
C_1_34_9 Node1_34_9 GND 3.6093750000000004e-07
R_1_34_10_1 Node1_34_10 Node1_34_11 250.00000000000003
R_1_34_10_2 Node1_34_10 Node1_35_10 250.00000000000003
R_1_34_10_3 Node1_34_10 GND 16.0
C_1_34_10 Node1_34_10 GND 3.6093750000000004e-07
R_1_34_11_1 Node1_34_11 Node1_34_12 250.00000000000003
R_1_34_11_2 Node1_34_11 Node1_35_11 250.00000000000003
R_1_34_11_3 Node1_34_11 GND 16.0
C_1_34_11 Node1_34_11 GND 3.6093750000000004e-07
R_1_34_12_1 Node1_34_12 Node1_34_13 250.00000000000003
R_1_34_12_2 Node1_34_12 Node1_35_12 250.00000000000003
R_1_34_12_3 Node1_34_12 GND 16.0
C_1_34_12 Node1_34_12 GND 3.6093750000000004e-07
R_1_34_13_1 Node1_34_13 Node1_34_14 250.00000000000003
R_1_34_13_2 Node1_34_13 Node1_35_13 250.00000000000003
R_1_34_13_3 Node1_34_13 GND 16.0
C_1_34_13 Node1_34_13 GND 3.6093750000000004e-07
R_1_34_14_1 Node1_34_14 Node1_34_15 250.00000000000003
R_1_34_14_2 Node1_34_14 Node1_35_14 250.00000000000003
R_1_34_14_3 Node1_34_14 GND 16.0
C_1_34_14 Node1_34_14 GND 3.6093750000000004e-07
R_1_34_15_1 Node1_34_15 Node1_34_16 250.00000000000003
R_1_34_15_2 Node1_34_15 Node1_35_15 250.00000000000003
R_1_34_15_3 Node1_34_15 GND 16.0
C_1_34_15 Node1_34_15 GND 3.6093750000000004e-07
R_1_34_16_1 Node1_34_16 Node1_34_17 250.00000000000003
R_1_34_16_2 Node1_34_16 Node1_35_16 250.00000000000003
R_1_34_16_3 Node1_34_16 GND 16.0
C_1_34_16 Node1_34_16 GND 3.6093750000000004e-07
R_1_34_17_1 Node1_34_17 Node1_34_18 250.00000000000003
R_1_34_17_2 Node1_34_17 Node1_35_17 250.00000000000003
R_1_34_17_3 Node1_34_17 GND 16.0
C_1_34_17 Node1_34_17 GND 3.6093750000000004e-07
R_1_34_18_1 Node1_34_18 Node1_34_19 250.00000000000003
R_1_34_18_2 Node1_34_18 Node1_35_18 250.00000000000003
R_1_34_18_3 Node1_34_18 GND 16.0
C_1_34_18 Node1_34_18 GND 3.6093750000000004e-07
R_1_34_19_1 Node1_34_19 Node1_34_20 250.00000000000003
R_1_34_19_2 Node1_34_19 Node1_35_19 250.00000000000003
R_1_34_19_3 Node1_34_19 GND 16.0
C_1_34_19 Node1_34_19 GND 3.6093750000000004e-07
R_1_34_20_1 Node1_34_20 Node1_34_21 250.00000000000003
R_1_34_20_2 Node1_34_20 Node1_35_20 250.00000000000003
R_1_34_20_3 Node1_34_20 GND 16.0
C_1_34_20 Node1_34_20 GND 3.6093750000000004e-07
R_1_34_21_1 Node1_34_21 Node1_34_22 250.00000000000003
R_1_34_21_2 Node1_34_21 Node1_35_21 250.00000000000003
R_1_34_21_3 Node1_34_21 GND 16.0
C_1_34_21 Node1_34_21 GND 3.6093750000000004e-07
R_1_34_22_1 Node1_34_22 Node1_34_23 250.00000000000003
R_1_34_22_2 Node1_34_22 Node1_35_22 250.00000000000003
R_1_34_22_3 Node1_34_22 GND 16.0
C_1_34_22 Node1_34_22 GND 3.6093750000000004e-07
R_1_34_23_1 Node1_34_23 Node1_34_24 250.00000000000003
R_1_34_23_2 Node1_34_23 Node1_35_23 250.00000000000003
R_1_34_23_3 Node1_34_23 GND 16.0
C_1_34_23 Node1_34_23 GND 3.6093750000000004e-07
R_1_34_24_1 Node1_34_24 Node1_34_25 250.00000000000003
R_1_34_24_2 Node1_34_24 Node1_35_24 250.00000000000003
R_1_34_24_3 Node1_34_24 GND 16.0
C_1_34_24 Node1_34_24 GND 3.6093750000000004e-07
R_1_34_25_1 Node1_34_25 Node1_34_26 250.00000000000003
R_1_34_25_2 Node1_34_25 Node1_35_25 250.00000000000003
R_1_34_25_3 Node1_34_25 GND 16.0
C_1_34_25 Node1_34_25 GND 3.6093750000000004e-07
R_1_34_26_1 Node1_34_26 Node1_34_27 250.00000000000003
R_1_34_26_2 Node1_34_26 Node1_35_26 250.00000000000003
R_1_34_26_3 Node1_34_26 GND 16.0
C_1_34_26 Node1_34_26 GND 3.6093750000000004e-07
R_1_34_27_1 Node1_34_27 Node1_34_28 250.00000000000003
R_1_34_27_2 Node1_34_27 Node1_35_27 250.00000000000003
R_1_34_27_3 Node1_34_27 GND 16.0
C_1_34_27 Node1_34_27 GND 3.6093750000000004e-07
R_1_34_28_1 Node1_34_28 Node1_34_29 250.00000000000003
R_1_34_28_2 Node1_34_28 Node1_35_28 250.00000000000003
R_1_34_28_3 Node1_34_28 GND 16.0
C_1_34_28 Node1_34_28 GND 3.6093750000000004e-07
R_1_34_29_1 Node1_34_29 Node1_34_30 250.00000000000003
R_1_34_29_2 Node1_34_29 Node1_35_29 250.00000000000003
R_1_34_29_3 Node1_34_29 GND 16.0
C_1_34_29 Node1_34_29 GND 3.6093750000000004e-07
R_1_34_30_1 Node1_34_30 Node1_34_31 250.00000000000003
R_1_34_30_2 Node1_34_30 Node1_35_30 250.00000000000003
R_1_34_30_3 Node1_34_30 GND 16.0
C_1_34_30 Node1_34_30 GND 3.6093750000000004e-07
R_1_34_31_1 Node1_34_31 Node1_34_32 250.00000000000003
R_1_34_31_2 Node1_34_31 Node1_35_31 250.00000000000003
R_1_34_31_3 Node1_34_31 GND 16.0
C_1_34_31 Node1_34_31 GND 3.6093750000000004e-07
R_1_34_32_1 Node1_34_32 Node1_34_33 250.00000000000003
R_1_34_32_2 Node1_34_32 Node1_35_32 250.00000000000003
R_1_34_32_3 Node1_34_32 GND 16.0
C_1_34_32 Node1_34_32 GND 3.6093750000000004e-07
R_1_34_33_1 Node1_34_33 Node1_34_34 250.00000000000003
R_1_34_33_2 Node1_34_33 Node1_35_33 250.00000000000003
R_1_34_33_3 Node1_34_33 GND 16.0
C_1_34_33 Node1_34_33 GND 3.6093750000000004e-07
R_1_34_34_1 Node1_34_34 Node1_34_35 250.00000000000003
R_1_34_34_2 Node1_34_34 Node1_35_34 250.00000000000003
R_1_34_34_3 Node1_34_34 GND 16.0
C_1_34_34 Node1_34_34 GND 3.6093750000000004e-07
R_1_34_35_1 Node1_34_35 Node1_34_36 250.00000000000003
R_1_34_35_2 Node1_34_35 Node1_35_35 250.00000000000003
R_1_34_35_3 Node1_34_35 GND 16.0
C_1_34_35 Node1_34_35 GND 3.6093750000000004e-07
R_1_34_36_1 Node1_34_36 Node1_34_37 250.00000000000003
R_1_34_36_2 Node1_34_36 Node1_35_36 250.00000000000003
R_1_34_36_3 Node1_34_36 GND 16.0
C_1_34_36 Node1_34_36 GND 3.6093750000000004e-07
R_1_34_37_1 Node1_34_37 Node1_34_38 250.00000000000003
R_1_34_37_2 Node1_34_37 Node1_35_37 250.00000000000003
R_1_34_37_3 Node1_34_37 GND 16.0
C_1_34_37 Node1_34_37 GND 3.6093750000000004e-07
R_1_34_38_1 Node1_34_38 Node1_34_39 250.00000000000003
R_1_34_38_2 Node1_34_38 Node1_35_38 250.00000000000003
R_1_34_38_3 Node1_34_38 GND 16.0
C_1_34_38 Node1_34_38 GND 3.6093750000000004e-07
R_1_34_39_2 Node1_34_39 Node1_35_39 250.00000000000003
R_1_34_39_3 Node1_34_39 GND 16.0
C_1_34_39 Node1_34_39 GND 3.6093750000000004e-07
R_1_35_0_1 Node1_35_0 Node1_35_1 250.00000000000003
R_1_35_0_2 Node1_35_0 Node1_36_0 250.00000000000003
R_1_35_0_3 Node1_35_0 GND 16.0
C_1_35_0 Node1_35_0 GND 3.6093750000000004e-07
R_1_35_1_1 Node1_35_1 Node1_35_2 250.00000000000003
R_1_35_1_2 Node1_35_1 Node1_36_1 250.00000000000003
R_1_35_1_3 Node1_35_1 GND 16.0
C_1_35_1 Node1_35_1 GND 3.6093750000000004e-07
R_1_35_2_1 Node1_35_2 Node1_35_3 250.00000000000003
R_1_35_2_2 Node1_35_2 Node1_36_2 250.00000000000003
R_1_35_2_3 Node1_35_2 GND 16.0
C_1_35_2 Node1_35_2 GND 3.6093750000000004e-07
R_1_35_3_1 Node1_35_3 Node1_35_4 250.00000000000003
R_1_35_3_2 Node1_35_3 Node1_36_3 250.00000000000003
R_1_35_3_3 Node1_35_3 GND 16.0
C_1_35_3 Node1_35_3 GND 3.6093750000000004e-07
R_1_35_4_1 Node1_35_4 Node1_35_5 250.00000000000003
R_1_35_4_2 Node1_35_4 Node1_36_4 250.00000000000003
R_1_35_4_3 Node1_35_4 GND 16.0
C_1_35_4 Node1_35_4 GND 3.6093750000000004e-07
R_1_35_5_1 Node1_35_5 Node1_35_6 250.00000000000003
R_1_35_5_2 Node1_35_5 Node1_36_5 250.00000000000003
R_1_35_5_3 Node1_35_5 GND 16.0
C_1_35_5 Node1_35_5 GND 3.6093750000000004e-07
R_1_35_6_1 Node1_35_6 Node1_35_7 250.00000000000003
R_1_35_6_2 Node1_35_6 Node1_36_6 250.00000000000003
R_1_35_6_3 Node1_35_6 GND 16.0
C_1_35_6 Node1_35_6 GND 3.6093750000000004e-07
R_1_35_7_1 Node1_35_7 Node1_35_8 250.00000000000003
R_1_35_7_2 Node1_35_7 Node1_36_7 250.00000000000003
R_1_35_7_3 Node1_35_7 GND 16.0
C_1_35_7 Node1_35_7 GND 3.6093750000000004e-07
R_1_35_8_1 Node1_35_8 Node1_35_9 250.00000000000003
R_1_35_8_2 Node1_35_8 Node1_36_8 250.00000000000003
R_1_35_8_3 Node1_35_8 GND 16.0
C_1_35_8 Node1_35_8 GND 3.6093750000000004e-07
R_1_35_9_1 Node1_35_9 Node1_35_10 250.00000000000003
R_1_35_9_2 Node1_35_9 Node1_36_9 250.00000000000003
R_1_35_9_3 Node1_35_9 GND 16.0
C_1_35_9 Node1_35_9 GND 3.6093750000000004e-07
R_1_35_10_1 Node1_35_10 Node1_35_11 250.00000000000003
R_1_35_10_2 Node1_35_10 Node1_36_10 250.00000000000003
R_1_35_10_3 Node1_35_10 GND 16.0
C_1_35_10 Node1_35_10 GND 3.6093750000000004e-07
R_1_35_11_1 Node1_35_11 Node1_35_12 250.00000000000003
R_1_35_11_2 Node1_35_11 Node1_36_11 250.00000000000003
R_1_35_11_3 Node1_35_11 GND 16.0
C_1_35_11 Node1_35_11 GND 3.6093750000000004e-07
R_1_35_12_1 Node1_35_12 Node1_35_13 250.00000000000003
R_1_35_12_2 Node1_35_12 Node1_36_12 250.00000000000003
R_1_35_12_3 Node1_35_12 GND 16.0
C_1_35_12 Node1_35_12 GND 3.6093750000000004e-07
R_1_35_13_1 Node1_35_13 Node1_35_14 250.00000000000003
R_1_35_13_2 Node1_35_13 Node1_36_13 250.00000000000003
R_1_35_13_3 Node1_35_13 GND 16.0
C_1_35_13 Node1_35_13 GND 3.6093750000000004e-07
R_1_35_14_1 Node1_35_14 Node1_35_15 250.00000000000003
R_1_35_14_2 Node1_35_14 Node1_36_14 250.00000000000003
R_1_35_14_3 Node1_35_14 GND 16.0
C_1_35_14 Node1_35_14 GND 3.6093750000000004e-07
R_1_35_15_1 Node1_35_15 Node1_35_16 250.00000000000003
R_1_35_15_2 Node1_35_15 Node1_36_15 250.00000000000003
R_1_35_15_3 Node1_35_15 GND 16.0
C_1_35_15 Node1_35_15 GND 3.6093750000000004e-07
R_1_35_16_1 Node1_35_16 Node1_35_17 250.00000000000003
R_1_35_16_2 Node1_35_16 Node1_36_16 250.00000000000003
R_1_35_16_3 Node1_35_16 GND 16.0
C_1_35_16 Node1_35_16 GND 3.6093750000000004e-07
R_1_35_17_1 Node1_35_17 Node1_35_18 250.00000000000003
R_1_35_17_2 Node1_35_17 Node1_36_17 250.00000000000003
R_1_35_17_3 Node1_35_17 GND 16.0
C_1_35_17 Node1_35_17 GND 3.6093750000000004e-07
R_1_35_18_1 Node1_35_18 Node1_35_19 250.00000000000003
R_1_35_18_2 Node1_35_18 Node1_36_18 250.00000000000003
R_1_35_18_3 Node1_35_18 GND 16.0
C_1_35_18 Node1_35_18 GND 3.6093750000000004e-07
R_1_35_19_1 Node1_35_19 Node1_35_20 250.00000000000003
R_1_35_19_2 Node1_35_19 Node1_36_19 250.00000000000003
R_1_35_19_3 Node1_35_19 GND 16.0
C_1_35_19 Node1_35_19 GND 3.6093750000000004e-07
R_1_35_20_1 Node1_35_20 Node1_35_21 250.00000000000003
R_1_35_20_2 Node1_35_20 Node1_36_20 250.00000000000003
R_1_35_20_3 Node1_35_20 GND 16.0
C_1_35_20 Node1_35_20 GND 3.6093750000000004e-07
R_1_35_21_1 Node1_35_21 Node1_35_22 250.00000000000003
R_1_35_21_2 Node1_35_21 Node1_36_21 250.00000000000003
R_1_35_21_3 Node1_35_21 GND 16.0
C_1_35_21 Node1_35_21 GND 3.6093750000000004e-07
R_1_35_22_1 Node1_35_22 Node1_35_23 250.00000000000003
R_1_35_22_2 Node1_35_22 Node1_36_22 250.00000000000003
R_1_35_22_3 Node1_35_22 GND 16.0
C_1_35_22 Node1_35_22 GND 3.6093750000000004e-07
R_1_35_23_1 Node1_35_23 Node1_35_24 250.00000000000003
R_1_35_23_2 Node1_35_23 Node1_36_23 250.00000000000003
R_1_35_23_3 Node1_35_23 GND 16.0
C_1_35_23 Node1_35_23 GND 3.6093750000000004e-07
R_1_35_24_1 Node1_35_24 Node1_35_25 250.00000000000003
R_1_35_24_2 Node1_35_24 Node1_36_24 250.00000000000003
R_1_35_24_3 Node1_35_24 GND 16.0
C_1_35_24 Node1_35_24 GND 3.6093750000000004e-07
R_1_35_25_1 Node1_35_25 Node1_35_26 250.00000000000003
R_1_35_25_2 Node1_35_25 Node1_36_25 250.00000000000003
R_1_35_25_3 Node1_35_25 GND 16.0
C_1_35_25 Node1_35_25 GND 3.6093750000000004e-07
R_1_35_26_1 Node1_35_26 Node1_35_27 250.00000000000003
R_1_35_26_2 Node1_35_26 Node1_36_26 250.00000000000003
R_1_35_26_3 Node1_35_26 GND 16.0
C_1_35_26 Node1_35_26 GND 3.6093750000000004e-07
R_1_35_27_1 Node1_35_27 Node1_35_28 250.00000000000003
R_1_35_27_2 Node1_35_27 Node1_36_27 250.00000000000003
R_1_35_27_3 Node1_35_27 GND 16.0
C_1_35_27 Node1_35_27 GND 3.6093750000000004e-07
R_1_35_28_1 Node1_35_28 Node1_35_29 250.00000000000003
R_1_35_28_2 Node1_35_28 Node1_36_28 250.00000000000003
R_1_35_28_3 Node1_35_28 GND 16.0
C_1_35_28 Node1_35_28 GND 3.6093750000000004e-07
R_1_35_29_1 Node1_35_29 Node1_35_30 250.00000000000003
R_1_35_29_2 Node1_35_29 Node1_36_29 250.00000000000003
R_1_35_29_3 Node1_35_29 GND 16.0
C_1_35_29 Node1_35_29 GND 3.6093750000000004e-07
R_1_35_30_1 Node1_35_30 Node1_35_31 250.00000000000003
R_1_35_30_2 Node1_35_30 Node1_36_30 250.00000000000003
R_1_35_30_3 Node1_35_30 GND 16.0
C_1_35_30 Node1_35_30 GND 3.6093750000000004e-07
R_1_35_31_1 Node1_35_31 Node1_35_32 250.00000000000003
R_1_35_31_2 Node1_35_31 Node1_36_31 250.00000000000003
R_1_35_31_3 Node1_35_31 GND 16.0
C_1_35_31 Node1_35_31 GND 3.6093750000000004e-07
R_1_35_32_1 Node1_35_32 Node1_35_33 250.00000000000003
R_1_35_32_2 Node1_35_32 Node1_36_32 250.00000000000003
R_1_35_32_3 Node1_35_32 GND 16.0
C_1_35_32 Node1_35_32 GND 3.6093750000000004e-07
R_1_35_33_1 Node1_35_33 Node1_35_34 250.00000000000003
R_1_35_33_2 Node1_35_33 Node1_36_33 250.00000000000003
R_1_35_33_3 Node1_35_33 GND 16.0
C_1_35_33 Node1_35_33 GND 3.6093750000000004e-07
R_1_35_34_1 Node1_35_34 Node1_35_35 250.00000000000003
R_1_35_34_2 Node1_35_34 Node1_36_34 250.00000000000003
R_1_35_34_3 Node1_35_34 GND 16.0
C_1_35_34 Node1_35_34 GND 3.6093750000000004e-07
R_1_35_35_1 Node1_35_35 Node1_35_36 250.00000000000003
R_1_35_35_2 Node1_35_35 Node1_36_35 250.00000000000003
R_1_35_35_3 Node1_35_35 GND 16.0
C_1_35_35 Node1_35_35 GND 3.6093750000000004e-07
R_1_35_36_1 Node1_35_36 Node1_35_37 250.00000000000003
R_1_35_36_2 Node1_35_36 Node1_36_36 250.00000000000003
R_1_35_36_3 Node1_35_36 GND 16.0
C_1_35_36 Node1_35_36 GND 3.6093750000000004e-07
R_1_35_37_1 Node1_35_37 Node1_35_38 250.00000000000003
R_1_35_37_2 Node1_35_37 Node1_36_37 250.00000000000003
R_1_35_37_3 Node1_35_37 GND 16.0
C_1_35_37 Node1_35_37 GND 3.6093750000000004e-07
R_1_35_38_1 Node1_35_38 Node1_35_39 250.00000000000003
R_1_35_38_2 Node1_35_38 Node1_36_38 250.00000000000003
R_1_35_38_3 Node1_35_38 GND 16.0
C_1_35_38 Node1_35_38 GND 3.6093750000000004e-07
R_1_35_39_2 Node1_35_39 Node1_36_39 250.00000000000003
R_1_35_39_3 Node1_35_39 GND 16.0
C_1_35_39 Node1_35_39 GND 3.6093750000000004e-07
R_1_36_0_1 Node1_36_0 Node1_36_1 250.00000000000003
R_1_36_0_2 Node1_36_0 Node1_37_0 250.00000000000003
R_1_36_0_3 Node1_36_0 GND 16.0
C_1_36_0 Node1_36_0 GND 3.6093750000000004e-07
R_1_36_1_1 Node1_36_1 Node1_36_2 250.00000000000003
R_1_36_1_2 Node1_36_1 Node1_37_1 250.00000000000003
R_1_36_1_3 Node1_36_1 GND 16.0
C_1_36_1 Node1_36_1 GND 3.6093750000000004e-07
R_1_36_2_1 Node1_36_2 Node1_36_3 250.00000000000003
R_1_36_2_2 Node1_36_2 Node1_37_2 250.00000000000003
R_1_36_2_3 Node1_36_2 GND 16.0
C_1_36_2 Node1_36_2 GND 3.6093750000000004e-07
R_1_36_3_1 Node1_36_3 Node1_36_4 250.00000000000003
R_1_36_3_2 Node1_36_3 Node1_37_3 250.00000000000003
R_1_36_3_3 Node1_36_3 GND 16.0
C_1_36_3 Node1_36_3 GND 3.6093750000000004e-07
R_1_36_4_1 Node1_36_4 Node1_36_5 250.00000000000003
R_1_36_4_2 Node1_36_4 Node1_37_4 250.00000000000003
R_1_36_4_3 Node1_36_4 GND 16.0
C_1_36_4 Node1_36_4 GND 3.6093750000000004e-07
R_1_36_5_1 Node1_36_5 Node1_36_6 250.00000000000003
R_1_36_5_2 Node1_36_5 Node1_37_5 250.00000000000003
R_1_36_5_3 Node1_36_5 GND 16.0
C_1_36_5 Node1_36_5 GND 3.6093750000000004e-07
R_1_36_6_1 Node1_36_6 Node1_36_7 250.00000000000003
R_1_36_6_2 Node1_36_6 Node1_37_6 250.00000000000003
R_1_36_6_3 Node1_36_6 GND 16.0
C_1_36_6 Node1_36_6 GND 3.6093750000000004e-07
R_1_36_7_1 Node1_36_7 Node1_36_8 250.00000000000003
R_1_36_7_2 Node1_36_7 Node1_37_7 250.00000000000003
R_1_36_7_3 Node1_36_7 GND 16.0
C_1_36_7 Node1_36_7 GND 3.6093750000000004e-07
R_1_36_8_1 Node1_36_8 Node1_36_9 250.00000000000003
R_1_36_8_2 Node1_36_8 Node1_37_8 250.00000000000003
R_1_36_8_3 Node1_36_8 GND 16.0
C_1_36_8 Node1_36_8 GND 3.6093750000000004e-07
R_1_36_9_1 Node1_36_9 Node1_36_10 250.00000000000003
R_1_36_9_2 Node1_36_9 Node1_37_9 250.00000000000003
R_1_36_9_3 Node1_36_9 GND 16.0
C_1_36_9 Node1_36_9 GND 3.6093750000000004e-07
R_1_36_10_1 Node1_36_10 Node1_36_11 250.00000000000003
R_1_36_10_2 Node1_36_10 Node1_37_10 250.00000000000003
R_1_36_10_3 Node1_36_10 GND 16.0
C_1_36_10 Node1_36_10 GND 3.6093750000000004e-07
R_1_36_11_1 Node1_36_11 Node1_36_12 250.00000000000003
R_1_36_11_2 Node1_36_11 Node1_37_11 250.00000000000003
R_1_36_11_3 Node1_36_11 GND 16.0
C_1_36_11 Node1_36_11 GND 3.6093750000000004e-07
R_1_36_12_1 Node1_36_12 Node1_36_13 250.00000000000003
R_1_36_12_2 Node1_36_12 Node1_37_12 250.00000000000003
R_1_36_12_3 Node1_36_12 GND 16.0
C_1_36_12 Node1_36_12 GND 3.6093750000000004e-07
R_1_36_13_1 Node1_36_13 Node1_36_14 250.00000000000003
R_1_36_13_2 Node1_36_13 Node1_37_13 250.00000000000003
R_1_36_13_3 Node1_36_13 GND 16.0
C_1_36_13 Node1_36_13 GND 3.6093750000000004e-07
R_1_36_14_1 Node1_36_14 Node1_36_15 250.00000000000003
R_1_36_14_2 Node1_36_14 Node1_37_14 250.00000000000003
R_1_36_14_3 Node1_36_14 GND 16.0
C_1_36_14 Node1_36_14 GND 3.6093750000000004e-07
R_1_36_15_1 Node1_36_15 Node1_36_16 250.00000000000003
R_1_36_15_2 Node1_36_15 Node1_37_15 250.00000000000003
R_1_36_15_3 Node1_36_15 GND 16.0
C_1_36_15 Node1_36_15 GND 3.6093750000000004e-07
R_1_36_16_1 Node1_36_16 Node1_36_17 250.00000000000003
R_1_36_16_2 Node1_36_16 Node1_37_16 250.00000000000003
R_1_36_16_3 Node1_36_16 GND 16.0
C_1_36_16 Node1_36_16 GND 3.6093750000000004e-07
R_1_36_17_1 Node1_36_17 Node1_36_18 250.00000000000003
R_1_36_17_2 Node1_36_17 Node1_37_17 250.00000000000003
R_1_36_17_3 Node1_36_17 GND 16.0
C_1_36_17 Node1_36_17 GND 3.6093750000000004e-07
R_1_36_18_1 Node1_36_18 Node1_36_19 250.00000000000003
R_1_36_18_2 Node1_36_18 Node1_37_18 250.00000000000003
R_1_36_18_3 Node1_36_18 GND 16.0
C_1_36_18 Node1_36_18 GND 3.6093750000000004e-07
R_1_36_19_1 Node1_36_19 Node1_36_20 250.00000000000003
R_1_36_19_2 Node1_36_19 Node1_37_19 250.00000000000003
R_1_36_19_3 Node1_36_19 GND 16.0
C_1_36_19 Node1_36_19 GND 3.6093750000000004e-07
R_1_36_20_1 Node1_36_20 Node1_36_21 250.00000000000003
R_1_36_20_2 Node1_36_20 Node1_37_20 250.00000000000003
R_1_36_20_3 Node1_36_20 GND 16.0
C_1_36_20 Node1_36_20 GND 3.6093750000000004e-07
R_1_36_21_1 Node1_36_21 Node1_36_22 250.00000000000003
R_1_36_21_2 Node1_36_21 Node1_37_21 250.00000000000003
R_1_36_21_3 Node1_36_21 GND 16.0
C_1_36_21 Node1_36_21 GND 3.6093750000000004e-07
R_1_36_22_1 Node1_36_22 Node1_36_23 250.00000000000003
R_1_36_22_2 Node1_36_22 Node1_37_22 250.00000000000003
R_1_36_22_3 Node1_36_22 GND 16.0
C_1_36_22 Node1_36_22 GND 3.6093750000000004e-07
R_1_36_23_1 Node1_36_23 Node1_36_24 250.00000000000003
R_1_36_23_2 Node1_36_23 Node1_37_23 250.00000000000003
R_1_36_23_3 Node1_36_23 GND 16.0
C_1_36_23 Node1_36_23 GND 3.6093750000000004e-07
R_1_36_24_1 Node1_36_24 Node1_36_25 250.00000000000003
R_1_36_24_2 Node1_36_24 Node1_37_24 250.00000000000003
R_1_36_24_3 Node1_36_24 GND 16.0
C_1_36_24 Node1_36_24 GND 3.6093750000000004e-07
R_1_36_25_1 Node1_36_25 Node1_36_26 250.00000000000003
R_1_36_25_2 Node1_36_25 Node1_37_25 250.00000000000003
R_1_36_25_3 Node1_36_25 GND 16.0
C_1_36_25 Node1_36_25 GND 3.6093750000000004e-07
R_1_36_26_1 Node1_36_26 Node1_36_27 250.00000000000003
R_1_36_26_2 Node1_36_26 Node1_37_26 250.00000000000003
R_1_36_26_3 Node1_36_26 GND 16.0
C_1_36_26 Node1_36_26 GND 3.6093750000000004e-07
R_1_36_27_1 Node1_36_27 Node1_36_28 250.00000000000003
R_1_36_27_2 Node1_36_27 Node1_37_27 250.00000000000003
R_1_36_27_3 Node1_36_27 GND 16.0
C_1_36_27 Node1_36_27 GND 3.6093750000000004e-07
R_1_36_28_1 Node1_36_28 Node1_36_29 250.00000000000003
R_1_36_28_2 Node1_36_28 Node1_37_28 250.00000000000003
R_1_36_28_3 Node1_36_28 GND 16.0
C_1_36_28 Node1_36_28 GND 3.6093750000000004e-07
R_1_36_29_1 Node1_36_29 Node1_36_30 250.00000000000003
R_1_36_29_2 Node1_36_29 Node1_37_29 250.00000000000003
R_1_36_29_3 Node1_36_29 GND 16.0
C_1_36_29 Node1_36_29 GND 3.6093750000000004e-07
R_1_36_30_1 Node1_36_30 Node1_36_31 250.00000000000003
R_1_36_30_2 Node1_36_30 Node1_37_30 250.00000000000003
R_1_36_30_3 Node1_36_30 GND 16.0
C_1_36_30 Node1_36_30 GND 3.6093750000000004e-07
R_1_36_31_1 Node1_36_31 Node1_36_32 250.00000000000003
R_1_36_31_2 Node1_36_31 Node1_37_31 250.00000000000003
R_1_36_31_3 Node1_36_31 GND 16.0
C_1_36_31 Node1_36_31 GND 3.6093750000000004e-07
R_1_36_32_1 Node1_36_32 Node1_36_33 250.00000000000003
R_1_36_32_2 Node1_36_32 Node1_37_32 250.00000000000003
R_1_36_32_3 Node1_36_32 GND 16.0
C_1_36_32 Node1_36_32 GND 3.6093750000000004e-07
R_1_36_33_1 Node1_36_33 Node1_36_34 250.00000000000003
R_1_36_33_2 Node1_36_33 Node1_37_33 250.00000000000003
R_1_36_33_3 Node1_36_33 GND 16.0
C_1_36_33 Node1_36_33 GND 3.6093750000000004e-07
R_1_36_34_1 Node1_36_34 Node1_36_35 250.00000000000003
R_1_36_34_2 Node1_36_34 Node1_37_34 250.00000000000003
R_1_36_34_3 Node1_36_34 GND 16.0
C_1_36_34 Node1_36_34 GND 3.6093750000000004e-07
R_1_36_35_1 Node1_36_35 Node1_36_36 250.00000000000003
R_1_36_35_2 Node1_36_35 Node1_37_35 250.00000000000003
R_1_36_35_3 Node1_36_35 GND 16.0
C_1_36_35 Node1_36_35 GND 3.6093750000000004e-07
R_1_36_36_1 Node1_36_36 Node1_36_37 250.00000000000003
R_1_36_36_2 Node1_36_36 Node1_37_36 250.00000000000003
R_1_36_36_3 Node1_36_36 GND 16.0
C_1_36_36 Node1_36_36 GND 3.6093750000000004e-07
R_1_36_37_1 Node1_36_37 Node1_36_38 250.00000000000003
R_1_36_37_2 Node1_36_37 Node1_37_37 250.00000000000003
R_1_36_37_3 Node1_36_37 GND 16.0
C_1_36_37 Node1_36_37 GND 3.6093750000000004e-07
R_1_36_38_1 Node1_36_38 Node1_36_39 250.00000000000003
R_1_36_38_2 Node1_36_38 Node1_37_38 250.00000000000003
R_1_36_38_3 Node1_36_38 GND 16.0
C_1_36_38 Node1_36_38 GND 3.6093750000000004e-07
R_1_36_39_2 Node1_36_39 Node1_37_39 250.00000000000003
R_1_36_39_3 Node1_36_39 GND 16.0
C_1_36_39 Node1_36_39 GND 3.6093750000000004e-07
R_1_37_0_1 Node1_37_0 Node1_37_1 250.00000000000003
R_1_37_0_2 Node1_37_0 Node1_38_0 250.00000000000003
R_1_37_0_3 Node1_37_0 GND 16.0
C_1_37_0 Node1_37_0 GND 3.6093750000000004e-07
R_1_37_1_1 Node1_37_1 Node1_37_2 250.00000000000003
R_1_37_1_2 Node1_37_1 Node1_38_1 250.00000000000003
R_1_37_1_3 Node1_37_1 GND 16.0
C_1_37_1 Node1_37_1 GND 3.6093750000000004e-07
R_1_37_2_1 Node1_37_2 Node1_37_3 250.00000000000003
R_1_37_2_2 Node1_37_2 Node1_38_2 250.00000000000003
R_1_37_2_3 Node1_37_2 GND 16.0
C_1_37_2 Node1_37_2 GND 3.6093750000000004e-07
R_1_37_3_1 Node1_37_3 Node1_37_4 250.00000000000003
R_1_37_3_2 Node1_37_3 Node1_38_3 250.00000000000003
R_1_37_3_3 Node1_37_3 GND 16.0
C_1_37_3 Node1_37_3 GND 3.6093750000000004e-07
R_1_37_4_1 Node1_37_4 Node1_37_5 250.00000000000003
R_1_37_4_2 Node1_37_4 Node1_38_4 250.00000000000003
R_1_37_4_3 Node1_37_4 GND 16.0
C_1_37_4 Node1_37_4 GND 3.6093750000000004e-07
R_1_37_5_1 Node1_37_5 Node1_37_6 250.00000000000003
R_1_37_5_2 Node1_37_5 Node1_38_5 250.00000000000003
R_1_37_5_3 Node1_37_5 GND 16.0
C_1_37_5 Node1_37_5 GND 3.6093750000000004e-07
R_1_37_6_1 Node1_37_6 Node1_37_7 250.00000000000003
R_1_37_6_2 Node1_37_6 Node1_38_6 250.00000000000003
R_1_37_6_3 Node1_37_6 GND 16.0
C_1_37_6 Node1_37_6 GND 3.6093750000000004e-07
R_1_37_7_1 Node1_37_7 Node1_37_8 250.00000000000003
R_1_37_7_2 Node1_37_7 Node1_38_7 250.00000000000003
R_1_37_7_3 Node1_37_7 GND 16.0
C_1_37_7 Node1_37_7 GND 3.6093750000000004e-07
R_1_37_8_1 Node1_37_8 Node1_37_9 250.00000000000003
R_1_37_8_2 Node1_37_8 Node1_38_8 250.00000000000003
R_1_37_8_3 Node1_37_8 GND 16.0
C_1_37_8 Node1_37_8 GND 3.6093750000000004e-07
R_1_37_9_1 Node1_37_9 Node1_37_10 250.00000000000003
R_1_37_9_2 Node1_37_9 Node1_38_9 250.00000000000003
R_1_37_9_3 Node1_37_9 GND 16.0
C_1_37_9 Node1_37_9 GND 3.6093750000000004e-07
R_1_37_10_1 Node1_37_10 Node1_37_11 250.00000000000003
R_1_37_10_2 Node1_37_10 Node1_38_10 250.00000000000003
R_1_37_10_3 Node1_37_10 GND 16.0
C_1_37_10 Node1_37_10 GND 3.6093750000000004e-07
R_1_37_11_1 Node1_37_11 Node1_37_12 250.00000000000003
R_1_37_11_2 Node1_37_11 Node1_38_11 250.00000000000003
R_1_37_11_3 Node1_37_11 GND 16.0
C_1_37_11 Node1_37_11 GND 3.6093750000000004e-07
R_1_37_12_1 Node1_37_12 Node1_37_13 250.00000000000003
R_1_37_12_2 Node1_37_12 Node1_38_12 250.00000000000003
R_1_37_12_3 Node1_37_12 GND 16.0
C_1_37_12 Node1_37_12 GND 3.6093750000000004e-07
R_1_37_13_1 Node1_37_13 Node1_37_14 250.00000000000003
R_1_37_13_2 Node1_37_13 Node1_38_13 250.00000000000003
R_1_37_13_3 Node1_37_13 GND 16.0
C_1_37_13 Node1_37_13 GND 3.6093750000000004e-07
R_1_37_14_1 Node1_37_14 Node1_37_15 250.00000000000003
R_1_37_14_2 Node1_37_14 Node1_38_14 250.00000000000003
R_1_37_14_3 Node1_37_14 GND 16.0
C_1_37_14 Node1_37_14 GND 3.6093750000000004e-07
R_1_37_15_1 Node1_37_15 Node1_37_16 250.00000000000003
R_1_37_15_2 Node1_37_15 Node1_38_15 250.00000000000003
R_1_37_15_3 Node1_37_15 GND 16.0
C_1_37_15 Node1_37_15 GND 3.6093750000000004e-07
R_1_37_16_1 Node1_37_16 Node1_37_17 250.00000000000003
R_1_37_16_2 Node1_37_16 Node1_38_16 250.00000000000003
R_1_37_16_3 Node1_37_16 GND 16.0
C_1_37_16 Node1_37_16 GND 3.6093750000000004e-07
R_1_37_17_1 Node1_37_17 Node1_37_18 250.00000000000003
R_1_37_17_2 Node1_37_17 Node1_38_17 250.00000000000003
R_1_37_17_3 Node1_37_17 GND 16.0
C_1_37_17 Node1_37_17 GND 3.6093750000000004e-07
R_1_37_18_1 Node1_37_18 Node1_37_19 250.00000000000003
R_1_37_18_2 Node1_37_18 Node1_38_18 250.00000000000003
R_1_37_18_3 Node1_37_18 GND 16.0
C_1_37_18 Node1_37_18 GND 3.6093750000000004e-07
R_1_37_19_1 Node1_37_19 Node1_37_20 250.00000000000003
R_1_37_19_2 Node1_37_19 Node1_38_19 250.00000000000003
R_1_37_19_3 Node1_37_19 GND 16.0
C_1_37_19 Node1_37_19 GND 3.6093750000000004e-07
R_1_37_20_1 Node1_37_20 Node1_37_21 250.00000000000003
R_1_37_20_2 Node1_37_20 Node1_38_20 250.00000000000003
R_1_37_20_3 Node1_37_20 GND 16.0
C_1_37_20 Node1_37_20 GND 3.6093750000000004e-07
R_1_37_21_1 Node1_37_21 Node1_37_22 250.00000000000003
R_1_37_21_2 Node1_37_21 Node1_38_21 250.00000000000003
R_1_37_21_3 Node1_37_21 GND 16.0
C_1_37_21 Node1_37_21 GND 3.6093750000000004e-07
R_1_37_22_1 Node1_37_22 Node1_37_23 250.00000000000003
R_1_37_22_2 Node1_37_22 Node1_38_22 250.00000000000003
R_1_37_22_3 Node1_37_22 GND 16.0
C_1_37_22 Node1_37_22 GND 3.6093750000000004e-07
R_1_37_23_1 Node1_37_23 Node1_37_24 250.00000000000003
R_1_37_23_2 Node1_37_23 Node1_38_23 250.00000000000003
R_1_37_23_3 Node1_37_23 GND 16.0
C_1_37_23 Node1_37_23 GND 3.6093750000000004e-07
R_1_37_24_1 Node1_37_24 Node1_37_25 250.00000000000003
R_1_37_24_2 Node1_37_24 Node1_38_24 250.00000000000003
R_1_37_24_3 Node1_37_24 GND 16.0
C_1_37_24 Node1_37_24 GND 3.6093750000000004e-07
R_1_37_25_1 Node1_37_25 Node1_37_26 250.00000000000003
R_1_37_25_2 Node1_37_25 Node1_38_25 250.00000000000003
R_1_37_25_3 Node1_37_25 GND 16.0
C_1_37_25 Node1_37_25 GND 3.6093750000000004e-07
R_1_37_26_1 Node1_37_26 Node1_37_27 250.00000000000003
R_1_37_26_2 Node1_37_26 Node1_38_26 250.00000000000003
R_1_37_26_3 Node1_37_26 GND 16.0
C_1_37_26 Node1_37_26 GND 3.6093750000000004e-07
R_1_37_27_1 Node1_37_27 Node1_37_28 250.00000000000003
R_1_37_27_2 Node1_37_27 Node1_38_27 250.00000000000003
R_1_37_27_3 Node1_37_27 GND 16.0
C_1_37_27 Node1_37_27 GND 3.6093750000000004e-07
R_1_37_28_1 Node1_37_28 Node1_37_29 250.00000000000003
R_1_37_28_2 Node1_37_28 Node1_38_28 250.00000000000003
R_1_37_28_3 Node1_37_28 GND 16.0
C_1_37_28 Node1_37_28 GND 3.6093750000000004e-07
R_1_37_29_1 Node1_37_29 Node1_37_30 250.00000000000003
R_1_37_29_2 Node1_37_29 Node1_38_29 250.00000000000003
R_1_37_29_3 Node1_37_29 GND 16.0
C_1_37_29 Node1_37_29 GND 3.6093750000000004e-07
R_1_37_30_1 Node1_37_30 Node1_37_31 250.00000000000003
R_1_37_30_2 Node1_37_30 Node1_38_30 250.00000000000003
R_1_37_30_3 Node1_37_30 GND 16.0
C_1_37_30 Node1_37_30 GND 3.6093750000000004e-07
R_1_37_31_1 Node1_37_31 Node1_37_32 250.00000000000003
R_1_37_31_2 Node1_37_31 Node1_38_31 250.00000000000003
R_1_37_31_3 Node1_37_31 GND 16.0
C_1_37_31 Node1_37_31 GND 3.6093750000000004e-07
R_1_37_32_1 Node1_37_32 Node1_37_33 250.00000000000003
R_1_37_32_2 Node1_37_32 Node1_38_32 250.00000000000003
R_1_37_32_3 Node1_37_32 GND 16.0
C_1_37_32 Node1_37_32 GND 3.6093750000000004e-07
R_1_37_33_1 Node1_37_33 Node1_37_34 250.00000000000003
R_1_37_33_2 Node1_37_33 Node1_38_33 250.00000000000003
R_1_37_33_3 Node1_37_33 GND 16.0
C_1_37_33 Node1_37_33 GND 3.6093750000000004e-07
R_1_37_34_1 Node1_37_34 Node1_37_35 250.00000000000003
R_1_37_34_2 Node1_37_34 Node1_38_34 250.00000000000003
R_1_37_34_3 Node1_37_34 GND 16.0
C_1_37_34 Node1_37_34 GND 3.6093750000000004e-07
R_1_37_35_1 Node1_37_35 Node1_37_36 250.00000000000003
R_1_37_35_2 Node1_37_35 Node1_38_35 250.00000000000003
R_1_37_35_3 Node1_37_35 GND 16.0
C_1_37_35 Node1_37_35 GND 3.6093750000000004e-07
R_1_37_36_1 Node1_37_36 Node1_37_37 250.00000000000003
R_1_37_36_2 Node1_37_36 Node1_38_36 250.00000000000003
R_1_37_36_3 Node1_37_36 GND 16.0
C_1_37_36 Node1_37_36 GND 3.6093750000000004e-07
R_1_37_37_1 Node1_37_37 Node1_37_38 250.00000000000003
R_1_37_37_2 Node1_37_37 Node1_38_37 250.00000000000003
R_1_37_37_3 Node1_37_37 GND 16.0
C_1_37_37 Node1_37_37 GND 3.6093750000000004e-07
R_1_37_38_1 Node1_37_38 Node1_37_39 250.00000000000003
R_1_37_38_2 Node1_37_38 Node1_38_38 250.00000000000003
R_1_37_38_3 Node1_37_38 GND 16.0
C_1_37_38 Node1_37_38 GND 3.6093750000000004e-07
R_1_37_39_2 Node1_37_39 Node1_38_39 250.00000000000003
R_1_37_39_3 Node1_37_39 GND 16.0
C_1_37_39 Node1_37_39 GND 3.6093750000000004e-07
R_1_38_0_1 Node1_38_0 Node1_38_1 250.00000000000003
R_1_38_0_2 Node1_38_0 Node1_39_0 250.00000000000003
R_1_38_0_3 Node1_38_0 GND 16.0
C_1_38_0 Node1_38_0 GND 3.6093750000000004e-07
R_1_38_1_1 Node1_38_1 Node1_38_2 250.00000000000003
R_1_38_1_2 Node1_38_1 Node1_39_1 250.00000000000003
R_1_38_1_3 Node1_38_1 GND 16.0
C_1_38_1 Node1_38_1 GND 3.6093750000000004e-07
R_1_38_2_1 Node1_38_2 Node1_38_3 250.00000000000003
R_1_38_2_2 Node1_38_2 Node1_39_2 250.00000000000003
R_1_38_2_3 Node1_38_2 GND 16.0
C_1_38_2 Node1_38_2 GND 3.6093750000000004e-07
R_1_38_3_1 Node1_38_3 Node1_38_4 250.00000000000003
R_1_38_3_2 Node1_38_3 Node1_39_3 250.00000000000003
R_1_38_3_3 Node1_38_3 GND 16.0
C_1_38_3 Node1_38_3 GND 3.6093750000000004e-07
R_1_38_4_1 Node1_38_4 Node1_38_5 250.00000000000003
R_1_38_4_2 Node1_38_4 Node1_39_4 250.00000000000003
R_1_38_4_3 Node1_38_4 GND 16.0
C_1_38_4 Node1_38_4 GND 3.6093750000000004e-07
R_1_38_5_1 Node1_38_5 Node1_38_6 250.00000000000003
R_1_38_5_2 Node1_38_5 Node1_39_5 250.00000000000003
R_1_38_5_3 Node1_38_5 GND 16.0
C_1_38_5 Node1_38_5 GND 3.6093750000000004e-07
R_1_38_6_1 Node1_38_6 Node1_38_7 250.00000000000003
R_1_38_6_2 Node1_38_6 Node1_39_6 250.00000000000003
R_1_38_6_3 Node1_38_6 GND 16.0
C_1_38_6 Node1_38_6 GND 3.6093750000000004e-07
R_1_38_7_1 Node1_38_7 Node1_38_8 250.00000000000003
R_1_38_7_2 Node1_38_7 Node1_39_7 250.00000000000003
R_1_38_7_3 Node1_38_7 GND 16.0
C_1_38_7 Node1_38_7 GND 3.6093750000000004e-07
R_1_38_8_1 Node1_38_8 Node1_38_9 250.00000000000003
R_1_38_8_2 Node1_38_8 Node1_39_8 250.00000000000003
R_1_38_8_3 Node1_38_8 GND 16.0
C_1_38_8 Node1_38_8 GND 3.6093750000000004e-07
R_1_38_9_1 Node1_38_9 Node1_38_10 250.00000000000003
R_1_38_9_2 Node1_38_9 Node1_39_9 250.00000000000003
R_1_38_9_3 Node1_38_9 GND 16.0
C_1_38_9 Node1_38_9 GND 3.6093750000000004e-07
R_1_38_10_1 Node1_38_10 Node1_38_11 250.00000000000003
R_1_38_10_2 Node1_38_10 Node1_39_10 250.00000000000003
R_1_38_10_3 Node1_38_10 GND 16.0
C_1_38_10 Node1_38_10 GND 3.6093750000000004e-07
R_1_38_11_1 Node1_38_11 Node1_38_12 250.00000000000003
R_1_38_11_2 Node1_38_11 Node1_39_11 250.00000000000003
R_1_38_11_3 Node1_38_11 GND 16.0
C_1_38_11 Node1_38_11 GND 3.6093750000000004e-07
R_1_38_12_1 Node1_38_12 Node1_38_13 250.00000000000003
R_1_38_12_2 Node1_38_12 Node1_39_12 250.00000000000003
R_1_38_12_3 Node1_38_12 GND 16.0
C_1_38_12 Node1_38_12 GND 3.6093750000000004e-07
R_1_38_13_1 Node1_38_13 Node1_38_14 250.00000000000003
R_1_38_13_2 Node1_38_13 Node1_39_13 250.00000000000003
R_1_38_13_3 Node1_38_13 GND 16.0
C_1_38_13 Node1_38_13 GND 3.6093750000000004e-07
R_1_38_14_1 Node1_38_14 Node1_38_15 250.00000000000003
R_1_38_14_2 Node1_38_14 Node1_39_14 250.00000000000003
R_1_38_14_3 Node1_38_14 GND 16.0
C_1_38_14 Node1_38_14 GND 3.6093750000000004e-07
R_1_38_15_1 Node1_38_15 Node1_38_16 250.00000000000003
R_1_38_15_2 Node1_38_15 Node1_39_15 250.00000000000003
R_1_38_15_3 Node1_38_15 GND 16.0
C_1_38_15 Node1_38_15 GND 3.6093750000000004e-07
R_1_38_16_1 Node1_38_16 Node1_38_17 250.00000000000003
R_1_38_16_2 Node1_38_16 Node1_39_16 250.00000000000003
R_1_38_16_3 Node1_38_16 GND 16.0
C_1_38_16 Node1_38_16 GND 3.6093750000000004e-07
R_1_38_17_1 Node1_38_17 Node1_38_18 250.00000000000003
R_1_38_17_2 Node1_38_17 Node1_39_17 250.00000000000003
R_1_38_17_3 Node1_38_17 GND 16.0
C_1_38_17 Node1_38_17 GND 3.6093750000000004e-07
R_1_38_18_1 Node1_38_18 Node1_38_19 250.00000000000003
R_1_38_18_2 Node1_38_18 Node1_39_18 250.00000000000003
R_1_38_18_3 Node1_38_18 GND 16.0
C_1_38_18 Node1_38_18 GND 3.6093750000000004e-07
R_1_38_19_1 Node1_38_19 Node1_38_20 250.00000000000003
R_1_38_19_2 Node1_38_19 Node1_39_19 250.00000000000003
R_1_38_19_3 Node1_38_19 GND 16.0
C_1_38_19 Node1_38_19 GND 3.6093750000000004e-07
R_1_38_20_1 Node1_38_20 Node1_38_21 250.00000000000003
R_1_38_20_2 Node1_38_20 Node1_39_20 250.00000000000003
R_1_38_20_3 Node1_38_20 GND 16.0
C_1_38_20 Node1_38_20 GND 3.6093750000000004e-07
R_1_38_21_1 Node1_38_21 Node1_38_22 250.00000000000003
R_1_38_21_2 Node1_38_21 Node1_39_21 250.00000000000003
R_1_38_21_3 Node1_38_21 GND 16.0
C_1_38_21 Node1_38_21 GND 3.6093750000000004e-07
R_1_38_22_1 Node1_38_22 Node1_38_23 250.00000000000003
R_1_38_22_2 Node1_38_22 Node1_39_22 250.00000000000003
R_1_38_22_3 Node1_38_22 GND 16.0
C_1_38_22 Node1_38_22 GND 3.6093750000000004e-07
R_1_38_23_1 Node1_38_23 Node1_38_24 250.00000000000003
R_1_38_23_2 Node1_38_23 Node1_39_23 250.00000000000003
R_1_38_23_3 Node1_38_23 GND 16.0
C_1_38_23 Node1_38_23 GND 3.6093750000000004e-07
R_1_38_24_1 Node1_38_24 Node1_38_25 250.00000000000003
R_1_38_24_2 Node1_38_24 Node1_39_24 250.00000000000003
R_1_38_24_3 Node1_38_24 GND 16.0
C_1_38_24 Node1_38_24 GND 3.6093750000000004e-07
R_1_38_25_1 Node1_38_25 Node1_38_26 250.00000000000003
R_1_38_25_2 Node1_38_25 Node1_39_25 250.00000000000003
R_1_38_25_3 Node1_38_25 GND 16.0
C_1_38_25 Node1_38_25 GND 3.6093750000000004e-07
R_1_38_26_1 Node1_38_26 Node1_38_27 250.00000000000003
R_1_38_26_2 Node1_38_26 Node1_39_26 250.00000000000003
R_1_38_26_3 Node1_38_26 GND 16.0
C_1_38_26 Node1_38_26 GND 3.6093750000000004e-07
R_1_38_27_1 Node1_38_27 Node1_38_28 250.00000000000003
R_1_38_27_2 Node1_38_27 Node1_39_27 250.00000000000003
R_1_38_27_3 Node1_38_27 GND 16.0
C_1_38_27 Node1_38_27 GND 3.6093750000000004e-07
R_1_38_28_1 Node1_38_28 Node1_38_29 250.00000000000003
R_1_38_28_2 Node1_38_28 Node1_39_28 250.00000000000003
R_1_38_28_3 Node1_38_28 GND 16.0
C_1_38_28 Node1_38_28 GND 3.6093750000000004e-07
R_1_38_29_1 Node1_38_29 Node1_38_30 250.00000000000003
R_1_38_29_2 Node1_38_29 Node1_39_29 250.00000000000003
R_1_38_29_3 Node1_38_29 GND 16.0
C_1_38_29 Node1_38_29 GND 3.6093750000000004e-07
R_1_38_30_1 Node1_38_30 Node1_38_31 250.00000000000003
R_1_38_30_2 Node1_38_30 Node1_39_30 250.00000000000003
R_1_38_30_3 Node1_38_30 GND 16.0
C_1_38_30 Node1_38_30 GND 3.6093750000000004e-07
R_1_38_31_1 Node1_38_31 Node1_38_32 250.00000000000003
R_1_38_31_2 Node1_38_31 Node1_39_31 250.00000000000003
R_1_38_31_3 Node1_38_31 GND 16.0
C_1_38_31 Node1_38_31 GND 3.6093750000000004e-07
R_1_38_32_1 Node1_38_32 Node1_38_33 250.00000000000003
R_1_38_32_2 Node1_38_32 Node1_39_32 250.00000000000003
R_1_38_32_3 Node1_38_32 GND 16.0
C_1_38_32 Node1_38_32 GND 3.6093750000000004e-07
R_1_38_33_1 Node1_38_33 Node1_38_34 250.00000000000003
R_1_38_33_2 Node1_38_33 Node1_39_33 250.00000000000003
R_1_38_33_3 Node1_38_33 GND 16.0
C_1_38_33 Node1_38_33 GND 3.6093750000000004e-07
R_1_38_34_1 Node1_38_34 Node1_38_35 250.00000000000003
R_1_38_34_2 Node1_38_34 Node1_39_34 250.00000000000003
R_1_38_34_3 Node1_38_34 GND 16.0
C_1_38_34 Node1_38_34 GND 3.6093750000000004e-07
R_1_38_35_1 Node1_38_35 Node1_38_36 250.00000000000003
R_1_38_35_2 Node1_38_35 Node1_39_35 250.00000000000003
R_1_38_35_3 Node1_38_35 GND 16.0
C_1_38_35 Node1_38_35 GND 3.6093750000000004e-07
R_1_38_36_1 Node1_38_36 Node1_38_37 250.00000000000003
R_1_38_36_2 Node1_38_36 Node1_39_36 250.00000000000003
R_1_38_36_3 Node1_38_36 GND 16.0
C_1_38_36 Node1_38_36 GND 3.6093750000000004e-07
R_1_38_37_1 Node1_38_37 Node1_38_38 250.00000000000003
R_1_38_37_2 Node1_38_37 Node1_39_37 250.00000000000003
R_1_38_37_3 Node1_38_37 GND 16.0
C_1_38_37 Node1_38_37 GND 3.6093750000000004e-07
R_1_38_38_1 Node1_38_38 Node1_38_39 250.00000000000003
R_1_38_38_2 Node1_38_38 Node1_39_38 250.00000000000003
R_1_38_38_3 Node1_38_38 GND 16.0
C_1_38_38 Node1_38_38 GND 3.6093750000000004e-07
R_1_38_39_2 Node1_38_39 Node1_39_39 250.00000000000003
R_1_38_39_3 Node1_38_39 GND 16.0
C_1_38_39 Node1_38_39 GND 3.6093750000000004e-07
R_1_39_0_1 Node1_39_0 Node1_39_1 250.00000000000003
R_1_39_0_3 Node1_39_0 GND 16.0
C_1_39_0 Node1_39_0 GND 3.6093750000000004e-07
R_1_39_1_1 Node1_39_1 Node1_39_2 250.00000000000003
R_1_39_1_3 Node1_39_1 GND 16.0
C_1_39_1 Node1_39_1 GND 3.6093750000000004e-07
R_1_39_2_1 Node1_39_2 Node1_39_3 250.00000000000003
R_1_39_2_3 Node1_39_2 GND 16.0
C_1_39_2 Node1_39_2 GND 3.6093750000000004e-07
R_1_39_3_1 Node1_39_3 Node1_39_4 250.00000000000003
R_1_39_3_3 Node1_39_3 GND 16.0
C_1_39_3 Node1_39_3 GND 3.6093750000000004e-07
R_1_39_4_1 Node1_39_4 Node1_39_5 250.00000000000003
R_1_39_4_3 Node1_39_4 GND 16.0
C_1_39_4 Node1_39_4 GND 3.6093750000000004e-07
R_1_39_5_1 Node1_39_5 Node1_39_6 250.00000000000003
R_1_39_5_3 Node1_39_5 GND 16.0
C_1_39_5 Node1_39_5 GND 3.6093750000000004e-07
R_1_39_6_1 Node1_39_6 Node1_39_7 250.00000000000003
R_1_39_6_3 Node1_39_6 GND 16.0
C_1_39_6 Node1_39_6 GND 3.6093750000000004e-07
R_1_39_7_1 Node1_39_7 Node1_39_8 250.00000000000003
R_1_39_7_3 Node1_39_7 GND 16.0
C_1_39_7 Node1_39_7 GND 3.6093750000000004e-07
R_1_39_8_1 Node1_39_8 Node1_39_9 250.00000000000003
R_1_39_8_3 Node1_39_8 GND 16.0
C_1_39_8 Node1_39_8 GND 3.6093750000000004e-07
R_1_39_9_1 Node1_39_9 Node1_39_10 250.00000000000003
R_1_39_9_3 Node1_39_9 GND 16.0
C_1_39_9 Node1_39_9 GND 3.6093750000000004e-07
R_1_39_10_1 Node1_39_10 Node1_39_11 250.00000000000003
R_1_39_10_3 Node1_39_10 GND 16.0
C_1_39_10 Node1_39_10 GND 3.6093750000000004e-07
R_1_39_11_1 Node1_39_11 Node1_39_12 250.00000000000003
R_1_39_11_3 Node1_39_11 GND 16.0
C_1_39_11 Node1_39_11 GND 3.6093750000000004e-07
R_1_39_12_1 Node1_39_12 Node1_39_13 250.00000000000003
R_1_39_12_3 Node1_39_12 GND 16.0
C_1_39_12 Node1_39_12 GND 3.6093750000000004e-07
R_1_39_13_1 Node1_39_13 Node1_39_14 250.00000000000003
R_1_39_13_3 Node1_39_13 GND 16.0
C_1_39_13 Node1_39_13 GND 3.6093750000000004e-07
R_1_39_14_1 Node1_39_14 Node1_39_15 250.00000000000003
R_1_39_14_3 Node1_39_14 GND 16.0
C_1_39_14 Node1_39_14 GND 3.6093750000000004e-07
R_1_39_15_1 Node1_39_15 Node1_39_16 250.00000000000003
R_1_39_15_3 Node1_39_15 GND 16.0
C_1_39_15 Node1_39_15 GND 3.6093750000000004e-07
R_1_39_16_1 Node1_39_16 Node1_39_17 250.00000000000003
R_1_39_16_3 Node1_39_16 GND 16.0
C_1_39_16 Node1_39_16 GND 3.6093750000000004e-07
R_1_39_17_1 Node1_39_17 Node1_39_18 250.00000000000003
R_1_39_17_3 Node1_39_17 GND 16.0
C_1_39_17 Node1_39_17 GND 3.6093750000000004e-07
R_1_39_18_1 Node1_39_18 Node1_39_19 250.00000000000003
R_1_39_18_3 Node1_39_18 GND 16.0
C_1_39_18 Node1_39_18 GND 3.6093750000000004e-07
R_1_39_19_1 Node1_39_19 Node1_39_20 250.00000000000003
R_1_39_19_3 Node1_39_19 GND 16.0
C_1_39_19 Node1_39_19 GND 3.6093750000000004e-07
R_1_39_20_1 Node1_39_20 Node1_39_21 250.00000000000003
R_1_39_20_3 Node1_39_20 GND 16.0
C_1_39_20 Node1_39_20 GND 3.6093750000000004e-07
R_1_39_21_1 Node1_39_21 Node1_39_22 250.00000000000003
R_1_39_21_3 Node1_39_21 GND 16.0
C_1_39_21 Node1_39_21 GND 3.6093750000000004e-07
R_1_39_22_1 Node1_39_22 Node1_39_23 250.00000000000003
R_1_39_22_3 Node1_39_22 GND 16.0
C_1_39_22 Node1_39_22 GND 3.6093750000000004e-07
R_1_39_23_1 Node1_39_23 Node1_39_24 250.00000000000003
R_1_39_23_3 Node1_39_23 GND 16.0
C_1_39_23 Node1_39_23 GND 3.6093750000000004e-07
R_1_39_24_1 Node1_39_24 Node1_39_25 250.00000000000003
R_1_39_24_3 Node1_39_24 GND 16.0
C_1_39_24 Node1_39_24 GND 3.6093750000000004e-07
R_1_39_25_1 Node1_39_25 Node1_39_26 250.00000000000003
R_1_39_25_3 Node1_39_25 GND 16.0
C_1_39_25 Node1_39_25 GND 3.6093750000000004e-07
R_1_39_26_1 Node1_39_26 Node1_39_27 250.00000000000003
R_1_39_26_3 Node1_39_26 GND 16.0
C_1_39_26 Node1_39_26 GND 3.6093750000000004e-07
R_1_39_27_1 Node1_39_27 Node1_39_28 250.00000000000003
R_1_39_27_3 Node1_39_27 GND 16.0
C_1_39_27 Node1_39_27 GND 3.6093750000000004e-07
R_1_39_28_1 Node1_39_28 Node1_39_29 250.00000000000003
R_1_39_28_3 Node1_39_28 GND 16.0
C_1_39_28 Node1_39_28 GND 3.6093750000000004e-07
R_1_39_29_1 Node1_39_29 Node1_39_30 250.00000000000003
R_1_39_29_3 Node1_39_29 GND 16.0
C_1_39_29 Node1_39_29 GND 3.6093750000000004e-07
R_1_39_30_1 Node1_39_30 Node1_39_31 250.00000000000003
R_1_39_30_3 Node1_39_30 GND 16.0
C_1_39_30 Node1_39_30 GND 3.6093750000000004e-07
R_1_39_31_1 Node1_39_31 Node1_39_32 250.00000000000003
R_1_39_31_3 Node1_39_31 GND 16.0
C_1_39_31 Node1_39_31 GND 3.6093750000000004e-07
R_1_39_32_1 Node1_39_32 Node1_39_33 250.00000000000003
R_1_39_32_3 Node1_39_32 GND 16.0
C_1_39_32 Node1_39_32 GND 3.6093750000000004e-07
R_1_39_33_1 Node1_39_33 Node1_39_34 250.00000000000003
R_1_39_33_3 Node1_39_33 GND 16.0
C_1_39_33 Node1_39_33 GND 3.6093750000000004e-07
R_1_39_34_1 Node1_39_34 Node1_39_35 250.00000000000003
R_1_39_34_3 Node1_39_34 GND 16.0
C_1_39_34 Node1_39_34 GND 3.6093750000000004e-07
R_1_39_35_1 Node1_39_35 Node1_39_36 250.00000000000003
R_1_39_35_3 Node1_39_35 GND 16.0
C_1_39_35 Node1_39_35 GND 3.6093750000000004e-07
R_1_39_36_1 Node1_39_36 Node1_39_37 250.00000000000003
R_1_39_36_3 Node1_39_36 GND 16.0
C_1_39_36 Node1_39_36 GND 3.6093750000000004e-07
R_1_39_37_1 Node1_39_37 Node1_39_38 250.00000000000003
R_1_39_37_3 Node1_39_37 GND 16.0
C_1_39_37 Node1_39_37 GND 3.6093750000000004e-07
R_1_39_38_1 Node1_39_38 Node1_39_39 250.00000000000003
R_1_39_38_3 Node1_39_38 GND 16.0
C_1_39_38 Node1_39_38 GND 3.6093750000000004e-07
R_1_39_39_3 Node1_39_39 GND 16.0
C_1_39_39 Node1_39_39 GND 3.6093750000000004e-07
.TRAN 333u 33.3ms
.OPTIONS TIMEINT METHOD=TRAP
.OPTIONS OUTPUT INITIAL_INTERVAL=333us None
.PRINT TRAN FORMAT=CSV PRECISION=4 V(Node0_0_0) V(Node0_0_1) V(Node0_0_2) V(Node0_0_3) V(Node0_0_4) V(Node0_0_5) V(Node0_0_6) V(Node0_0_7) V(Node0_0_8) V(Node0_0_9) V(Node0_0_10) V(Node0_0_11) V(Node0_0_12) V(Node0_0_13) V(Node0_0_14) V(Node0_0_15) V(Node0_0_16) V(Node0_0_17) V(Node0_0_18) V(Node0_0_19) V(Node0_0_20) V(Node0_0_21) V(Node0_0_22) V(Node0_0_23) V(Node0_0_24) V(Node0_0_25) V(Node0_0_26) V(Node0_0_27) V(Node0_0_28) V(Node0_0_29) V(Node0_0_30) V(Node0_0_31) V(Node0_0_32) V(Node0_0_33) V(Node0_0_34) V(Node0_0_35) V(Node0_0_36) V(Node0_0_37) V(Node0_0_38) V(Node0_0_39) V(Node0_1_0) V(Node0_1_1) V(Node0_1_2) V(Node0_1_3) V(Node0_1_4) V(Node0_1_5) V(Node0_1_6) V(Node0_1_7) V(Node0_1_8) V(Node0_1_9) V(Node0_1_10) V(Node0_1_11) V(Node0_1_12) V(Node0_1_13) V(Node0_1_14) V(Node0_1_15) V(Node0_1_16) V(Node0_1_17) V(Node0_1_18) V(Node0_1_19) V(Node0_1_20) V(Node0_1_21) V(Node0_1_22) V(Node0_1_23) V(Node0_1_24) V(Node0_1_25) V(Node0_1_26) V(Node0_1_27) V(Node0_1_28) V(Node0_1_29) V(Node0_1_30) V(Node0_1_31) V(Node0_1_32) V(Node0_1_33) V(Node0_1_34) V(Node0_1_35) V(Node0_1_36) V(Node0_1_37) V(Node0_1_38) V(Node0_1_39) V(Node0_2_0) V(Node0_2_1) V(Node0_2_2) V(Node0_2_3) V(Node0_2_4) V(Node0_2_5) V(Node0_2_6) V(Node0_2_7) V(Node0_2_8) V(Node0_2_9) V(Node0_2_10) V(Node0_2_11) V(Node0_2_12) V(Node0_2_13) V(Node0_2_14) V(Node0_2_15) V(Node0_2_16) V(Node0_2_17) V(Node0_2_18) V(Node0_2_19) V(Node0_2_20) V(Node0_2_21) V(Node0_2_22) V(Node0_2_23) V(Node0_2_24) V(Node0_2_25) V(Node0_2_26) V(Node0_2_27) V(Node0_2_28) V(Node0_2_29) V(Node0_2_30) V(Node0_2_31) V(Node0_2_32) V(Node0_2_33) V(Node0_2_34) V(Node0_2_35) V(Node0_2_36) V(Node0_2_37) V(Node0_2_38) V(Node0_2_39) V(Node0_3_0) V(Node0_3_1) V(Node0_3_2) V(Node0_3_3) V(Node0_3_4) V(Node0_3_5) V(Node0_3_6) V(Node0_3_7) V(Node0_3_8) V(Node0_3_9) V(Node0_3_10) V(Node0_3_11) V(Node0_3_12) V(Node0_3_13) V(Node0_3_14) V(Node0_3_15) V(Node0_3_16) V(Node0_3_17) V(Node0_3_18) V(Node0_3_19) V(Node0_3_20) V(Node0_3_21) V(Node0_3_22) V(Node0_3_23) V(Node0_3_24) V(Node0_3_25) V(Node0_3_26) V(Node0_3_27) V(Node0_3_28) V(Node0_3_29) V(Node0_3_30) V(Node0_3_31) V(Node0_3_32) V(Node0_3_33) V(Node0_3_34) V(Node0_3_35) V(Node0_3_36) V(Node0_3_37) V(Node0_3_38) V(Node0_3_39) V(Node0_4_0) V(Node0_4_1) V(Node0_4_2) V(Node0_4_3) V(Node0_4_4) V(Node0_4_5) V(Node0_4_6) V(Node0_4_7) V(Node0_4_8) V(Node0_4_9) V(Node0_4_10) V(Node0_4_11) V(Node0_4_12) V(Node0_4_13) V(Node0_4_14) V(Node0_4_15) V(Node0_4_16) V(Node0_4_17) V(Node0_4_18) V(Node0_4_19) V(Node0_4_20) V(Node0_4_21) V(Node0_4_22) V(Node0_4_23) V(Node0_4_24) V(Node0_4_25) V(Node0_4_26) V(Node0_4_27) V(Node0_4_28) V(Node0_4_29) V(Node0_4_30) V(Node0_4_31) V(Node0_4_32) V(Node0_4_33) V(Node0_4_34) V(Node0_4_35) V(Node0_4_36) V(Node0_4_37) V(Node0_4_38) V(Node0_4_39) V(Node0_5_0) V(Node0_5_1) V(Node0_5_2) V(Node0_5_3) V(Node0_5_4) V(Node0_5_5) V(Node0_5_6) V(Node0_5_7) V(Node0_5_8) V(Node0_5_9) V(Node0_5_10) V(Node0_5_11) V(Node0_5_12) V(Node0_5_13) V(Node0_5_14) V(Node0_5_15) V(Node0_5_16) V(Node0_5_17) V(Node0_5_18) V(Node0_5_19) V(Node0_5_20) V(Node0_5_21) V(Node0_5_22) V(Node0_5_23) V(Node0_5_24) V(Node0_5_25) V(Node0_5_26) V(Node0_5_27) V(Node0_5_28) V(Node0_5_29) V(Node0_5_30) V(Node0_5_31) V(Node0_5_32) V(Node0_5_33) V(Node0_5_34) V(Node0_5_35) V(Node0_5_36) V(Node0_5_37) V(Node0_5_38) V(Node0_5_39) V(Node0_6_0) V(Node0_6_1) V(Node0_6_2) V(Node0_6_3) V(Node0_6_4) V(Node0_6_5) V(Node0_6_6) V(Node0_6_7) V(Node0_6_8) V(Node0_6_9) V(Node0_6_10) V(Node0_6_11) V(Node0_6_12) V(Node0_6_13) V(Node0_6_14) V(Node0_6_15) V(Node0_6_16) V(Node0_6_17) V(Node0_6_18) V(Node0_6_19) V(Node0_6_20) V(Node0_6_21) V(Node0_6_22) V(Node0_6_23) V(Node0_6_24) V(Node0_6_25) V(Node0_6_26) V(Node0_6_27) V(Node0_6_28) V(Node0_6_29) V(Node0_6_30) V(Node0_6_31) V(Node0_6_32) V(Node0_6_33) V(Node0_6_34) V(Node0_6_35) V(Node0_6_36) V(Node0_6_37) V(Node0_6_38) V(Node0_6_39) V(Node0_7_0) V(Node0_7_1) V(Node0_7_2) V(Node0_7_3) V(Node0_7_4) V(Node0_7_5) V(Node0_7_6) V(Node0_7_7) V(Node0_7_8) V(Node0_7_9) V(Node0_7_10) V(Node0_7_11) V(Node0_7_12) V(Node0_7_13) V(Node0_7_14) V(Node0_7_15) V(Node0_7_16) V(Node0_7_17) V(Node0_7_18) V(Node0_7_19) V(Node0_7_20) V(Node0_7_21) V(Node0_7_22) V(Node0_7_23) V(Node0_7_24) V(Node0_7_25) V(Node0_7_26) V(Node0_7_27) V(Node0_7_28) V(Node0_7_29) V(Node0_7_30) V(Node0_7_31) V(Node0_7_32) V(Node0_7_33) V(Node0_7_34) V(Node0_7_35) V(Node0_7_36) V(Node0_7_37) V(Node0_7_38) V(Node0_7_39) V(Node0_8_0) V(Node0_8_1) V(Node0_8_2) V(Node0_8_3) V(Node0_8_4) V(Node0_8_5) V(Node0_8_6) V(Node0_8_7) V(Node0_8_8) V(Node0_8_9) V(Node0_8_10) V(Node0_8_11) V(Node0_8_12) V(Node0_8_13) V(Node0_8_14) V(Node0_8_15) V(Node0_8_16) V(Node0_8_17) V(Node0_8_18) V(Node0_8_19) V(Node0_8_20) V(Node0_8_21) V(Node0_8_22) V(Node0_8_23) V(Node0_8_24) V(Node0_8_25) V(Node0_8_26) V(Node0_8_27) V(Node0_8_28) V(Node0_8_29) V(Node0_8_30) V(Node0_8_31) V(Node0_8_32) V(Node0_8_33) V(Node0_8_34) V(Node0_8_35) V(Node0_8_36) V(Node0_8_37) V(Node0_8_38) V(Node0_8_39) V(Node0_9_0) V(Node0_9_1) V(Node0_9_2) V(Node0_9_3) V(Node0_9_4) V(Node0_9_5) V(Node0_9_6) V(Node0_9_7) V(Node0_9_8) V(Node0_9_9) V(Node0_9_10) V(Node0_9_11) V(Node0_9_12) V(Node0_9_13) V(Node0_9_14) V(Node0_9_15) V(Node0_9_16) V(Node0_9_17) V(Node0_9_18) V(Node0_9_19) V(Node0_9_20) V(Node0_9_21) V(Node0_9_22) V(Node0_9_23) V(Node0_9_24) V(Node0_9_25) V(Node0_9_26) V(Node0_9_27) V(Node0_9_28) V(Node0_9_29) V(Node0_9_30) V(Node0_9_31) V(Node0_9_32) V(Node0_9_33) V(Node0_9_34) V(Node0_9_35) V(Node0_9_36) V(Node0_9_37) V(Node0_9_38) V(Node0_9_39) V(Node0_10_0) V(Node0_10_1) V(Node0_10_2) V(Node0_10_3) V(Node0_10_4) V(Node0_10_5) V(Node0_10_6) V(Node0_10_7) V(Node0_10_8) V(Node0_10_9) V(Node0_10_10) V(Node0_10_11) V(Node0_10_12) V(Node0_10_13) V(Node0_10_14) V(Node0_10_15) V(Node0_10_16) V(Node0_10_17) V(Node0_10_18) V(Node0_10_19) V(Node0_10_20) V(Node0_10_21) V(Node0_10_22) V(Node0_10_23) V(Node0_10_24) V(Node0_10_25) V(Node0_10_26) V(Node0_10_27) V(Node0_10_28) V(Node0_10_29) V(Node0_10_30) V(Node0_10_31) V(Node0_10_32) V(Node0_10_33) V(Node0_10_34) V(Node0_10_35) V(Node0_10_36) V(Node0_10_37) V(Node0_10_38) V(Node0_10_39) V(Node0_11_0) V(Node0_11_1) V(Node0_11_2) V(Node0_11_3) V(Node0_11_4) V(Node0_11_5) V(Node0_11_6) V(Node0_11_7) V(Node0_11_8) V(Node0_11_9) V(Node0_11_10) V(Node0_11_11) V(Node0_11_12) V(Node0_11_13) V(Node0_11_14) V(Node0_11_15) V(Node0_11_16) V(Node0_11_17) V(Node0_11_18) V(Node0_11_19) V(Node0_11_20) V(Node0_11_21) V(Node0_11_22) V(Node0_11_23) V(Node0_11_24) V(Node0_11_25) V(Node0_11_26) V(Node0_11_27) V(Node0_11_28) V(Node0_11_29) V(Node0_11_30) V(Node0_11_31) V(Node0_11_32) V(Node0_11_33) V(Node0_11_34) V(Node0_11_35) V(Node0_11_36) V(Node0_11_37) V(Node0_11_38) V(Node0_11_39) V(Node0_12_0) V(Node0_12_1) V(Node0_12_2) V(Node0_12_3) V(Node0_12_4) V(Node0_12_5) V(Node0_12_6) V(Node0_12_7) V(Node0_12_8) V(Node0_12_9) V(Node0_12_10) V(Node0_12_11) V(Node0_12_12) V(Node0_12_13) V(Node0_12_14) V(Node0_12_15) V(Node0_12_16) V(Node0_12_17) V(Node0_12_18) V(Node0_12_19) V(Node0_12_20) V(Node0_12_21) V(Node0_12_22) V(Node0_12_23) V(Node0_12_24) V(Node0_12_25) V(Node0_12_26) V(Node0_12_27) V(Node0_12_28) V(Node0_12_29) V(Node0_12_30) V(Node0_12_31) V(Node0_12_32) V(Node0_12_33) V(Node0_12_34) V(Node0_12_35) V(Node0_12_36) V(Node0_12_37) V(Node0_12_38) V(Node0_12_39) V(Node0_13_0) V(Node0_13_1) V(Node0_13_2) V(Node0_13_3) V(Node0_13_4) V(Node0_13_5) V(Node0_13_6) V(Node0_13_7) V(Node0_13_8) V(Node0_13_9) V(Node0_13_10) V(Node0_13_11) V(Node0_13_12) V(Node0_13_13) V(Node0_13_14) V(Node0_13_15) V(Node0_13_16) V(Node0_13_17) V(Node0_13_18) V(Node0_13_19) V(Node0_13_20) V(Node0_13_21) V(Node0_13_22) V(Node0_13_23) V(Node0_13_24) V(Node0_13_25) V(Node0_13_26) V(Node0_13_27) V(Node0_13_28) V(Node0_13_29) V(Node0_13_30) V(Node0_13_31) V(Node0_13_32) V(Node0_13_33) V(Node0_13_34) V(Node0_13_35) V(Node0_13_36) V(Node0_13_37) V(Node0_13_38) V(Node0_13_39) V(Node0_14_0) V(Node0_14_1) V(Node0_14_2) V(Node0_14_3) V(Node0_14_4) V(Node0_14_5) V(Node0_14_6) V(Node0_14_7) V(Node0_14_8) V(Node0_14_9) V(Node0_14_10) V(Node0_14_11) V(Node0_14_12) V(Node0_14_13) V(Node0_14_14) V(Node0_14_15) V(Node0_14_16) V(Node0_14_17) V(Node0_14_18) V(Node0_14_19) V(Node0_14_20) V(Node0_14_21) V(Node0_14_22) V(Node0_14_23) V(Node0_14_24) V(Node0_14_25) V(Node0_14_26) V(Node0_14_27) V(Node0_14_28) V(Node0_14_29) V(Node0_14_30) V(Node0_14_31) V(Node0_14_32) V(Node0_14_33) V(Node0_14_34) V(Node0_14_35) V(Node0_14_36) V(Node0_14_37) V(Node0_14_38) V(Node0_14_39) V(Node0_15_0) V(Node0_15_1) V(Node0_15_2) V(Node0_15_3) V(Node0_15_4) V(Node0_15_5) V(Node0_15_6) V(Node0_15_7) V(Node0_15_8) V(Node0_15_9) V(Node0_15_10) V(Node0_15_11) V(Node0_15_12) V(Node0_15_13) V(Node0_15_14) V(Node0_15_15) V(Node0_15_16) V(Node0_15_17) V(Node0_15_18) V(Node0_15_19) V(Node0_15_20) V(Node0_15_21) V(Node0_15_22) V(Node0_15_23) V(Node0_15_24) V(Node0_15_25) V(Node0_15_26) V(Node0_15_27) V(Node0_15_28) V(Node0_15_29) V(Node0_15_30) V(Node0_15_31) V(Node0_15_32) V(Node0_15_33) V(Node0_15_34) V(Node0_15_35) V(Node0_15_36) V(Node0_15_37) V(Node0_15_38) V(Node0_15_39) V(Node0_16_0) V(Node0_16_1) V(Node0_16_2) V(Node0_16_3) V(Node0_16_4) V(Node0_16_5) V(Node0_16_6) V(Node0_16_7) V(Node0_16_8) V(Node0_16_9) V(Node0_16_10) V(Node0_16_11) V(Node0_16_12) V(Node0_16_13) V(Node0_16_14) V(Node0_16_15) V(Node0_16_16) V(Node0_16_17) V(Node0_16_18) V(Node0_16_19) V(Node0_16_20) V(Node0_16_21) V(Node0_16_22) V(Node0_16_23) V(Node0_16_24) V(Node0_16_25) V(Node0_16_26) V(Node0_16_27) V(Node0_16_28) V(Node0_16_29) V(Node0_16_30) V(Node0_16_31) V(Node0_16_32) V(Node0_16_33) V(Node0_16_34) V(Node0_16_35) V(Node0_16_36) V(Node0_16_37) V(Node0_16_38) V(Node0_16_39) V(Node0_17_0) V(Node0_17_1) V(Node0_17_2) V(Node0_17_3) V(Node0_17_4) V(Node0_17_5) V(Node0_17_6) V(Node0_17_7) V(Node0_17_8) V(Node0_17_9) V(Node0_17_10) V(Node0_17_11) V(Node0_17_12) V(Node0_17_13) V(Node0_17_14) V(Node0_17_15) V(Node0_17_16) V(Node0_17_17) V(Node0_17_18) V(Node0_17_19) V(Node0_17_20) V(Node0_17_21) V(Node0_17_22) V(Node0_17_23) V(Node0_17_24) V(Node0_17_25) V(Node0_17_26) V(Node0_17_27) V(Node0_17_28) V(Node0_17_29) V(Node0_17_30) V(Node0_17_31) V(Node0_17_32) V(Node0_17_33) V(Node0_17_34) V(Node0_17_35) V(Node0_17_36) V(Node0_17_37) V(Node0_17_38) V(Node0_17_39) V(Node0_18_0) V(Node0_18_1) V(Node0_18_2) V(Node0_18_3) V(Node0_18_4) V(Node0_18_5) V(Node0_18_6) V(Node0_18_7) V(Node0_18_8) V(Node0_18_9) V(Node0_18_10) V(Node0_18_11) V(Node0_18_12) V(Node0_18_13) V(Node0_18_14) V(Node0_18_15) V(Node0_18_16) V(Node0_18_17) V(Node0_18_18) V(Node0_18_19) V(Node0_18_20) V(Node0_18_21) V(Node0_18_22) V(Node0_18_23) V(Node0_18_24) V(Node0_18_25) V(Node0_18_26) V(Node0_18_27) V(Node0_18_28) V(Node0_18_29) V(Node0_18_30) V(Node0_18_31) V(Node0_18_32) V(Node0_18_33) V(Node0_18_34) V(Node0_18_35) V(Node0_18_36) V(Node0_18_37) V(Node0_18_38) V(Node0_18_39) V(Node0_19_0) V(Node0_19_1) V(Node0_19_2) V(Node0_19_3) V(Node0_19_4) V(Node0_19_5) V(Node0_19_6) V(Node0_19_7) V(Node0_19_8) V(Node0_19_9) V(Node0_19_10) V(Node0_19_11) V(Node0_19_12) V(Node0_19_13) V(Node0_19_14) V(Node0_19_15) V(Node0_19_16) V(Node0_19_17) V(Node0_19_18) V(Node0_19_19) V(Node0_19_20) V(Node0_19_21) V(Node0_19_22) V(Node0_19_23) V(Node0_19_24) V(Node0_19_25) V(Node0_19_26) V(Node0_19_27) V(Node0_19_28) V(Node0_19_29) V(Node0_19_30) V(Node0_19_31) V(Node0_19_32) V(Node0_19_33) V(Node0_19_34) V(Node0_19_35) V(Node0_19_36) V(Node0_19_37) V(Node0_19_38) V(Node0_19_39) V(Node0_20_0) V(Node0_20_1) V(Node0_20_2) V(Node0_20_3) V(Node0_20_4) V(Node0_20_5) V(Node0_20_6) V(Node0_20_7) V(Node0_20_8) V(Node0_20_9) V(Node0_20_10) V(Node0_20_11) V(Node0_20_12) V(Node0_20_13) V(Node0_20_14) V(Node0_20_15) V(Node0_20_16) V(Node0_20_17) V(Node0_20_18) V(Node0_20_19) V(Node0_20_20) V(Node0_20_21) V(Node0_20_22) V(Node0_20_23) V(Node0_20_24) V(Node0_20_25) V(Node0_20_26) V(Node0_20_27) V(Node0_20_28) V(Node0_20_29) V(Node0_20_30) V(Node0_20_31) V(Node0_20_32) V(Node0_20_33) V(Node0_20_34) V(Node0_20_35) V(Node0_20_36) V(Node0_20_37) V(Node0_20_38) V(Node0_20_39) V(Node0_21_0) V(Node0_21_1) V(Node0_21_2) V(Node0_21_3) V(Node0_21_4) V(Node0_21_5) V(Node0_21_6) V(Node0_21_7) V(Node0_21_8) V(Node0_21_9) V(Node0_21_10) V(Node0_21_11) V(Node0_21_12) V(Node0_21_13) V(Node0_21_14) V(Node0_21_15) V(Node0_21_16) V(Node0_21_17) V(Node0_21_18) V(Node0_21_19) V(Node0_21_20) V(Node0_21_21) V(Node0_21_22) V(Node0_21_23) V(Node0_21_24) V(Node0_21_25) V(Node0_21_26) V(Node0_21_27) V(Node0_21_28) V(Node0_21_29) V(Node0_21_30) V(Node0_21_31) V(Node0_21_32) V(Node0_21_33) V(Node0_21_34) V(Node0_21_35) V(Node0_21_36) V(Node0_21_37) V(Node0_21_38) V(Node0_21_39) V(Node0_22_0) V(Node0_22_1) V(Node0_22_2) V(Node0_22_3) V(Node0_22_4) V(Node0_22_5) V(Node0_22_6) V(Node0_22_7) V(Node0_22_8) V(Node0_22_9) V(Node0_22_10) V(Node0_22_11) V(Node0_22_12) V(Node0_22_13) V(Node0_22_14) V(Node0_22_15) V(Node0_22_16) V(Node0_22_17) V(Node0_22_18) V(Node0_22_19) V(Node0_22_20) V(Node0_22_21) V(Node0_22_22) V(Node0_22_23) V(Node0_22_24) V(Node0_22_25) V(Node0_22_26) V(Node0_22_27) V(Node0_22_28) V(Node0_22_29) V(Node0_22_30) V(Node0_22_31) V(Node0_22_32) V(Node0_22_33) V(Node0_22_34) V(Node0_22_35) V(Node0_22_36) V(Node0_22_37) V(Node0_22_38) V(Node0_22_39) V(Node0_23_0) V(Node0_23_1) V(Node0_23_2) V(Node0_23_3) V(Node0_23_4) V(Node0_23_5) V(Node0_23_6) V(Node0_23_7) V(Node0_23_8) V(Node0_23_9) V(Node0_23_10) V(Node0_23_11) V(Node0_23_12) V(Node0_23_13) V(Node0_23_14) V(Node0_23_15) V(Node0_23_16) V(Node0_23_17) V(Node0_23_18) V(Node0_23_19) V(Node0_23_20) V(Node0_23_21) V(Node0_23_22) V(Node0_23_23) V(Node0_23_24) V(Node0_23_25) V(Node0_23_26) V(Node0_23_27) V(Node0_23_28) V(Node0_23_29) V(Node0_23_30) V(Node0_23_31) V(Node0_23_32) V(Node0_23_33) V(Node0_23_34) V(Node0_23_35) V(Node0_23_36) V(Node0_23_37) V(Node0_23_38) V(Node0_23_39) V(Node0_24_0) V(Node0_24_1) V(Node0_24_2) V(Node0_24_3) V(Node0_24_4) V(Node0_24_5) V(Node0_24_6) V(Node0_24_7) V(Node0_24_8) V(Node0_24_9) V(Node0_24_10) V(Node0_24_11) V(Node0_24_12) V(Node0_24_13) V(Node0_24_14) V(Node0_24_15) V(Node0_24_16) V(Node0_24_17) V(Node0_24_18) V(Node0_24_19) V(Node0_24_20) V(Node0_24_21) V(Node0_24_22) V(Node0_24_23) V(Node0_24_24) V(Node0_24_25) V(Node0_24_26) V(Node0_24_27) V(Node0_24_28) V(Node0_24_29) V(Node0_24_30) V(Node0_24_31) V(Node0_24_32) V(Node0_24_33) V(Node0_24_34) V(Node0_24_35) V(Node0_24_36) V(Node0_24_37) V(Node0_24_38) V(Node0_24_39) V(Node0_25_0) V(Node0_25_1) V(Node0_25_2) V(Node0_25_3) V(Node0_25_4) V(Node0_25_5) V(Node0_25_6) V(Node0_25_7) V(Node0_25_8) V(Node0_25_9) V(Node0_25_10) V(Node0_25_11) V(Node0_25_12) V(Node0_25_13) V(Node0_25_14) V(Node0_25_15) V(Node0_25_16) V(Node0_25_17) V(Node0_25_18) V(Node0_25_19) V(Node0_25_20) V(Node0_25_21) V(Node0_25_22) V(Node0_25_23) V(Node0_25_24) V(Node0_25_25) V(Node0_25_26) V(Node0_25_27) V(Node0_25_28) V(Node0_25_29) V(Node0_25_30) V(Node0_25_31) V(Node0_25_32) V(Node0_25_33) V(Node0_25_34) V(Node0_25_35) V(Node0_25_36) V(Node0_25_37) V(Node0_25_38) V(Node0_25_39) V(Node0_26_0) V(Node0_26_1) V(Node0_26_2) V(Node0_26_3) V(Node0_26_4) V(Node0_26_5) V(Node0_26_6) V(Node0_26_7) V(Node0_26_8) V(Node0_26_9) V(Node0_26_10) V(Node0_26_11) V(Node0_26_12) V(Node0_26_13) V(Node0_26_14) V(Node0_26_15) V(Node0_26_16) V(Node0_26_17) V(Node0_26_18) V(Node0_26_19) V(Node0_26_20) V(Node0_26_21) V(Node0_26_22) V(Node0_26_23) V(Node0_26_24) V(Node0_26_25) V(Node0_26_26) V(Node0_26_27) V(Node0_26_28) V(Node0_26_29) V(Node0_26_30) V(Node0_26_31) V(Node0_26_32) V(Node0_26_33) V(Node0_26_34) V(Node0_26_35) V(Node0_26_36) V(Node0_26_37) V(Node0_26_38) V(Node0_26_39) V(Node0_27_0) V(Node0_27_1) V(Node0_27_2) V(Node0_27_3) V(Node0_27_4) V(Node0_27_5) V(Node0_27_6) V(Node0_27_7) V(Node0_27_8) V(Node0_27_9) V(Node0_27_10) V(Node0_27_11) V(Node0_27_12) V(Node0_27_13) V(Node0_27_14) V(Node0_27_15) V(Node0_27_16) V(Node0_27_17) V(Node0_27_18) V(Node0_27_19) V(Node0_27_20) V(Node0_27_21) V(Node0_27_22) V(Node0_27_23) V(Node0_27_24) V(Node0_27_25) V(Node0_27_26) V(Node0_27_27) V(Node0_27_28) V(Node0_27_29) V(Node0_27_30) V(Node0_27_31) V(Node0_27_32) V(Node0_27_33) V(Node0_27_34) V(Node0_27_35) V(Node0_27_36) V(Node0_27_37) V(Node0_27_38) V(Node0_27_39) V(Node0_28_0) V(Node0_28_1) V(Node0_28_2) V(Node0_28_3) V(Node0_28_4) V(Node0_28_5) V(Node0_28_6) V(Node0_28_7) V(Node0_28_8) V(Node0_28_9) V(Node0_28_10) V(Node0_28_11) V(Node0_28_12) V(Node0_28_13) V(Node0_28_14) V(Node0_28_15) V(Node0_28_16) V(Node0_28_17) V(Node0_28_18) V(Node0_28_19) V(Node0_28_20) V(Node0_28_21) V(Node0_28_22) V(Node0_28_23) V(Node0_28_24) V(Node0_28_25) V(Node0_28_26) V(Node0_28_27) V(Node0_28_28) V(Node0_28_29) V(Node0_28_30) V(Node0_28_31) V(Node0_28_32) V(Node0_28_33) V(Node0_28_34) V(Node0_28_35) V(Node0_28_36) V(Node0_28_37) V(Node0_28_38) V(Node0_28_39) V(Node0_29_0) V(Node0_29_1) V(Node0_29_2) V(Node0_29_3) V(Node0_29_4) V(Node0_29_5) V(Node0_29_6) V(Node0_29_7) V(Node0_29_8) V(Node0_29_9) V(Node0_29_10) V(Node0_29_11) V(Node0_29_12) V(Node0_29_13) V(Node0_29_14) V(Node0_29_15) V(Node0_29_16) V(Node0_29_17) V(Node0_29_18) V(Node0_29_19) V(Node0_29_20) V(Node0_29_21) V(Node0_29_22) V(Node0_29_23) V(Node0_29_24) V(Node0_29_25) V(Node0_29_26) V(Node0_29_27) V(Node0_29_28) V(Node0_29_29) V(Node0_29_30) V(Node0_29_31) V(Node0_29_32) V(Node0_29_33) V(Node0_29_34) V(Node0_29_35) V(Node0_29_36) V(Node0_29_37) V(Node0_29_38) V(Node0_29_39) V(Node0_30_0) V(Node0_30_1) V(Node0_30_2) V(Node0_30_3) V(Node0_30_4) V(Node0_30_5) V(Node0_30_6) V(Node0_30_7) V(Node0_30_8) V(Node0_30_9) V(Node0_30_10) V(Node0_30_11) V(Node0_30_12) V(Node0_30_13) V(Node0_30_14) V(Node0_30_15) V(Node0_30_16) V(Node0_30_17) V(Node0_30_18) V(Node0_30_19) V(Node0_30_20) V(Node0_30_21) V(Node0_30_22) V(Node0_30_23) V(Node0_30_24) V(Node0_30_25) V(Node0_30_26) V(Node0_30_27) V(Node0_30_28) V(Node0_30_29) V(Node0_30_30) V(Node0_30_31) V(Node0_30_32) V(Node0_30_33) V(Node0_30_34) V(Node0_30_35) V(Node0_30_36) V(Node0_30_37) V(Node0_30_38) V(Node0_30_39) V(Node0_31_0) V(Node0_31_1) V(Node0_31_2) V(Node0_31_3) V(Node0_31_4) V(Node0_31_5) V(Node0_31_6) V(Node0_31_7) V(Node0_31_8) V(Node0_31_9) V(Node0_31_10) V(Node0_31_11) V(Node0_31_12) V(Node0_31_13) V(Node0_31_14) V(Node0_31_15) V(Node0_31_16) V(Node0_31_17) V(Node0_31_18) V(Node0_31_19) V(Node0_31_20) V(Node0_31_21) V(Node0_31_22) V(Node0_31_23) V(Node0_31_24) V(Node0_31_25) V(Node0_31_26) V(Node0_31_27) V(Node0_31_28) V(Node0_31_29) V(Node0_31_30) V(Node0_31_31) V(Node0_31_32) V(Node0_31_33) V(Node0_31_34) V(Node0_31_35) V(Node0_31_36) V(Node0_31_37) V(Node0_31_38) V(Node0_31_39) V(Node0_32_0) V(Node0_32_1) V(Node0_32_2) V(Node0_32_3) V(Node0_32_4) V(Node0_32_5) V(Node0_32_6) V(Node0_32_7) V(Node0_32_8) V(Node0_32_9) V(Node0_32_10) V(Node0_32_11) V(Node0_32_12) V(Node0_32_13) V(Node0_32_14) V(Node0_32_15) V(Node0_32_16) V(Node0_32_17) V(Node0_32_18) V(Node0_32_19) V(Node0_32_20) V(Node0_32_21) V(Node0_32_22) V(Node0_32_23) V(Node0_32_24) V(Node0_32_25) V(Node0_32_26) V(Node0_32_27) V(Node0_32_28) V(Node0_32_29) V(Node0_32_30) V(Node0_32_31) V(Node0_32_32) V(Node0_32_33) V(Node0_32_34) V(Node0_32_35) V(Node0_32_36) V(Node0_32_37) V(Node0_32_38) V(Node0_32_39) V(Node0_33_0) V(Node0_33_1) V(Node0_33_2) V(Node0_33_3) V(Node0_33_4) V(Node0_33_5) V(Node0_33_6) V(Node0_33_7) V(Node0_33_8) V(Node0_33_9) V(Node0_33_10) V(Node0_33_11) V(Node0_33_12) V(Node0_33_13) V(Node0_33_14) V(Node0_33_15) V(Node0_33_16) V(Node0_33_17) V(Node0_33_18) V(Node0_33_19) V(Node0_33_20) V(Node0_33_21) V(Node0_33_22) V(Node0_33_23) V(Node0_33_24) V(Node0_33_25) V(Node0_33_26) V(Node0_33_27) V(Node0_33_28) V(Node0_33_29) V(Node0_33_30) V(Node0_33_31) V(Node0_33_32) V(Node0_33_33) V(Node0_33_34) V(Node0_33_35) V(Node0_33_36) V(Node0_33_37) V(Node0_33_38) V(Node0_33_39) V(Node0_34_0) V(Node0_34_1) V(Node0_34_2) V(Node0_34_3) V(Node0_34_4) V(Node0_34_5) V(Node0_34_6) V(Node0_34_7) V(Node0_34_8) V(Node0_34_9) V(Node0_34_10) V(Node0_34_11) V(Node0_34_12) V(Node0_34_13) V(Node0_34_14) V(Node0_34_15) V(Node0_34_16) V(Node0_34_17) V(Node0_34_18) V(Node0_34_19) V(Node0_34_20) V(Node0_34_21) V(Node0_34_22) V(Node0_34_23) V(Node0_34_24) V(Node0_34_25) V(Node0_34_26) V(Node0_34_27) V(Node0_34_28) V(Node0_34_29) V(Node0_34_30) V(Node0_34_31) V(Node0_34_32) V(Node0_34_33) V(Node0_34_34) V(Node0_34_35) V(Node0_34_36) V(Node0_34_37) V(Node0_34_38) V(Node0_34_39) V(Node0_35_0) V(Node0_35_1) V(Node0_35_2) V(Node0_35_3) V(Node0_35_4) V(Node0_35_5) V(Node0_35_6) V(Node0_35_7) V(Node0_35_8) V(Node0_35_9) V(Node0_35_10) V(Node0_35_11) V(Node0_35_12) V(Node0_35_13) V(Node0_35_14) V(Node0_35_15) V(Node0_35_16) V(Node0_35_17) V(Node0_35_18) V(Node0_35_19) V(Node0_35_20) V(Node0_35_21) V(Node0_35_22) V(Node0_35_23) V(Node0_35_24) V(Node0_35_25) V(Node0_35_26) V(Node0_35_27) V(Node0_35_28) V(Node0_35_29) V(Node0_35_30) V(Node0_35_31) V(Node0_35_32) V(Node0_35_33) V(Node0_35_34) V(Node0_35_35) V(Node0_35_36) V(Node0_35_37) V(Node0_35_38) V(Node0_35_39) V(Node0_36_0) V(Node0_36_1) V(Node0_36_2) V(Node0_36_3) V(Node0_36_4) V(Node0_36_5) V(Node0_36_6) V(Node0_36_7) V(Node0_36_8) V(Node0_36_9) V(Node0_36_10) V(Node0_36_11) V(Node0_36_12) V(Node0_36_13) V(Node0_36_14) V(Node0_36_15) V(Node0_36_16) V(Node0_36_17) V(Node0_36_18) V(Node0_36_19) V(Node0_36_20) V(Node0_36_21) V(Node0_36_22) V(Node0_36_23) V(Node0_36_24) V(Node0_36_25) V(Node0_36_26) V(Node0_36_27) V(Node0_36_28) V(Node0_36_29) V(Node0_36_30) V(Node0_36_31) V(Node0_36_32) V(Node0_36_33) V(Node0_36_34) V(Node0_36_35) V(Node0_36_36) V(Node0_36_37) V(Node0_36_38) V(Node0_36_39) V(Node0_37_0) V(Node0_37_1) V(Node0_37_2) V(Node0_37_3) V(Node0_37_4) V(Node0_37_5) V(Node0_37_6) V(Node0_37_7) V(Node0_37_8) V(Node0_37_9) V(Node0_37_10) V(Node0_37_11) V(Node0_37_12) V(Node0_37_13) V(Node0_37_14) V(Node0_37_15) V(Node0_37_16) V(Node0_37_17) V(Node0_37_18) V(Node0_37_19) V(Node0_37_20) V(Node0_37_21) V(Node0_37_22) V(Node0_37_23) V(Node0_37_24) V(Node0_37_25) V(Node0_37_26) V(Node0_37_27) V(Node0_37_28) V(Node0_37_29) V(Node0_37_30) V(Node0_37_31) V(Node0_37_32) V(Node0_37_33) V(Node0_37_34) V(Node0_37_35) V(Node0_37_36) V(Node0_37_37) V(Node0_37_38) V(Node0_37_39) V(Node0_38_0) V(Node0_38_1) V(Node0_38_2) V(Node0_38_3) V(Node0_38_4) V(Node0_38_5) V(Node0_38_6) V(Node0_38_7) V(Node0_38_8) V(Node0_38_9) V(Node0_38_10) V(Node0_38_11) V(Node0_38_12) V(Node0_38_13) V(Node0_38_14) V(Node0_38_15) V(Node0_38_16) V(Node0_38_17) V(Node0_38_18) V(Node0_38_19) V(Node0_38_20) V(Node0_38_21) V(Node0_38_22) V(Node0_38_23) V(Node0_38_24) V(Node0_38_25) V(Node0_38_26) V(Node0_38_27) V(Node0_38_28) V(Node0_38_29) V(Node0_38_30) V(Node0_38_31) V(Node0_38_32) V(Node0_38_33) V(Node0_38_34) V(Node0_38_35) V(Node0_38_36) V(Node0_38_37) V(Node0_38_38) V(Node0_38_39) V(Node0_39_0) V(Node0_39_1) V(Node0_39_2) V(Node0_39_3) V(Node0_39_4) V(Node0_39_5) V(Node0_39_6) V(Node0_39_7) V(Node0_39_8) V(Node0_39_9) V(Node0_39_10) V(Node0_39_11) V(Node0_39_12) V(Node0_39_13) V(Node0_39_14) V(Node0_39_15) V(Node0_39_16) V(Node0_39_17) V(Node0_39_18) V(Node0_39_19) V(Node0_39_20) V(Node0_39_21) V(Node0_39_22) V(Node0_39_23) V(Node0_39_24) V(Node0_39_25) V(Node0_39_26) V(Node0_39_27) V(Node0_39_28) V(Node0_39_29) V(Node0_39_30) V(Node0_39_31) V(Node0_39_32) V(Node0_39_33) V(Node0_39_34) V(Node0_39_35) V(Node0_39_36) V(Node0_39_37) V(Node0_39_38) V(Node0_39_39) V(Node1_0_0) V(Node1_0_1) V(Node1_0_2) V(Node1_0_3) V(Node1_0_4) V(Node1_0_5) V(Node1_0_6) V(Node1_0_7) V(Node1_0_8) V(Node1_0_9) V(Node1_0_10) V(Node1_0_11) V(Node1_0_12) V(Node1_0_13) V(Node1_0_14) V(Node1_0_15) V(Node1_0_16) V(Node1_0_17) V(Node1_0_18) V(Node1_0_19) V(Node1_0_20) V(Node1_0_21) V(Node1_0_22) V(Node1_0_23) V(Node1_0_24) V(Node1_0_25) V(Node1_0_26) V(Node1_0_27) V(Node1_0_28) V(Node1_0_29) V(Node1_0_30) V(Node1_0_31) V(Node1_0_32) V(Node1_0_33) V(Node1_0_34) V(Node1_0_35) V(Node1_0_36) V(Node1_0_37) V(Node1_0_38) V(Node1_0_39) V(Node1_1_0) V(Node1_1_1) V(Node1_1_2) V(Node1_1_3) V(Node1_1_4) V(Node1_1_5) V(Node1_1_6) V(Node1_1_7) V(Node1_1_8) V(Node1_1_9) V(Node1_1_10) V(Node1_1_11) V(Node1_1_12) V(Node1_1_13) V(Node1_1_14) V(Node1_1_15) V(Node1_1_16) V(Node1_1_17) V(Node1_1_18) V(Node1_1_19) V(Node1_1_20) V(Node1_1_21) V(Node1_1_22) V(Node1_1_23) V(Node1_1_24) V(Node1_1_25) V(Node1_1_26) V(Node1_1_27) V(Node1_1_28) V(Node1_1_29) V(Node1_1_30) V(Node1_1_31) V(Node1_1_32) V(Node1_1_33) V(Node1_1_34) V(Node1_1_35) V(Node1_1_36) V(Node1_1_37) V(Node1_1_38) V(Node1_1_39) V(Node1_2_0) V(Node1_2_1) V(Node1_2_2) V(Node1_2_3) V(Node1_2_4) V(Node1_2_5) V(Node1_2_6) V(Node1_2_7) V(Node1_2_8) V(Node1_2_9) V(Node1_2_10) V(Node1_2_11) V(Node1_2_12) V(Node1_2_13) V(Node1_2_14) V(Node1_2_15) V(Node1_2_16) V(Node1_2_17) V(Node1_2_18) V(Node1_2_19) V(Node1_2_20) V(Node1_2_21) V(Node1_2_22) V(Node1_2_23) V(Node1_2_24) V(Node1_2_25) V(Node1_2_26) V(Node1_2_27) V(Node1_2_28) V(Node1_2_29) V(Node1_2_30) V(Node1_2_31) V(Node1_2_32) V(Node1_2_33) V(Node1_2_34) V(Node1_2_35) V(Node1_2_36) V(Node1_2_37) V(Node1_2_38) V(Node1_2_39) V(Node1_3_0) V(Node1_3_1) V(Node1_3_2) V(Node1_3_3) V(Node1_3_4) V(Node1_3_5) V(Node1_3_6) V(Node1_3_7) V(Node1_3_8) V(Node1_3_9) V(Node1_3_10) V(Node1_3_11) V(Node1_3_12) V(Node1_3_13) V(Node1_3_14) V(Node1_3_15) V(Node1_3_16) V(Node1_3_17) V(Node1_3_18) V(Node1_3_19) V(Node1_3_20) V(Node1_3_21) V(Node1_3_22) V(Node1_3_23) V(Node1_3_24) V(Node1_3_25) V(Node1_3_26) V(Node1_3_27) V(Node1_3_28) V(Node1_3_29) V(Node1_3_30) V(Node1_3_31) V(Node1_3_32) V(Node1_3_33) V(Node1_3_34) V(Node1_3_35) V(Node1_3_36) V(Node1_3_37) V(Node1_3_38) V(Node1_3_39) V(Node1_4_0) V(Node1_4_1) V(Node1_4_2) V(Node1_4_3) V(Node1_4_4) V(Node1_4_5) V(Node1_4_6) V(Node1_4_7) V(Node1_4_8) V(Node1_4_9) V(Node1_4_10) V(Node1_4_11) V(Node1_4_12) V(Node1_4_13) V(Node1_4_14) V(Node1_4_15) V(Node1_4_16) V(Node1_4_17) V(Node1_4_18) V(Node1_4_19) V(Node1_4_20) V(Node1_4_21) V(Node1_4_22) V(Node1_4_23) V(Node1_4_24) V(Node1_4_25) V(Node1_4_26) V(Node1_4_27) V(Node1_4_28) V(Node1_4_29) V(Node1_4_30) V(Node1_4_31) V(Node1_4_32) V(Node1_4_33) V(Node1_4_34) V(Node1_4_35) V(Node1_4_36) V(Node1_4_37) V(Node1_4_38) V(Node1_4_39) V(Node1_5_0) V(Node1_5_1) V(Node1_5_2) V(Node1_5_3) V(Node1_5_4) V(Node1_5_5) V(Node1_5_6) V(Node1_5_7) V(Node1_5_8) V(Node1_5_9) V(Node1_5_10) V(Node1_5_11) V(Node1_5_12) V(Node1_5_13) V(Node1_5_14) V(Node1_5_15) V(Node1_5_16) V(Node1_5_17) V(Node1_5_18) V(Node1_5_19) V(Node1_5_20) V(Node1_5_21) V(Node1_5_22) V(Node1_5_23) V(Node1_5_24) V(Node1_5_25) V(Node1_5_26) V(Node1_5_27) V(Node1_5_28) V(Node1_5_29) V(Node1_5_30) V(Node1_5_31) V(Node1_5_32) V(Node1_5_33) V(Node1_5_34) V(Node1_5_35) V(Node1_5_36) V(Node1_5_37) V(Node1_5_38) V(Node1_5_39) V(Node1_6_0) V(Node1_6_1) V(Node1_6_2) V(Node1_6_3) V(Node1_6_4) V(Node1_6_5) V(Node1_6_6) V(Node1_6_7) V(Node1_6_8) V(Node1_6_9) V(Node1_6_10) V(Node1_6_11) V(Node1_6_12) V(Node1_6_13) V(Node1_6_14) V(Node1_6_15) V(Node1_6_16) V(Node1_6_17) V(Node1_6_18) V(Node1_6_19) V(Node1_6_20) V(Node1_6_21) V(Node1_6_22) V(Node1_6_23) V(Node1_6_24) V(Node1_6_25) V(Node1_6_26) V(Node1_6_27) V(Node1_6_28) V(Node1_6_29) V(Node1_6_30) V(Node1_6_31) V(Node1_6_32) V(Node1_6_33) V(Node1_6_34) V(Node1_6_35) V(Node1_6_36) V(Node1_6_37) V(Node1_6_38) V(Node1_6_39) V(Node1_7_0) V(Node1_7_1) V(Node1_7_2) V(Node1_7_3) V(Node1_7_4) V(Node1_7_5) V(Node1_7_6) V(Node1_7_7) V(Node1_7_8) V(Node1_7_9) V(Node1_7_10) V(Node1_7_11) V(Node1_7_12) V(Node1_7_13) V(Node1_7_14) V(Node1_7_15) V(Node1_7_16) V(Node1_7_17) V(Node1_7_18) V(Node1_7_19) V(Node1_7_20) V(Node1_7_21) V(Node1_7_22) V(Node1_7_23) V(Node1_7_24) V(Node1_7_25) V(Node1_7_26) V(Node1_7_27) V(Node1_7_28) V(Node1_7_29) V(Node1_7_30) V(Node1_7_31) V(Node1_7_32) V(Node1_7_33) V(Node1_7_34) V(Node1_7_35) V(Node1_7_36) V(Node1_7_37) V(Node1_7_38) V(Node1_7_39) V(Node1_8_0) V(Node1_8_1) V(Node1_8_2) V(Node1_8_3) V(Node1_8_4) V(Node1_8_5) V(Node1_8_6) V(Node1_8_7) V(Node1_8_8) V(Node1_8_9) V(Node1_8_10) V(Node1_8_11) V(Node1_8_12) V(Node1_8_13) V(Node1_8_14) V(Node1_8_15) V(Node1_8_16) V(Node1_8_17) V(Node1_8_18) V(Node1_8_19) V(Node1_8_20) V(Node1_8_21) V(Node1_8_22) V(Node1_8_23) V(Node1_8_24) V(Node1_8_25) V(Node1_8_26) V(Node1_8_27) V(Node1_8_28) V(Node1_8_29) V(Node1_8_30) V(Node1_8_31) V(Node1_8_32) V(Node1_8_33) V(Node1_8_34) V(Node1_8_35) V(Node1_8_36) V(Node1_8_37) V(Node1_8_38) V(Node1_8_39) V(Node1_9_0) V(Node1_9_1) V(Node1_9_2) V(Node1_9_3) V(Node1_9_4) V(Node1_9_5) V(Node1_9_6) V(Node1_9_7) V(Node1_9_8) V(Node1_9_9) V(Node1_9_10) V(Node1_9_11) V(Node1_9_12) V(Node1_9_13) V(Node1_9_14) V(Node1_9_15) V(Node1_9_16) V(Node1_9_17) V(Node1_9_18) V(Node1_9_19) V(Node1_9_20) V(Node1_9_21) V(Node1_9_22) V(Node1_9_23) V(Node1_9_24) V(Node1_9_25) V(Node1_9_26) V(Node1_9_27) V(Node1_9_28) V(Node1_9_29) V(Node1_9_30) V(Node1_9_31) V(Node1_9_32) V(Node1_9_33) V(Node1_9_34) V(Node1_9_35) V(Node1_9_36) V(Node1_9_37) V(Node1_9_38) V(Node1_9_39) V(Node1_10_0) V(Node1_10_1) V(Node1_10_2) V(Node1_10_3) V(Node1_10_4) V(Node1_10_5) V(Node1_10_6) V(Node1_10_7) V(Node1_10_8) V(Node1_10_9) V(Node1_10_10) V(Node1_10_11) V(Node1_10_12) V(Node1_10_13) V(Node1_10_14) V(Node1_10_15) V(Node1_10_16) V(Node1_10_17) V(Node1_10_18) V(Node1_10_19) V(Node1_10_20) V(Node1_10_21) V(Node1_10_22) V(Node1_10_23) V(Node1_10_24) V(Node1_10_25) V(Node1_10_26) V(Node1_10_27) V(Node1_10_28) V(Node1_10_29) V(Node1_10_30) V(Node1_10_31) V(Node1_10_32) V(Node1_10_33) V(Node1_10_34) V(Node1_10_35) V(Node1_10_36) V(Node1_10_37) V(Node1_10_38) V(Node1_10_39) V(Node1_11_0) V(Node1_11_1) V(Node1_11_2) V(Node1_11_3) V(Node1_11_4) V(Node1_11_5) V(Node1_11_6) V(Node1_11_7) V(Node1_11_8) V(Node1_11_9) V(Node1_11_10) V(Node1_11_11) V(Node1_11_12) V(Node1_11_13) V(Node1_11_14) V(Node1_11_15) V(Node1_11_16) V(Node1_11_17) V(Node1_11_18) V(Node1_11_19) V(Node1_11_20) V(Node1_11_21) V(Node1_11_22) V(Node1_11_23) V(Node1_11_24) V(Node1_11_25) V(Node1_11_26) V(Node1_11_27) V(Node1_11_28) V(Node1_11_29) V(Node1_11_30) V(Node1_11_31) V(Node1_11_32) V(Node1_11_33) V(Node1_11_34) V(Node1_11_35) V(Node1_11_36) V(Node1_11_37) V(Node1_11_38) V(Node1_11_39) V(Node1_12_0) V(Node1_12_1) V(Node1_12_2) V(Node1_12_3) V(Node1_12_4) V(Node1_12_5) V(Node1_12_6) V(Node1_12_7) V(Node1_12_8) V(Node1_12_9) V(Node1_12_10) V(Node1_12_11) V(Node1_12_12) V(Node1_12_13) V(Node1_12_14) V(Node1_12_15) V(Node1_12_16) V(Node1_12_17) V(Node1_12_18) V(Node1_12_19) V(Node1_12_20) V(Node1_12_21) V(Node1_12_22) V(Node1_12_23) V(Node1_12_24) V(Node1_12_25) V(Node1_12_26) V(Node1_12_27) V(Node1_12_28) V(Node1_12_29) V(Node1_12_30) V(Node1_12_31) V(Node1_12_32) V(Node1_12_33) V(Node1_12_34) V(Node1_12_35) V(Node1_12_36) V(Node1_12_37) V(Node1_12_38) V(Node1_12_39) V(Node1_13_0) V(Node1_13_1) V(Node1_13_2) V(Node1_13_3) V(Node1_13_4) V(Node1_13_5) V(Node1_13_6) V(Node1_13_7) V(Node1_13_8) V(Node1_13_9) V(Node1_13_10) V(Node1_13_11) V(Node1_13_12) V(Node1_13_13) V(Node1_13_14) V(Node1_13_15) V(Node1_13_16) V(Node1_13_17) V(Node1_13_18) V(Node1_13_19) V(Node1_13_20) V(Node1_13_21) V(Node1_13_22) V(Node1_13_23) V(Node1_13_24) V(Node1_13_25) V(Node1_13_26) V(Node1_13_27) V(Node1_13_28) V(Node1_13_29) V(Node1_13_30) V(Node1_13_31) V(Node1_13_32) V(Node1_13_33) V(Node1_13_34) V(Node1_13_35) V(Node1_13_36) V(Node1_13_37) V(Node1_13_38) V(Node1_13_39) V(Node1_14_0) V(Node1_14_1) V(Node1_14_2) V(Node1_14_3) V(Node1_14_4) V(Node1_14_5) V(Node1_14_6) V(Node1_14_7) V(Node1_14_8) V(Node1_14_9) V(Node1_14_10) V(Node1_14_11) V(Node1_14_12) V(Node1_14_13) V(Node1_14_14) V(Node1_14_15) V(Node1_14_16) V(Node1_14_17) V(Node1_14_18) V(Node1_14_19) V(Node1_14_20) V(Node1_14_21) V(Node1_14_22) V(Node1_14_23) V(Node1_14_24) V(Node1_14_25) V(Node1_14_26) V(Node1_14_27) V(Node1_14_28) V(Node1_14_29) V(Node1_14_30) V(Node1_14_31) V(Node1_14_32) V(Node1_14_33) V(Node1_14_34) V(Node1_14_35) V(Node1_14_36) V(Node1_14_37) V(Node1_14_38) V(Node1_14_39) V(Node1_15_0) V(Node1_15_1) V(Node1_15_2) V(Node1_15_3) V(Node1_15_4) V(Node1_15_5) V(Node1_15_6) V(Node1_15_7) V(Node1_15_8) V(Node1_15_9) V(Node1_15_10) V(Node1_15_11) V(Node1_15_12) V(Node1_15_13) V(Node1_15_14) V(Node1_15_15) V(Node1_15_16) V(Node1_15_17) V(Node1_15_18) V(Node1_15_19) V(Node1_15_20) V(Node1_15_21) V(Node1_15_22) V(Node1_15_23) V(Node1_15_24) V(Node1_15_25) V(Node1_15_26) V(Node1_15_27) V(Node1_15_28) V(Node1_15_29) V(Node1_15_30) V(Node1_15_31) V(Node1_15_32) V(Node1_15_33) V(Node1_15_34) V(Node1_15_35) V(Node1_15_36) V(Node1_15_37) V(Node1_15_38) V(Node1_15_39) V(Node1_16_0) V(Node1_16_1) V(Node1_16_2) V(Node1_16_3) V(Node1_16_4) V(Node1_16_5) V(Node1_16_6) V(Node1_16_7) V(Node1_16_8) V(Node1_16_9) V(Node1_16_10) V(Node1_16_11) V(Node1_16_12) V(Node1_16_13) V(Node1_16_14) V(Node1_16_15) V(Node1_16_16) V(Node1_16_17) V(Node1_16_18) V(Node1_16_19) V(Node1_16_20) V(Node1_16_21) V(Node1_16_22) V(Node1_16_23) V(Node1_16_24) V(Node1_16_25) V(Node1_16_26) V(Node1_16_27) V(Node1_16_28) V(Node1_16_29) V(Node1_16_30) V(Node1_16_31) V(Node1_16_32) V(Node1_16_33) V(Node1_16_34) V(Node1_16_35) V(Node1_16_36) V(Node1_16_37) V(Node1_16_38) V(Node1_16_39) V(Node1_17_0) V(Node1_17_1) V(Node1_17_2) V(Node1_17_3) V(Node1_17_4) V(Node1_17_5) V(Node1_17_6) V(Node1_17_7) V(Node1_17_8) V(Node1_17_9) V(Node1_17_10) V(Node1_17_11) V(Node1_17_12) V(Node1_17_13) V(Node1_17_14) V(Node1_17_15) V(Node1_17_16) V(Node1_17_17) V(Node1_17_18) V(Node1_17_19) V(Node1_17_20) V(Node1_17_21) V(Node1_17_22) V(Node1_17_23) V(Node1_17_24) V(Node1_17_25) V(Node1_17_26) V(Node1_17_27) V(Node1_17_28) V(Node1_17_29) V(Node1_17_30) V(Node1_17_31) V(Node1_17_32) V(Node1_17_33) V(Node1_17_34) V(Node1_17_35) V(Node1_17_36) V(Node1_17_37) V(Node1_17_38) V(Node1_17_39) V(Node1_18_0) V(Node1_18_1) V(Node1_18_2) V(Node1_18_3) V(Node1_18_4) V(Node1_18_5) V(Node1_18_6) V(Node1_18_7) V(Node1_18_8) V(Node1_18_9) V(Node1_18_10) V(Node1_18_11) V(Node1_18_12) V(Node1_18_13) V(Node1_18_14) V(Node1_18_15) V(Node1_18_16) V(Node1_18_17) V(Node1_18_18) V(Node1_18_19) V(Node1_18_20) V(Node1_18_21) V(Node1_18_22) V(Node1_18_23) V(Node1_18_24) V(Node1_18_25) V(Node1_18_26) V(Node1_18_27) V(Node1_18_28) V(Node1_18_29) V(Node1_18_30) V(Node1_18_31) V(Node1_18_32) V(Node1_18_33) V(Node1_18_34) V(Node1_18_35) V(Node1_18_36) V(Node1_18_37) V(Node1_18_38) V(Node1_18_39) V(Node1_19_0) V(Node1_19_1) V(Node1_19_2) V(Node1_19_3) V(Node1_19_4) V(Node1_19_5) V(Node1_19_6) V(Node1_19_7) V(Node1_19_8) V(Node1_19_9) V(Node1_19_10) V(Node1_19_11) V(Node1_19_12) V(Node1_19_13) V(Node1_19_14) V(Node1_19_15) V(Node1_19_16) V(Node1_19_17) V(Node1_19_18) V(Node1_19_19) V(Node1_19_20) V(Node1_19_21) V(Node1_19_22) V(Node1_19_23) V(Node1_19_24) V(Node1_19_25) V(Node1_19_26) V(Node1_19_27) V(Node1_19_28) V(Node1_19_29) V(Node1_19_30) V(Node1_19_31) V(Node1_19_32) V(Node1_19_33) V(Node1_19_34) V(Node1_19_35) V(Node1_19_36) V(Node1_19_37) V(Node1_19_38) V(Node1_19_39) V(Node1_20_0) V(Node1_20_1) V(Node1_20_2) V(Node1_20_3) V(Node1_20_4) V(Node1_20_5) V(Node1_20_6) V(Node1_20_7) V(Node1_20_8) V(Node1_20_9) V(Node1_20_10) V(Node1_20_11) V(Node1_20_12) V(Node1_20_13) V(Node1_20_14) V(Node1_20_15) V(Node1_20_16) V(Node1_20_17) V(Node1_20_18) V(Node1_20_19) V(Node1_20_20) V(Node1_20_21) V(Node1_20_22) V(Node1_20_23) V(Node1_20_24) V(Node1_20_25) V(Node1_20_26) V(Node1_20_27) V(Node1_20_28) V(Node1_20_29) V(Node1_20_30) V(Node1_20_31) V(Node1_20_32) V(Node1_20_33) V(Node1_20_34) V(Node1_20_35) V(Node1_20_36) V(Node1_20_37) V(Node1_20_38) V(Node1_20_39) V(Node1_21_0) V(Node1_21_1) V(Node1_21_2) V(Node1_21_3) V(Node1_21_4) V(Node1_21_5) V(Node1_21_6) V(Node1_21_7) V(Node1_21_8) V(Node1_21_9) V(Node1_21_10) V(Node1_21_11) V(Node1_21_12) V(Node1_21_13) V(Node1_21_14) V(Node1_21_15) V(Node1_21_16) V(Node1_21_17) V(Node1_21_18) V(Node1_21_19) V(Node1_21_20) V(Node1_21_21) V(Node1_21_22) V(Node1_21_23) V(Node1_21_24) V(Node1_21_25) V(Node1_21_26) V(Node1_21_27) V(Node1_21_28) V(Node1_21_29) V(Node1_21_30) V(Node1_21_31) V(Node1_21_32) V(Node1_21_33) V(Node1_21_34) V(Node1_21_35) V(Node1_21_36) V(Node1_21_37) V(Node1_21_38) V(Node1_21_39) V(Node1_22_0) V(Node1_22_1) V(Node1_22_2) V(Node1_22_3) V(Node1_22_4) V(Node1_22_5) V(Node1_22_6) V(Node1_22_7) V(Node1_22_8) V(Node1_22_9) V(Node1_22_10) V(Node1_22_11) V(Node1_22_12) V(Node1_22_13) V(Node1_22_14) V(Node1_22_15) V(Node1_22_16) V(Node1_22_17) V(Node1_22_18) V(Node1_22_19) V(Node1_22_20) V(Node1_22_21) V(Node1_22_22) V(Node1_22_23) V(Node1_22_24) V(Node1_22_25) V(Node1_22_26) V(Node1_22_27) V(Node1_22_28) V(Node1_22_29) V(Node1_22_30) V(Node1_22_31) V(Node1_22_32) V(Node1_22_33) V(Node1_22_34) V(Node1_22_35) V(Node1_22_36) V(Node1_22_37) V(Node1_22_38) V(Node1_22_39) V(Node1_23_0) V(Node1_23_1) V(Node1_23_2) V(Node1_23_3) V(Node1_23_4) V(Node1_23_5) V(Node1_23_6) V(Node1_23_7) V(Node1_23_8) V(Node1_23_9) V(Node1_23_10) V(Node1_23_11) V(Node1_23_12) V(Node1_23_13) V(Node1_23_14) V(Node1_23_15) V(Node1_23_16) V(Node1_23_17) V(Node1_23_18) V(Node1_23_19) V(Node1_23_20) V(Node1_23_21) V(Node1_23_22) V(Node1_23_23) V(Node1_23_24) V(Node1_23_25) V(Node1_23_26) V(Node1_23_27) V(Node1_23_28) V(Node1_23_29) V(Node1_23_30) V(Node1_23_31) V(Node1_23_32) V(Node1_23_33) V(Node1_23_34) V(Node1_23_35) V(Node1_23_36) V(Node1_23_37) V(Node1_23_38) V(Node1_23_39) V(Node1_24_0) V(Node1_24_1) V(Node1_24_2) V(Node1_24_3) V(Node1_24_4) V(Node1_24_5) V(Node1_24_6) V(Node1_24_7) V(Node1_24_8) V(Node1_24_9) V(Node1_24_10) V(Node1_24_11) V(Node1_24_12) V(Node1_24_13) V(Node1_24_14) V(Node1_24_15) V(Node1_24_16) V(Node1_24_17) V(Node1_24_18) V(Node1_24_19) V(Node1_24_20) V(Node1_24_21) V(Node1_24_22) V(Node1_24_23) V(Node1_24_24) V(Node1_24_25) V(Node1_24_26) V(Node1_24_27) V(Node1_24_28) V(Node1_24_29) V(Node1_24_30) V(Node1_24_31) V(Node1_24_32) V(Node1_24_33) V(Node1_24_34) V(Node1_24_35) V(Node1_24_36) V(Node1_24_37) V(Node1_24_38) V(Node1_24_39) V(Node1_25_0) V(Node1_25_1) V(Node1_25_2) V(Node1_25_3) V(Node1_25_4) V(Node1_25_5) V(Node1_25_6) V(Node1_25_7) V(Node1_25_8) V(Node1_25_9) V(Node1_25_10) V(Node1_25_11) V(Node1_25_12) V(Node1_25_13) V(Node1_25_14) V(Node1_25_15) V(Node1_25_16) V(Node1_25_17) V(Node1_25_18) V(Node1_25_19) V(Node1_25_20) V(Node1_25_21) V(Node1_25_22) V(Node1_25_23) V(Node1_25_24) V(Node1_25_25) V(Node1_25_26) V(Node1_25_27) V(Node1_25_28) V(Node1_25_29) V(Node1_25_30) V(Node1_25_31) V(Node1_25_32) V(Node1_25_33) V(Node1_25_34) V(Node1_25_35) V(Node1_25_36) V(Node1_25_37) V(Node1_25_38) V(Node1_25_39) V(Node1_26_0) V(Node1_26_1) V(Node1_26_2) V(Node1_26_3) V(Node1_26_4) V(Node1_26_5) V(Node1_26_6) V(Node1_26_7) V(Node1_26_8) V(Node1_26_9) V(Node1_26_10) V(Node1_26_11) V(Node1_26_12) V(Node1_26_13) V(Node1_26_14) V(Node1_26_15) V(Node1_26_16) V(Node1_26_17) V(Node1_26_18) V(Node1_26_19) V(Node1_26_20) V(Node1_26_21) V(Node1_26_22) V(Node1_26_23) V(Node1_26_24) V(Node1_26_25) V(Node1_26_26) V(Node1_26_27) V(Node1_26_28) V(Node1_26_29) V(Node1_26_30) V(Node1_26_31) V(Node1_26_32) V(Node1_26_33) V(Node1_26_34) V(Node1_26_35) V(Node1_26_36) V(Node1_26_37) V(Node1_26_38) V(Node1_26_39) V(Node1_27_0) V(Node1_27_1) V(Node1_27_2) V(Node1_27_3) V(Node1_27_4) V(Node1_27_5) V(Node1_27_6) V(Node1_27_7) V(Node1_27_8) V(Node1_27_9) V(Node1_27_10) V(Node1_27_11) V(Node1_27_12) V(Node1_27_13) V(Node1_27_14) V(Node1_27_15) V(Node1_27_16) V(Node1_27_17) V(Node1_27_18) V(Node1_27_19) V(Node1_27_20) V(Node1_27_21) V(Node1_27_22) V(Node1_27_23) V(Node1_27_24) V(Node1_27_25) V(Node1_27_26) V(Node1_27_27) V(Node1_27_28) V(Node1_27_29) V(Node1_27_30) V(Node1_27_31) V(Node1_27_32) V(Node1_27_33) V(Node1_27_34) V(Node1_27_35) V(Node1_27_36) V(Node1_27_37) V(Node1_27_38) V(Node1_27_39) V(Node1_28_0) V(Node1_28_1) V(Node1_28_2) V(Node1_28_3) V(Node1_28_4) V(Node1_28_5) V(Node1_28_6) V(Node1_28_7) V(Node1_28_8) V(Node1_28_9) V(Node1_28_10) V(Node1_28_11) V(Node1_28_12) V(Node1_28_13) V(Node1_28_14) V(Node1_28_15) V(Node1_28_16) V(Node1_28_17) V(Node1_28_18) V(Node1_28_19) V(Node1_28_20) V(Node1_28_21) V(Node1_28_22) V(Node1_28_23) V(Node1_28_24) V(Node1_28_25) V(Node1_28_26) V(Node1_28_27) V(Node1_28_28) V(Node1_28_29) V(Node1_28_30) V(Node1_28_31) V(Node1_28_32) V(Node1_28_33) V(Node1_28_34) V(Node1_28_35) V(Node1_28_36) V(Node1_28_37) V(Node1_28_38) V(Node1_28_39) V(Node1_29_0) V(Node1_29_1) V(Node1_29_2) V(Node1_29_3) V(Node1_29_4) V(Node1_29_5) V(Node1_29_6) V(Node1_29_7) V(Node1_29_8) V(Node1_29_9) V(Node1_29_10) V(Node1_29_11) V(Node1_29_12) V(Node1_29_13) V(Node1_29_14) V(Node1_29_15) V(Node1_29_16) V(Node1_29_17) V(Node1_29_18) V(Node1_29_19) V(Node1_29_20) V(Node1_29_21) V(Node1_29_22) V(Node1_29_23) V(Node1_29_24) V(Node1_29_25) V(Node1_29_26) V(Node1_29_27) V(Node1_29_28) V(Node1_29_29) V(Node1_29_30) V(Node1_29_31) V(Node1_29_32) V(Node1_29_33) V(Node1_29_34) V(Node1_29_35) V(Node1_29_36) V(Node1_29_37) V(Node1_29_38) V(Node1_29_39) V(Node1_30_0) V(Node1_30_1) V(Node1_30_2) V(Node1_30_3) V(Node1_30_4) V(Node1_30_5) V(Node1_30_6) V(Node1_30_7) V(Node1_30_8) V(Node1_30_9) V(Node1_30_10) V(Node1_30_11) V(Node1_30_12) V(Node1_30_13) V(Node1_30_14) V(Node1_30_15) V(Node1_30_16) V(Node1_30_17) V(Node1_30_18) V(Node1_30_19) V(Node1_30_20) V(Node1_30_21) V(Node1_30_22) V(Node1_30_23) V(Node1_30_24) V(Node1_30_25) V(Node1_30_26) V(Node1_30_27) V(Node1_30_28) V(Node1_30_29) V(Node1_30_30) V(Node1_30_31) V(Node1_30_32) V(Node1_30_33) V(Node1_30_34) V(Node1_30_35) V(Node1_30_36) V(Node1_30_37) V(Node1_30_38) V(Node1_30_39) V(Node1_31_0) V(Node1_31_1) V(Node1_31_2) V(Node1_31_3) V(Node1_31_4) V(Node1_31_5) V(Node1_31_6) V(Node1_31_7) V(Node1_31_8) V(Node1_31_9) V(Node1_31_10) V(Node1_31_11) V(Node1_31_12) V(Node1_31_13) V(Node1_31_14) V(Node1_31_15) V(Node1_31_16) V(Node1_31_17) V(Node1_31_18) V(Node1_31_19) V(Node1_31_20) V(Node1_31_21) V(Node1_31_22) V(Node1_31_23) V(Node1_31_24) V(Node1_31_25) V(Node1_31_26) V(Node1_31_27) V(Node1_31_28) V(Node1_31_29) V(Node1_31_30) V(Node1_31_31) V(Node1_31_32) V(Node1_31_33) V(Node1_31_34) V(Node1_31_35) V(Node1_31_36) V(Node1_31_37) V(Node1_31_38) V(Node1_31_39) V(Node1_32_0) V(Node1_32_1) V(Node1_32_2) V(Node1_32_3) V(Node1_32_4) V(Node1_32_5) V(Node1_32_6) V(Node1_32_7) V(Node1_32_8) V(Node1_32_9) V(Node1_32_10) V(Node1_32_11) V(Node1_32_12) V(Node1_32_13) V(Node1_32_14) V(Node1_32_15) V(Node1_32_16) V(Node1_32_17) V(Node1_32_18) V(Node1_32_19) V(Node1_32_20) V(Node1_32_21) V(Node1_32_22) V(Node1_32_23) V(Node1_32_24) V(Node1_32_25) V(Node1_32_26) V(Node1_32_27) V(Node1_32_28) V(Node1_32_29) V(Node1_32_30) V(Node1_32_31) V(Node1_32_32) V(Node1_32_33) V(Node1_32_34) V(Node1_32_35) V(Node1_32_36) V(Node1_32_37) V(Node1_32_38) V(Node1_32_39) V(Node1_33_0) V(Node1_33_1) V(Node1_33_2) V(Node1_33_3) V(Node1_33_4) V(Node1_33_5) V(Node1_33_6) V(Node1_33_7) V(Node1_33_8) V(Node1_33_9) V(Node1_33_10) V(Node1_33_11) V(Node1_33_12) V(Node1_33_13) V(Node1_33_14) V(Node1_33_15) V(Node1_33_16) V(Node1_33_17) V(Node1_33_18) V(Node1_33_19) V(Node1_33_20) V(Node1_33_21) V(Node1_33_22) V(Node1_33_23) V(Node1_33_24) V(Node1_33_25) V(Node1_33_26) V(Node1_33_27) V(Node1_33_28) V(Node1_33_29) V(Node1_33_30) V(Node1_33_31) V(Node1_33_32) V(Node1_33_33) V(Node1_33_34) V(Node1_33_35) V(Node1_33_36) V(Node1_33_37) V(Node1_33_38) V(Node1_33_39) V(Node1_34_0) V(Node1_34_1) V(Node1_34_2) V(Node1_34_3) V(Node1_34_4) V(Node1_34_5) V(Node1_34_6) V(Node1_34_7) V(Node1_34_8) V(Node1_34_9) V(Node1_34_10) V(Node1_34_11) V(Node1_34_12) V(Node1_34_13) V(Node1_34_14) V(Node1_34_15) V(Node1_34_16) V(Node1_34_17) V(Node1_34_18) V(Node1_34_19) V(Node1_34_20) V(Node1_34_21) V(Node1_34_22) V(Node1_34_23) V(Node1_34_24) V(Node1_34_25) V(Node1_34_26) V(Node1_34_27) V(Node1_34_28) V(Node1_34_29) V(Node1_34_30) V(Node1_34_31) V(Node1_34_32) V(Node1_34_33) V(Node1_34_34) V(Node1_34_35) V(Node1_34_36) V(Node1_34_37) V(Node1_34_38) V(Node1_34_39) V(Node1_35_0) V(Node1_35_1) V(Node1_35_2) V(Node1_35_3) V(Node1_35_4) V(Node1_35_5) V(Node1_35_6) V(Node1_35_7) V(Node1_35_8) V(Node1_35_9) V(Node1_35_10) V(Node1_35_11) V(Node1_35_12) V(Node1_35_13) V(Node1_35_14) V(Node1_35_15) V(Node1_35_16) V(Node1_35_17) V(Node1_35_18) V(Node1_35_19) V(Node1_35_20) V(Node1_35_21) V(Node1_35_22) V(Node1_35_23) V(Node1_35_24) V(Node1_35_25) V(Node1_35_26) V(Node1_35_27) V(Node1_35_28) V(Node1_35_29) V(Node1_35_30) V(Node1_35_31) V(Node1_35_32) V(Node1_35_33) V(Node1_35_34) V(Node1_35_35) V(Node1_35_36) V(Node1_35_37) V(Node1_35_38) V(Node1_35_39) V(Node1_36_0) V(Node1_36_1) V(Node1_36_2) V(Node1_36_3) V(Node1_36_4) V(Node1_36_5) V(Node1_36_6) V(Node1_36_7) V(Node1_36_8) V(Node1_36_9) V(Node1_36_10) V(Node1_36_11) V(Node1_36_12) V(Node1_36_13) V(Node1_36_14) V(Node1_36_15) V(Node1_36_16) V(Node1_36_17) V(Node1_36_18) V(Node1_36_19) V(Node1_36_20) V(Node1_36_21) V(Node1_36_22) V(Node1_36_23) V(Node1_36_24) V(Node1_36_25) V(Node1_36_26) V(Node1_36_27) V(Node1_36_28) V(Node1_36_29) V(Node1_36_30) V(Node1_36_31) V(Node1_36_32) V(Node1_36_33) V(Node1_36_34) V(Node1_36_35) V(Node1_36_36) V(Node1_36_37) V(Node1_36_38) V(Node1_36_39) V(Node1_37_0) V(Node1_37_1) V(Node1_37_2) V(Node1_37_3) V(Node1_37_4) V(Node1_37_5) V(Node1_37_6) V(Node1_37_7) V(Node1_37_8) V(Node1_37_9) V(Node1_37_10) V(Node1_37_11) V(Node1_37_12) V(Node1_37_13) V(Node1_37_14) V(Node1_37_15) V(Node1_37_16) V(Node1_37_17) V(Node1_37_18) V(Node1_37_19) V(Node1_37_20) V(Node1_37_21) V(Node1_37_22) V(Node1_37_23) V(Node1_37_24) V(Node1_37_25) V(Node1_37_26) V(Node1_37_27) V(Node1_37_28) V(Node1_37_29) V(Node1_37_30) V(Node1_37_31) V(Node1_37_32) V(Node1_37_33) V(Node1_37_34) V(Node1_37_35) V(Node1_37_36) V(Node1_37_37) V(Node1_37_38) V(Node1_37_39) V(Node1_38_0) V(Node1_38_1) V(Node1_38_2) V(Node1_38_3) V(Node1_38_4) V(Node1_38_5) V(Node1_38_6) V(Node1_38_7) V(Node1_38_8) V(Node1_38_9) V(Node1_38_10) V(Node1_38_11) V(Node1_38_12) V(Node1_38_13) V(Node1_38_14) V(Node1_38_15) V(Node1_38_16) V(Node1_38_17) V(Node1_38_18) V(Node1_38_19) V(Node1_38_20) V(Node1_38_21) V(Node1_38_22) V(Node1_38_23) V(Node1_38_24) V(Node1_38_25) V(Node1_38_26) V(Node1_38_27) V(Node1_38_28) V(Node1_38_29) V(Node1_38_30) V(Node1_38_31) V(Node1_38_32) V(Node1_38_33) V(Node1_38_34) V(Node1_38_35) V(Node1_38_36) V(Node1_38_37) V(Node1_38_38) V(Node1_38_39) V(Node1_39_0) V(Node1_39_1) V(Node1_39_2) V(Node1_39_3) V(Node1_39_4) V(Node1_39_5) V(Node1_39_6) V(Node1_39_7) V(Node1_39_8) V(Node1_39_9) V(Node1_39_10) V(Node1_39_11) V(Node1_39_12) V(Node1_39_13) V(Node1_39_14) V(Node1_39_15) V(Node1_39_16) V(Node1_39_17) V(Node1_39_18) V(Node1_39_19) V(Node1_39_20) V(Node1_39_21) V(Node1_39_22) V(Node1_39_23) V(Node1_39_24) V(Node1_39_25) V(Node1_39_26) V(Node1_39_27) V(Node1_39_28) V(Node1_39_29) V(Node1_39_30) V(Node1_39_31) V(Node1_39_32) V(Node1_39_33) V(Node1_39_34) V(Node1_39_35) V(Node1_39_36) V(Node1_39_37) V(Node1_39_38) V(Node1_39_39)
.SAVE TYPE=IC
.end
